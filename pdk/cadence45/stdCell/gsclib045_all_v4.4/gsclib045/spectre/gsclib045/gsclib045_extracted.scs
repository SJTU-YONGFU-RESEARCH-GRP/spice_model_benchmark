C7 (CKbb VSS) capacitor c=2.91459e-17
C8 (Eint VSS) capacitor c=4.46864e-17
C9 (15 VSS) capacitor c=1.79092e-18
C10 (ECKb VSS) capacitor c=8.85108e-16
C11 (16 VSS) capacitor c=1.79092e-18
C12 (17 VSS) capacitor c=5.28058e-18
C13 (18 VSS) capacitor c=4.59784e-18
C14 (19 VSS) capacitor c=1.7265e-18
C15 (net217 VSS) capacitor c=2.32223e-18
C16 (net205 VSS) capacitor c=1.66895e-18
C17 (\6\:CKb VSS) capacitor c=2.56735e-17
C18 (\3\:Eint VSS) capacitor c=8.74259e-17
C19 (\3\:CKb VSS) capacitor c=7.15045e-17
C20 (\3\:CKbb VSS) capacitor c=7.43776e-17
C21 (\1\:E VSS) capacitor c=3.3811e-17
C22 (\1\:CK VSS) capacitor c=3.14359e-17
C23 (\21\:Eint VSS) capacitor c=7.69237e-17
C24 (\16\:CKbb VSS) capacitor c=4.53611e-17
C25 (\17\:CKbb VSS) capacitor c=2.38909e-17
C26 (\15\:Eint VSS) capacitor c=2.41556e-17
C27 (\16\:Eint VSS) capacitor c=2.36746e-17
C28 (\11\:CKbb VSS) capacitor c=2.27483e-17
C29 (\10\:CKbb VSS) capacitor c=4.44265e-17
C30 (\4\:Eint VSS) capacitor c=6.07172e-17
C31 (\8\:Eint VSS) capacitor c=5.65695e-17
C32 (\4\:CKbb VSS) capacitor c=5.4298e-17
C33 (\5\:CKb VSS) capacitor c=4.65642e-17
C34 (\3\:E VSS) capacitor c=9.16092e-17
C35 (\3\:CK VSS) capacitor c=5.51469e-17
C36 (\5\:CKbb VSS) capacitor c=7.83061e-16
C37 (\7\:CKb VSS) capacitor c=2.38322e-17
C38 (\2\:Eint VSS) capacitor c=8.18318e-17
C39 (\2\:CKbb VSS) capacitor c=7.36988e-17
C40 (\4\:CKb VSS) capacitor c=3.14201e-17
C41 (\2\:CKb VSS) capacitor c=4.59838e-17
C42 (\2\:E VSS) capacitor c=6.29799e-17
C43 (\2\:CK VSS) capacitor c=5.20933e-17
C44 (\68\:ECKb VSS) capacitor c=5.98708e-16
C45 (\26\:CKbb VSS) capacitor c=4.82413e-17
C46 (\28\:Eint VSS) capacitor c=1.36884e-16
C47 (\12\:n0 VSS) capacitor c=4.02546e-17
C48 (\60\:VDD VSS) capacitor c=4.67146e-17
C49 (\15\:CKb VSS) capacitor c=7.93938e-17
C50 (\1\:VDD VSS) capacitor c=1.39506e-15
C51 (\77\:ECKb VSS) capacitor c=1.03527e-16
C52 (\85\:ECKb VSS) capacitor c=1.54857e-16
C53 (\87\:ECKb VSS) capacitor c=7.8392e-17
C54 (\23\:CKbb VSS) capacitor c=7.12734e-17
C55 (\26\:Eint VSS) capacitor c=5.71336e-17
C56 (\10\:n0 VSS) capacitor c=6.0951e-17
C57 (\12\:CKb VSS) capacitor c=1.96536e-17
C58 (\5\:Eint VSS) capacitor c=8.49733e-16
C59 (\12\:Eint VSS) capacitor c=2.36057e-17
C60 (\13\:Eint VSS) capacitor c=1.84915e-17
C61 (\4\:E VSS) capacitor c=1.00365e-16
C62 (\8\:n0 VSS) capacitor c=4.53961e-17
C63 (\9\:n0 VSS) capacitor c=8.91754e-17
C64 (\8\:CKb VSS) capacitor c=9.38235e-17
C65 (\9\:CKb VSS) capacitor c=1.33729e-16
C66 (\10\:CKb VSS) capacitor c=1.55078e-16
C67 (\11\:CKb VSS) capacitor c=1.05832e-16
C68 (\14\:CKb VSS) capacitor c=1.96338e-17
C69 (\22\:CKbb VSS) capacitor c=3.07536e-17
C70 (\25\:CKbb VSS) capacitor c=1.12393e-16
C71 (\30\:Eint VSS) capacitor c=5.17921e-17
C72 (\71\:ECKb VSS) capacitor c=9.18116e-17
C73 (\23\:VDD VSS) capacitor c=8.04885e-17
C74 (\26\:VDD VSS) capacitor c=2.03304e-18
Rk1 (\4\:CK CK) resistor r=0.01805 c=0
Rk92 (\1\:VDD \23\:VDD) resistor r=0.2204 c=0
Rk94 (\23\:VDD \25\:VDD) resistor r=0.2055 c=0
Rk95 (\25\:VDD \26\:VDD) resistor r=0.183 c=0
Rk97 (\27\:VDD VDD) resistor r=0.04993 c=0
Rk96 (\26\:VDD \27\:VDD) resistor r=0.1177 c=0
Rk114 (\26\:VDD \61\:VDD) resistor r=0.285 c=0
Rk4 (\4\:E E) resistor r=0.03911 c=0
Rk127 (\1\:VSS \15\:VSS) resistor r=0.2407 c=0
Rk128 (\15\:VSS \16\:VSS) resistor r=0.3609 c=0
Rk129 (\16\:VSS \17\:VSS) resistor r=0.4302 c=0
Rk132 (\17\:VSS \20\:VSS) resistor r=0.4227 c=0
Rk134 (\21\:VSS VSS) resistor r=0.04993 c=0
Rk133 (\20\:VSS \21\:VSS) resistor r=0.1127 c=0
Rk144 (\15\:VSS \41\:VSS) resistor r=0.2541 c=0
Rk145 (\16\:VSS \43\:VSS) resistor r=0.2541 c=0
Rk148 (\20\:VSS \49\:VSS) resistor r=0.1776 c=0
Rk8 (\8\:CKb \9\:CKb) resistor r=0.6959 c=0
Rk9 (\9\:CKb \10\:CKb) resistor r=0.7369 c=0
Rk10 (\10\:CKb \11\:CKb) resistor r=0.4567 c=0
Rk11 (\11\:CKb \13\:CKb) resistor r=0.09782 c=0
Rk12 (\9\:CKb \14\:CKb) resistor r=0.03511 c=0
Rk13 (\11\:CKb \16\:CKb) resistor r=0.6805 c=0
Rk5 (\8\:n0 \9\:n0) resistor r=0.3307 c=0
Rk6 (\9\:n0 \11\:n0) resistor r=0.392 c=0
Rk7 (\9\:n0 \13\:n0) resistor r=0.2538 c=0
Rk16 (\5\:CKbb \22\:CKbb) resistor r=0.3006 c=0
Rk17 (\22\:CKbb \24\:CKbb) resistor r=0.1182 c=0
Rk18 (\24\:CKbb \25\:CKbb) resistor r=0.7789 c=0
Rk19 (\22\:CKbb \27\:CKbb) resistor r=0.1619 c=0
Rk22 (\5\:Eint \25\:Eint) resistor r=1.0003 c=0
Rk23 (\25\:Eint \27\:Eint) resistor r=0.2408 c=0
Rk24 (\25\:Eint \29\:Eint) resistor r=0.03277 c=0
Rk25 (\27\:Eint \30\:Eint) resistor r=0.2633 c=0
Rk27 (\68\:ECKb \71\:ECKb) resistor r=0.3866 c=0
Rk32 (\71\:ECKb \78\:ECKb) resistor r=0.3928 c=0
Rk36 (\78\:ECKb \86\:ECKb) resistor r=0.7162 c=0
Rk37 (\86\:ECKb \88\:ECKb) resistor r=0.4711 c=0
Rl1 (\1\:CK \2\:CK) resistor r=24.2328 c=0
Rl2 (\2\:CK \3\:CK) resistor r=231.925 c=0
Rl3 (\1\:E \2\:E) resistor r=35.7134 c=0
Rl4 (\2\:E \3\:E) resistor r=216.483 c=0
Rl17 (\5\:CKb \6\:CKb) resistor r=94.0778 c=0
Rl18 (\6\:CKb \7\:CKb) resistor r=50.6918 c=0
Rl6 (\3\:CKb \4\:CKb) resistor r=29.5379 c=0
Rl5 (CKb \2\:CKb) resistor r=93.4636 c=0
Rl42 (\5\:CKbb \16\:CKbb) resistor r=28.0797 c=0
Rl43 (\5\:CKbb \17\:CKbb) resistor r=31.8361 c=0
Rl29 (\5\:CKbb \11\:CKbb) resistor r=30.0028 c=0
Rl28 (\5\:CKbb \10\:CKbb) resistor r=29.579 c=0
Rl19 (\5\:CKbb \4\:CKbb) resistor r=28.6412 c=0
Rl7 (\2\:CKbb CKbb) resistor r=29.5379 c=0
Rl8 (\2\:CKbb \3\:CKbb) resistor r=279.104 c=0
Rl9 (\2\:Eint Eint) resistor r=70.3288 c=0
Rl10 (\2\:Eint \3\:Eint) resistor r=194.129 c=0
Rl46 (\5\:Eint \21\:Eint) resistor r=90.1797 c=0
Rl21 (\5\:Eint \4\:Eint) resistor r=124.51 c=0
Rl24 (\5\:Eint \8\:Eint) resistor r=94.6154 c=0
Rl35 (\12\:Eint \15\:Eint) resistor r=28.0797 c=0
Rl32 (\12\:Eint \5\:Eint) resistor r=91.3489 c=0
Rl36 (\13\:Eint \16\:Eint) resistor r=25.0634 c=0
Rl34 (\13\:Eint \5\:Eint) resistor r=27.8457 c=0
Rl33 (\13\:Eint \12\:Eint) resistor r=102.268 c=0
Rz24 (\25\:VDD \1\:VDD) resistor r=18.75 c=0
Rz25 (\27\:VDD \1\:VDD) resistor r=37.5 c=0
Rz35 (\41\:VSS \40\:VSS) resistor r=75 c=0
Rz36 (\43\:VSS \42\:VSS) resistor r=75 c=0
Rz39 (\49\:VSS \48\:VSS) resistor r=75 c=0
Rz2 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz1 (\11\:n0 \10\:n0) resistor r=75 c=0
Rz3 (\24\:CKbb \23\:CKbb) resistor r=75 c=0
Rz4 (\27\:Eint \26\:Eint) resistor r=75 c=0
Rz5 (\78\:ECKb \77\:ECKb) resistor r=75 c=0
Rz6 (\86\:ECKb \85\:ECKb) resistor r=75 c=0
Rz7 (\88\:ECKb \87\:ECKb) resistor r=75 c=0
Ry35 (\61\:VDD \60\:VDD) resistor r=62 c=0
Ry40 (\17\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry41 (\21\:VSS \1\:VSS) resistor r=31 c=0
Ry2 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry1 (\13\:n0 \12\:n0) resistor r=62 c=0
Ry3 (\27\:CKbb \26\:CKbb) resistor r=62 c=0
Ry4 (\29\:Eint \28\:Eint) resistor r=62 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\2\:E \4\:E) resistor r=45 c=0
Rx4 (\7\:CKb \8\:CKb) resistor r=45 c=0
Rx5 (\2\:CKb \10\:CKb) resistor r=45 c=0
Rx6 (\4\:CKb \14\:CKb) resistor r=45 c=0
Rx3 (\8\:n0 n0) resistor r=45 c=0
Rx10 (\25\:CKbb \2\:CKbb) resistor r=45 c=0
Rx14 (\30\:Eint \2\:Eint) resistor r=45 c=0
Rx15 (\71\:ECKb ECKb) resistor r=45 c=0
mn0 (\12\:CKb \3\:CK \48\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.85e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn5 (net254 \3\:E \48\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.8e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn6 (\10\:n0 CKb net254 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.132e-14 ps=4.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=6.75e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn16 (\10\:n0 CKbb net230 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.885e-14 ad=4.132e-14 ps=5.5e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=3.45e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn15 (net230 Eint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.99e-14 ad=1.885e-14 ps=1.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.55e-07 sb=1.7e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn10 (\26\:Eint n0 \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.987e-14 ad=4.16e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=5.06058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn1 (\23\:CKbb \5\:CKb \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.985e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21_1__rcx (\87\:ECKb \4\:CKbb 15 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.198 scb=0.0131159 \
        scc=0.000803647 m=(1)
mn20_1__rcx (15 \8\:Eint \42\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=13.198 scb=0.0131159 \
        scc=0.000803647 m=(1)
mn20_2__rcx (16 \4\:Eint \42\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=13.198 scb=0.0131159 \
        scc=0.000803647 m=(1)
mn21_2__rcx (\85\:ECKb \10\:CKbb 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2e-06 sd=160n sca=13.198 scb=0.0131159 \
        scc=0.000803647 m=(1)
mn21_3__rcx (\85\:ECKb \11\:CKbb 17 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=2e-06 sd=160n sca=13.198 scb=0.0131159 \
        scc=0.000803647 m=(1)
mn20_3__rcx (17 \16\:Eint \40\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.93e-14 ad=4.16e-14 ps=1.13e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=2e-06 sd=160n sca=13.198 scb=0.0131159 \
        scc=0.000803647 m=(1)
mn20 (18 \15\:Eint \40\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=4.16e-14 ps=1.13e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.315e-06 sb=2e-06 sd=160n sca=13.198 scb=0.0131159 \
        scc=0.000803647 m=(1)
mn21 (\77\:ECKb \17\:CKbb 18 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52e-06 sb=2e-06 sd=160n sca=13.198 scb=0.0131159 \
        scc=0.000803647 m=(1)
mn21_4__rcx (\77\:ECKb \16\:CKbb 19 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.725e-06 sb=2e-06 sd=160n sca=13.198 scb=0.0131159 \
        scc=0.000803647 m=(1)
mn20_4__rcx (19 \21\:Eint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.91e-14 ad=1.56e-14 ps=1.03e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83e-06 sb=2e-06 sd=160n sca=13.198 scb=0.0131159 \
        scc=0.000803647 m=(1)
mn22_1__rcx (ECK ECKb \1\:VSS VSS) g45n1svt w=(3.05e-07) l=4.5e-08 nf=1 \
        as=4.941e-14 ad=4.916e-14 ps=9.3588e-07 pd=9.3235e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71967e-06 sb=2e-06 sd=160n sca=16.121 \
        scb=0.0155296 scc=0.00139557 m=(17)
mp5 (net217 \1\:E \60\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.408e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.12256e-06 sd=160n sca=13.2059 \
        scb=0.0110334 scc=0.000224619 m=(1)
mp6 (\12\:n0 \3\:CKbb net217 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=3.44e-14 ps=8.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=8.72558e-07 sd=160n sca=11.7941 \
        scb=0.00968423 scc=0.000220689 m=(1)
mp16 (\12\:n0 \3\:CKb net205 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=3.44e-14 ps=5.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=6.67558e-07 sd=160n sca=11.3578 \
        scb=0.0095436 scc=0.000220652 m=(1)
mp15 (net205 \3\:Eint \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.72e-14 ad=1.505e-14 ps=1.64e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=5.52558e-07 sd=160n sca=11.3578 \
        scb=0.0095436 scc=0.000220652 m=(1)
mp10 (\28\:Eint n0 \23\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0252e-13 ad=6.24e-14 ps=1.77e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.84615e-07 sb=5.04551e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp1 (\26\:CKbb \6\:CKb \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.1785e-13 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp21_1__rcx (\68\:ECKb \5\:CKbb \1\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=5.868e-14 ad=6.24e-14 ps=1.092e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.12308e-07 sb=2e-06 sd=160n \
        sca=13.5671 scb=0.012183 scc=0.000647513 m=(5)
mp20_1__rcx (\68\:ECKb \5\:Eint \1\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=8.642e-14 ad=6.24e-14 ps=1.244e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.17308e-07 sb=2e-06 sd=160n \
        sca=13.5671 scb=0.012183 scc=0.000647513 m=(5)
mp22_1__rcx (ECK ECKb \1\:VDD VDD) g45p1svt w=(4.6e-07) l=4.5e-08 nf=1 \
        as=7.332e-14 ad=7.36e-14 ps=1.24e-06 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.71087e-06 sb=2e-06 sd=160n sca=18.2478 \
        scb=0.0152569 scc=0.00157133 m=(16)
mp22_16__rcx (ECK ECKb \1\:VDD VDD) g45p1svt w=(4.55e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=6.37e-14 ps=1.24e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=25.0172 scb=0.024999 \
        scc=0.0018514 m=(1)
ends TLATNCAX20
// End of subcircuit definition.

// Generated for: spectre (May  9 18:22:40 2012 )
// Library name: gsclib045
// Cell name: TLATNCAX3
// View name: extracted

simulator lang=spectre

subckt TLATNCAX3 CK E ECK VDD VSS
mp0 (\14\:CKb \1\:CK \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=54.8038 \
        scb=0.0416044 scc=0.00645165 m=(1)
C1 (CK VSS) capacitor c=5.30492e-17
C2 (ECK VSS) capacitor c=2.8627e-17
C3 (E VSS) capacitor c=7.13425e-17
C4 (VDD VSS) capacitor c=1.73326e-16
C5 (CKb VSS) capacitor c=3.53393e-17
C6 (CKbb VSS) capacitor c=6.38375e-17
C7 (net254 VSS) capacitor c=3.04311e-18
C8 (n0 VSS) capacitor c=2.83089e-17
C9 (Eint VSS) capacitor c=7.598e-17
C10 (net238 VSS) capacitor c=1.63395e-18
C11 (ECKb VSS) capacitor c=1.82078e-16
C12 (net205 VSS) capacitor c=2.41748e-18
C13 (\4\:Eint VSS) capacitor c=4.72191e-17
C14 (\7\:CKbb VSS) capacitor c=4.46105e-17
C15 (\3\:n0 VSS) capacitor c=5.29794e-17
C16 (\3\:Eint VSS) capacitor c=3.89722e-17
C17 (\5\:CKb VSS) capacitor c=5.21079e-17
C18 (\3\:E VSS) capacitor c=7.33128e-17
C19 (\4\:CKb VSS) capacitor c=5.15148e-17
C20 (\1\:CK VSS) capacitor c=2.71215e-17
C21 (\6\:Eint VSS) capacitor c=7.68304e-17
C22 (\5\:CKbb VSS) capacitor c=5.35612e-17
C23 (\3\:CKbb VSS) capacitor c=7.80455e-17
C24 (\8\:CKb VSS) capacitor c=4.26902e-17
C25 (\1\:E VSS) capacitor c=5.91399e-17
C26 (\4\:CK VSS) capacitor c=1.85142e-17
C27 (\5\:ECKb VSS) capacitor c=2.18915e-17
C28 (\5\:Eint VSS) capacitor c=4.61329e-17
C29 (\6\:CKbb VSS) capacitor c=4.43193e-17
C30 (\2\:n0 VSS) capacitor c=3.83368e-17
C31 (\2\:Eint VSS) capacitor c=5.7182e-17
C32 (\4\:CKbb VSS) capacitor c=3.09389e-17
C33 (\2\:CKbb VSS) capacitor c=5.0344e-17
C34 (\7\:CKb VSS) capacitor c=5.21759e-17
C35 (\2\:E VSS) capacitor c=9.91353e-17
C36 (\3\:CKb VSS) capacitor c=1.67754e-17
C37 (\3\:CK VSS) capacitor c=1.08741e-17
C38 (\1\:ECK VSS) capacitor c=1.31781e-16
C39 (\1\:VDD VSS) capacitor c=1.14707e-16
C40 (\11\:ECKb VSS) capacitor c=9.4892e-17
C41 (\15\:VDD VSS) capacitor c=2.92442e-17
C42 (\13\:Eint VSS) capacitor c=2.80456e-17
C43 (\17\:VDD VSS) capacitor c=2.46335e-17
C44 (\6\:n0 VSS) capacitor c=5.89523e-17
C45 (\19\:VDD VSS) capacitor c=2.92649e-17
C46 (\14\:CKbb VSS) capacitor c=6.62604e-17
C47 (\14\:CKb VSS) capacitor c=2.95607e-17
C48 (\21\:VDD VSS) capacitor c=3.11202e-17
C49 (\3\:VDD VSS) capacitor c=8.83079e-17
C50 (\4\:ECK VSS) capacitor c=6.92645e-17
C51 (\14\:ECKb VSS) capacitor c=4.62677e-17
C52 (\11\:Eint VSS) capacitor c=6.22103e-17
C53 (\8\:n0 VSS) capacitor c=3.32513e-17
C54 (\11\:CKbb VSS) capacitor c=7.47055e-17
C55 (\12\:CKb VSS) capacitor c=2.43582e-17
C56 (\2\:CK VSS) capacitor c=1.07779e-17
C57 (\2\:CKb VSS) capacitor c=5.81895e-17
C58 (\6\:CKb VSS) capacitor c=4.02126e-17
C59 (\5\:CK VSS) capacitor c=3.62024e-17
C60 (\4\:E VSS) capacitor c=5.52395e-17
C61 (\9\:CKb VSS) capacitor c=7.06939e-17
C62 (\10\:CKb VSS) capacitor c=7.47131e-17
C63 (\11\:CKb VSS) capacitor c=3.366e-17
C64 (\4\:n0 VSS) capacitor c=4.34177e-17
C65 (\5\:n0 VSS) capacitor c=8.44266e-17
C66 (\8\:CKbb VSS) capacitor c=1.35502e-16
C67 (\9\:CKbb VSS) capacitor c=1.35115e-16
C68 (\10\:CKbb VSS) capacitor c=1.04378e-16
C69 (\13\:CKbb VSS) capacitor c=1.10146e-16
C70 (\7\:Eint VSS) capacitor c=7.23848e-17
C71 (\8\:Eint VSS) capacitor c=5.05395e-17
C72 (\9\:Eint VSS) capacitor c=3.20405e-17
C73 (\10\:Eint VSS) capacitor c=3.65006e-17
C74 (\13\:ECKb VSS) capacitor c=1.05161e-16
C75 (\6\:VDD VSS) capacitor c=8.74147e-18
C76 (\8\:VDD VSS) capacitor c=1.68322e-18
C77 (\10\:VDD VSS) capacitor c=9.32365e-18
C78 (\12\:VDD VSS) capacitor c=4.60094e-18
Rk1 (\5\:CK CK) resistor r=0.1908 c=0
Rk23 (\1\:ECK ECK) resistor r=0.1145 c=0
Rk24 (ECK \4\:ECK) resistor r=0.1733 c=0
Rk44 (\1\:VSS \6\:VSS) resistor r=0.2679 c=0
Rk45 (\6\:VSS \7\:VSS) resistor r=0.2078 c=0
Rk46 (\7\:VSS \8\:VSS) resistor r=0.3932 c=0
Rk48 (\7\:VSS \12\:VSS) resistor r=0.07334 c=0
Rk50 (\13\:VSS VSS) resistor r=0.04716 c=0
Rk49 (\8\:VSS \13\:VSS) resistor r=0.3536 c=0
Rk52 (\8\:VSS \16\:VSS) resistor r=0.2488 c=0
Rk53 (\13\:VSS \18\:VSS) resistor r=0.07334 c=0
Rk2 (E \4\:E) resistor r=0.06898 c=0
Rk29 (\1\:VDD \6\:VDD) resistor r=0.2201 c=0
Rk30 (\6\:VDD \7\:VDD) resistor r=0.1627 c=0
Rk31 (\7\:VDD \8\:VDD) resistor r=0.1501 c=0
Rk32 (\8\:VDD \9\:VDD) resistor r=0.2003 c=0
Rk33 (\9\:VDD \10\:VDD) resistor r=0.2028 c=0
Rk34 (\10\:VDD \11\:VDD) resistor r=0.1978 c=0
Rk36 (\12\:VDD VDD) resistor r=0.02712 c=0
Rk35 (\11\:VDD \12\:VDD) resistor r=0.1226 c=0
Rk38 (\6\:VDD \16\:VDD) resistor r=0.2224 c=0
Rk39 (\8\:VDD \18\:VDD) resistor r=0.2193 c=0
Rk40 (\10\:VDD \20\:VDD) resistor r=0.2193 c=0
Rk41 (\12\:VDD \22\:VDD) resistor r=0.4151 c=0
Rk3 (\9\:CKb \10\:CKb) resistor r=0.3855 c=0
Rk4 (\10\:CKb \11\:CKb) resistor r=0.1656 c=0
Rk5 (\11\:CKb \13\:CKb) resistor r=0.07119 c=0
Rk6 (\11\:CKb \15\:CKb) resistor r=0.2069 c=0
Rk10 (\8\:CKbb \9\:CKbb) resistor r=0.9169 c=0
Rk11 (\8\:CKbb \10\:CKbb) resistor r=0.3473 c=0
Rk12 (\10\:CKbb \12\:CKbb) resistor r=0.3564 c=0
Rk13 (\10\:CKbb \13\:CKbb) resistor r=0.4472 c=0
Rk14 (\13\:CKbb \15\:CKbb) resistor r=0.4522 c=0
Rk7 (\4\:n0 \5\:n0) resistor r=0.3006 c=0
Rk8 (\5\:n0 \7\:n0) resistor r=0.4933 c=0
Rk9 (\5\:n0 \9\:n0) resistor r=0.1381 c=0
Rk15 (\7\:Eint \8\:Eint) resistor r=0.3799 c=0
Rk16 (\8\:Eint \9\:Eint) resistor r=0.1542 c=0
Rk17 (\9\:Eint \10\:Eint) resistor r=0.199 c=0
Rk18 (\8\:Eint \12\:Eint) resistor r=0.2956 c=0
Rk19 (\9\:Eint \14\:Eint) resistor r=0.1901 c=0
Rk20 (\12\:ECKb \13\:ECKb) resistor r=0.5024 c=0
Rk21 (\13\:ECKb \15\:ECKb) resistor r=0.3256 c=0
Rl1 (\1\:CK \2\:CK) resistor r=49.7141 c=0
Rl3 (\2\:CK \4\:CK) resistor r=34.3295 c=0
Rl2 (\2\:CK \3\:CK) resistor r=1.2666 c=0
Rl8 (\2\:E \3\:E) resistor r=113.678 c=0
Rl7 (\1\:E \2\:E) resistor r=146.411 c=0
Rl4 (CKb \2\:CKb) resistor r=67.2856 c=0
Rl6 (\2\:CKb \4\:CKb) resistor r=174.681 c=0
Rl5 (\2\:CKb \3\:CKb) resistor r=13.851 c=0
Rl10 (\5\:CKb \6\:CKb) resistor r=159.16 c=0
Rl12 (\6\:CKb \8\:CKb) resistor r=76.7534 c=0
Rl11 (\6\:CKb \7\:CKb) resistor r=77.0603 c=0
Rl19 (\6\:CKbb \7\:CKbb) resistor r=72.3097 c=0
Rl18 (\5\:CKbb \6\:CKbb) resistor r=64.9387 c=0
Rl13 (\3\:CKbb \4\:CKbb) resistor r=48.7687 c=0
Rl9 (CKbb \2\:CKbb) resistor r=62.6944 c=0
Rl16 (n0 \2\:n0) resistor r=36.5385 c=0
Rl17 (\2\:n0 \3\:n0) resistor r=178.149 c=0
Rl20 (\4\:Eint \5\:Eint) resistor r=29.5379 c=0
Rl21 (\5\:Eint \6\:Eint) resistor r=79.5379 c=0
Rl14 (Eint \2\:Eint) resistor r=130.769 c=0
Rl15 (\2\:Eint \3\:Eint) resistor r=83.7912 c=0
Rl25 (ECKb \5\:ECKb) resistor r=4.8851 c=0
Rz14 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz15 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz16 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz8 (\1\:VDD \3\:VDD) resistor r=12.5 c=0
Rz9 (\7\:VDD \3\:VDD) resistor r=25 c=0
Rz10 (\9\:VDD \3\:VDD) resistor r=18.75 c=0
Rz11 (\11\:VDD \3\:VDD) resistor r=18.75 c=0
Rz1 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz3 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz4 (\11\:Eint \12\:Eint) resistor r=75 c=0
Rz5 (\15\:ECKb \14\:ECKb) resistor r=75 c=0
Ry17 (VSS \3\:VSS) resistor r=62 c=0
Ry14 (\1\:VSS \3\:VSS) resistor r=15.5 c=0
Ry15 (\6\:VSS \3\:VSS) resistor r=12.4 c=0
Ry16 (\8\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry10 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry11 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry12 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry13 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry1 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry3 (\14\:CKbb \15\:CKbb) resistor r=62 c=0
Ry2 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry4 (\13\:Eint \14\:Eint) resistor r=62 c=0
Ry5 (\12\:ECKb \11\:ECKb) resistor r=31 c=0
Rx1 (\3\:CK \5\:CK) resistor r=45 c=0
Rx2 (\2\:E \4\:E) resistor r=45 c=0
Rx3 (\7\:CKb \9\:CKb) resistor r=45 c=0
Rx4 (\3\:CKb \10\:CKb) resistor r=45 c=0
Rx6 (\4\:CKbb \8\:CKbb) resistor r=45 c=0
Rx7 (\6\:CKbb \9\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx5 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx9 (\5\:Eint \7\:Eint) resistor r=45 c=0
Rx10 (\2\:Eint \10\:Eint) resistor r=45 c=0
Rx11 (\13\:ECKb \5\:ECKb) resistor r=45 c=0
mn0 (\12\:CKb \4\:CK \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn1 (\11\:CKbb CKb \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.05e-14 ad=2.03e-14 ps=1.04e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.295e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn5 (net254 \1\:E \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.05e-14 ad=2.682e-14 ps=1.04e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.03e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn6 (\8\:n0 \8\:CKb net254 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.32e-14 ps=6.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=8e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn16 (\8\:n0 \3\:CKbb net230 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=5.95e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn15 (net230 Eint \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.39e-14 ad=8.7e-15 ps=1.43e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45e-07 sb=4.9e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn10 (\11\:Eint n0 \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.39e-14 ad=3.263e-14 ps=1.43e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21e-06 sb=2.25e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn21 (\14\:ECKb \5\:CKbb net238 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.6e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (net238 \6\:Eint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.55e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn22 (\4\:ECK ECKb \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=5.5e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
mp1 (\14\:CKbb \4\:CKb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.15e-06 sd=160n sca=10.9938 \
        scb=0.00779206 scc=7.78676e-05 m=(1)
mp5 (net217 \3\:E \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.45e-07 sd=160n sca=10.3176 \
        scb=0.00745056 scc=7.7647e-05 m=(1)
mp6 (\6\:n0 CKbb net217 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.3e-14 ps=5.5e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=8.4e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp16 (\6\:n0 \5\:CKb net205 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.407e-14 ad=4.3e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=5.95e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp15 (net205 \3\:Eint \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.407e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45e-07 sb=3.45e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp10 (\13\:Eint \3\:n0 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=1.4e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp21 (\11\:ECKb \7\:CKbb \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.6e-07 sd=160n sca=13.8244 \
        scb=0.0124477 scc=0.000698915 m=(1)
mp20 (\11\:ECKb \4\:Eint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.55e-07 sd=160n sca=14.1097 \
        scb=0.0125247 scc=0.000698928 m=(1)
mp22 (\1\:ECK ECKb \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.98e-14 ps=1.1e-06 pd=1.08667e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=5.5e-07 sd=160n sca=14.9549 \
        scb=0.0130951 scc=0.000699602 m=(3)
ends TLATNCAX3
// End of subcircuit definition.

// Generated for: spectre (May  9 18:23:19 2012 )
// Library name: gsclib045
// Cell name: TLATNCAX4
// View name: extracted

simulator lang=spectre

subckt TLATNCAX4 CK E ECK VDD VSS
mp0 (\9\:CKb \3\:CK \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.025e-14 ad=3.01e-14 ps=1.44e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.36081e-06 sd=160n sca=52.4731 \
        scb=0.0379902 scc=0.00614793 m=(1)
C1 (CK VSS) capacitor c=4.3224e-17
C2 (ECK VSS) capacitor c=1.97646e-17
C3 (VDD VSS) capacitor c=2.09155e-16
C4 (E VSS) capacitor c=4.388e-17
C5 (CKb VSS) capacitor c=3.16051e-17
C6 (ECKb VSS) capacitor c=2.17002e-16
C7 (CKbb VSS) capacitor c=5.58e-17
C8 (Eint VSS) capacitor c=6.54844e-17
C9 (n0 VSS) capacitor c=1.88144e-17
C10 (net254 VSS) capacitor c=1.5743e-18
C11 (net205 VSS) capacitor c=1.36479e-18
C12 (net217 VSS) capacitor c=2.42653e-18
C13 (\4\:n0 VSS) capacitor c=3.63409e-17
C14 (\1\:E VSS) capacitor c=3.97616e-17
C15 (\6\:CKbb VSS) capacitor c=4.32838e-17
C16 (\5\:CKb VSS) capacitor c=8.19756e-17
C17 (\7\:Eint VSS) capacitor c=4.01286e-17
C18 (\3\:CK VSS) capacitor c=2.11767e-17
C19 (\3\:n0 VSS) capacitor c=2.99266e-17
C20 (\3\:E VSS) capacitor c=3.94841e-17
C21 (\4\:CKb VSS) capacitor c=8.03895e-17
C22 (\4\:CKbb VSS) capacitor c=5.92808e-17
C23 (\5\:Eint VSS) capacitor c=2.71589e-17
C24 (\4\:Eint VSS) capacitor c=6.76461e-17
C25 (\3\:CKbb VSS) capacitor c=5.81449e-17
C26 (\2\:CKb VSS) capacitor c=4.16177e-17
C27 (\1\:CK VSS) capacitor c=2.64503e-17
C28 (\2\:E VSS) capacitor c=4.24164e-17
C29 (\7\:CKbb VSS) capacitor c=4.68301e-17
C30 (\6\:CKb VSS) capacitor c=3.54893e-17
C31 (\5\:CKbb VSS) capacitor c=6.50789e-17
C32 (\6\:Eint VSS) capacitor c=2.65827e-17
C33 (\2\:CKbb VSS) capacitor c=3.91207e-17
C34 (\3\:CKb VSS) capacitor c=2.34461e-17
C35 (\8\:Eint VSS) capacitor c=6.04011e-17
C36 (\1\:VDD VSS) capacitor c=3.20006e-17
C37 (\5\:n0 VSS) capacitor c=6.54824e-17
C38 (\10\:VDD VSS) capacitor c=3.19874e-17
C39 (\14\:ECKb VSS) capacitor c=1.16186e-16
C40 (\12\:VDD VSS) capacitor c=1.35703e-17
C41 (\14\:CKbb VSS) capacitor c=3.40358e-17
C42 (\1\:ECK VSS) capacitor c=1.23293e-16
C43 (\9\:CKb VSS) capacitor c=1.30611e-16
C44 (\3\:VDD VSS) capacitor c=7.28748e-17
C45 (\10\:Eint VSS) capacitor c=1.97765e-16
C46 (\8\:n0 VSS) capacitor c=5.09066e-17
C47 (\18\:ECKb VSS) capacitor c=8.52503e-17
C48 (\12\:CKbb VSS) capacitor c=3.88695e-17
C49 (\6\:ECK VSS) capacitor c=1.0495e-16
C50 (\11\:CKb VSS) capacitor c=3.3881e-17
C51 (\2\:CK VSS) capacitor c=2.79622e-17
C52 (\2\:Eint VSS) capacitor c=3.27502e-17
C53 (\3\:Eint VSS) capacitor c=3.72051e-17
C54 (\2\:n0 VSS) capacitor c=3.00213e-17
C55 (\5\:CK VSS) capacitor c=7.39081e-17
C56 (\16\:ECKb VSS) capacitor c=1.44741e-16
C57 (\17\:ECKb VSS) capacitor c=5.92648e-17
C58 (\7\:CKb VSS) capacitor c=9.90137e-17
C59 (\8\:CKb VSS) capacitor c=2.28795e-16
C60 (\8\:CKbb VSS) capacitor c=5.39302e-17
C61 (\9\:CKbb VSS) capacitor c=4.0087e-17
C62 (\10\:CKbb VSS) capacitor c=3.94329e-17
C63 (\11\:CKbb VSS) capacitor c=3.61676e-17
C64 (\4\:E VSS) capacitor c=6.73548e-17
C65 (\7\:n0 VSS) capacitor c=1.15832e-16
C66 (\10\:n0 VSS) capacitor c=7.76649e-17
C67 (\12\:Eint VSS) capacitor c=9.45114e-17
C68 (\5\:VDD VSS) capacitor c=1.58091e-17
C69 (\6\:VDD VSS) capacitor c=8.47661e-18
C70 (\8\:VDD VSS) capacitor c=9.74863e-17
Rk1 (CK \5\:CK) resistor r=0.08278 c=0
Rk4 (\1\:ECK ECK) resistor r=0.04575 c=0
Rk5 (ECK \6\:ECK) resistor r=0.2023 c=0
Rk37 (\2\:VDD \4\:VDD) resistor r=0.4799 c=0
Rk38 (\4\:VDD \5\:VDD) resistor r=0.2253 c=0
Rk39 (\5\:VDD \6\:VDD) resistor r=0.2201 c=0
Rk40 (\6\:VDD \7\:VDD) resistor r=0.105 c=0
Rk41 (\7\:VDD \8\:VDD) resistor r=0.1126 c=0
Rk43 (\5\:VDD \11\:VDD) resistor r=0.155 c=0
Rk44 (\6\:VDD \13\:VDD) resistor r=0.07334 c=0
Rk50 (\21\:VDD VDD) resistor r=0.04986 c=0
Rk49 (\8\:VDD \21\:VDD) resistor r=0.1176 c=0
Rk18 (E \4\:E) resistor r=0.05396 c=0
Rk24 (\2\:VSS \3\:VSS) resistor r=0.1476 c=0
Rk25 (\3\:VSS \4\:VSS) resistor r=0.1527 c=0
Rk26 (\4\:VSS \5\:VSS) resistor r=0.3556 c=0
Rk31 (\6\:VSS VSS) resistor r=0.1925 c=0
Rk27 (\5\:VSS \6\:VSS) resistor r=0.3855 c=0
Rk32 (\3\:VSS \11\:VSS) resistor r=0.1974 c=0
Rk33 (\5\:VSS \13\:VSS) resistor r=0.3213 c=0
Rk10 (\7\:CKb \8\:CKb) resistor r=0.7902 c=0
Rk11 (\8\:CKb \10\:CKb) resistor r=1.162 c=0
Rk12 (\10\:CKb \12\:CKb) resistor r=0.275 c=0
Rk7 (\15\:ECKb \16\:ECKb) resistor r=0.6843 c=0
Rk8 (\16\:ECKb \17\:ECKb) resistor r=0.2716 c=0
Rk9 (\16\:ECKb \19\:ECKb) resistor r=0.5695 c=0
Rk13 (\8\:CKbb \9\:CKbb) resistor r=0.2276 c=0
Rk14 (\9\:CKbb \10\:CKbb) resistor r=0.3206 c=0
Rk15 (\10\:CKbb \11\:CKbb) resistor r=0.1225 c=0
Rk16 (\11\:CKbb \13\:CKbb) resistor r=0.2449 c=0
Rk17 (\11\:CKbb \15\:CKbb) resistor r=0.08284 c=0
Rk22 (\9\:Eint \11\:Eint) resistor r=0.7356 c=0
Rk23 (\11\:Eint \12\:Eint) resistor r=0.8497 c=0
Rk19 (\6\:n0 \7\:n0) resistor r=0.4438 c=0
Rk20 (\7\:n0 \9\:n0) resistor r=0.303 c=0
Rk21 (\7\:n0 \10\:n0) resistor r=0.4419 c=0
Rl2 (\2\:CK \3\:CK) resistor r=63.1801 c=0
Rl1 (\1\:CK \2\:CK) resistor r=40.1031 c=0
Rl3 (\2\:CK \4\:CK) resistor r=3.3229 c=0
Rl30 (\1\:E \2\:E) resistor r=72.3097 c=0
Rl31 (\2\:E \3\:E) resistor r=99.2328 c=0
Rl27 (\4\:CKb \5\:CKb) resistor r=232.258 c=0
Rl16 (CKb \2\:CKb) resistor r=100 c=0
Rl28 (\5\:CKb \6\:CKb) resistor r=24.2328 c=0
Rl17 (CKb \3\:CKb) resistor r=49.2328 c=0
Rl29 (\6\:CKbb \7\:CKbb) resistor r=57.6695 c=0
Rl26 (\4\:CKbb \5\:CKbb) resistor r=92.9995 c=0
Rl18 (CKbb \2\:CKbb) resistor r=66.5405 c=0
Rl19 (\2\:CKbb \3\:CKbb) resistor r=58.8482 c=0
Rl24 (\5\:Eint \6\:Eint) resistor r=26.1559 c=0
Rl20 (Eint \2\:Eint) resistor r=90.3625 c=0
Rl23 (\2\:Eint \5\:Eint) resistor r=153.528 c=0
Rl25 (\3\:Eint \7\:Eint) resistor r=30.4507 c=0
Rl22 (\3\:Eint \4\:Eint) resistor r=144.209 c=0
Rl21 (\2\:Eint \3\:Eint) resistor r=36.9286 c=0
Rl32 (n0 \2\:n0) resistor r=16.2005 c=0
Rl34 (\2\:n0 \4\:n0) resistor r=143.11 c=0
Rl33 (\2\:n0 \3\:n0) resistor r=46.9565 c=0
Rz13 (\4\:VDD \3\:VDD) resistor r=8.3333 c=0
Rz14 (\7\:VDD \3\:VDD) resistor r=37.5 c=0
Rz15 (\8\:VDD \3\:VDD) resistor r=15 c=0
Rz16 (\21\:VDD \3\:VDD) resistor r=37.5 c=0
Rz8 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz9 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz4 (\11\:CKb \12\:CKb) resistor r=75 c=0
Rz3 (\19\:ECKb \18\:ECKb) resistor r=75 c=0
Rz5 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz7 (\10\:Eint \11\:Eint) resistor r=75 c=0
Rz6 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry11 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry12 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry13 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry9 (\4\:VSS \1\:VSS) resistor r=15.5 c=0
Ry10 (\6\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry4 (\9\:CKb \10\:CKb) resistor r=62 c=0
Ry3 (\15\:ECKb \14\:ECKb) resistor r=62 c=0
Ry5 (\14\:CKbb \15\:CKbb) resistor r=62 c=0
Ry7 (\8\:Eint \9\:Eint) resistor r=62 c=0
Ry6 (\5\:n0 \6\:n0) resistor r=62 c=0
Rx1 (\4\:CK \5\:CK) resistor r=45 c=0
Rx8 (\2\:E \4\:E) resistor r=45 c=0
Rx3 (\6\:CKb \7\:CKb) resistor r=45 c=0
Rx4 (\3\:CKb \8\:CKb) resistor r=45 c=0
Rx2 (\17\:ECKb ECKb) resistor r=45 c=0
Rx5 (\7\:CKbb \8\:CKbb) resistor r=45 c=0
Rx6 (\5\:CKbb \9\:CKbb) resistor r=45 c=0
Rx7 (\2\:CKbb \10\:CKbb) resistor r=45 c=0
Rx10 (\6\:Eint \12\:Eint) resistor r=45 c=0
Rx9 (n0 \10\:n0) resistor r=45 c=0
mn0 (\11\:CKb \1\:CK \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.8e-14 ad=2.32e-14 ps=9.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=1.355e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn22 (\6\:ECK ECKb \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.766e-14 ad=4.16e-14 ps=9.275e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.98942e-07 sb=9.48462e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(4)
mn1 (\12\:CKbb \2\:CKb \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.162e-14 ad=2.465e-14 ps=1.01e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.345e-06 sb=1.7e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn21 (\18\:ECKb \3\:CKbb net238 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.74231e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (net238 \4\:Eint \12\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.69231e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn15 (net230 \5\:Eint \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.812e-14 ps=8.4e-07 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.095e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn16 (\8\:n0 \4\:CKbb net230 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.812e-14 ad=2.755e-14 ps=5.4e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.2e-07 sb=9.25e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn6 (\8\:n0 \4\:CKb net254 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.755e-14 ps=7.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=6.9e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn5 (net254 \3\:E \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=3.48e-14 ps=9.9e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.14e-06 sb=4.05e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn10 (\10\:Eint \3\:n0 \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.75e-14 ad=2.03e-14 ps=9.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.405e-06 sb=1.4e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mp22 (\1\:ECK ECKb \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.973e-14 ad=6.24e-14 ps=1.525e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.99551e-07 sb=9.83269e-07 sd=160n sca=32.0868 \
        scb=0.0213516 scc=0.00336326 m=(4)
mp1 (\14\:CKbb CKb \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1785e-13 ad=3.35e-14 ps=1.9e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.345e-06 sb=1.55814e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp21 (\14\:ECKb CKbb \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.41e-14 ad=6.24e-14 ps=1.48e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.08974e-07 sb=9.41923e-07 sd=160n sca=11.9453 \
        scb=0.010292 scc=0.000333254 m=(1)
mp20 (\14\:ECKb \7\:Eint \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=8.27e-14 ad=6.24e-14 ps=1.32e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.13974e-07 sb=7.36923e-07 sd=160n sca=11.9453 \
        scb=0.010292 scc=0.000333254 m=(1)
mp15 (net205 Eint \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.27e-14 ad=1.505e-14 ps=1.32e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=9.35e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp16 (\5\:n0 \5\:CKb net205 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=4.085e-14 ps=5.7e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.85e-07 sb=8.2e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp6 (\5\:n0 \6\:CKbb net217 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=4.085e-14 ps=7e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=5.85e-07 sd=160n sca=13.449 \
        scb=0.0124246 scc=0.00050119 m=(1)
mp5 (net217 \1\:E \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=2.902e-14 ps=8.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-06 sb=4.05e-07 sd=160n sca=14.1512 \
        scb=0.0128629 scc=0.000501608 m=(1)
mp10 (\8\:Eint \4\:n0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.01e-14 ps=8.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.365e-06 sb=1.4e-07 sd=160n sca=17.1027 \
        scb=0.0172361 scc=0.000555702 m=(1)
ends TLATNCAX4
// End of subcircuit definition.

// Generated for: spectre (May  9 18:23:59 2012 )
// Library name: gsclib045
// Cell name: TLATNCAX6
// View name: extracted

simulator lang=spectre

subckt TLATNCAX6 CK E ECK VDD VSS
mp0 (\15\:CKb \1\:CK \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.225e-06 sd=160n sca=14.9821 \
        scb=0.0138226 scc=0.000350725 m=(1)
C1 (CK VSS) capacitor c=3.33535e-17
C2 (ECK VSS) capacitor c=5.1561e-16
C3 (VDD VSS) capacitor c=2.4285e-16
C4 (E VSS) capacitor c=8.83502e-17
C5 (CKb VSS) capacitor c=5.493e-17
C6 (net254 VSS) capacitor c=1.62207e-18
C7 (n0 VSS) capacitor c=5.27494e-17
C8 (CKbb VSS) capacitor c=3.28591e-17
C9 (Eint VSS) capacitor c=5.70727e-17
C10 (15 VSS) capacitor c=1.85061e-18
C11 (ECKb VSS) capacitor c=2.78372e-16
C12 (16 VSS) capacitor c=2.06853e-18
C13 (net217 VSS) capacitor c=2.37411e-18
C14 (net205 VSS) capacitor c=2.10638e-18
C15 (\3\:n0 VSS) capacitor c=4.54537e-17
C16 (\5\:CKb VSS) capacitor c=5.99621e-17
C17 (\3\:Eint VSS) capacitor c=4.94042e-17
C18 (\3\:CKb VSS) capacitor c=4.85937e-17
C19 (\3\:CKbb VSS) capacitor c=7.45592e-17
C20 (\1\:E VSS) capacitor c=3.10299e-17
C21 (\1\:CK VSS) capacitor c=3.75353e-17
C22 (\10\:Eint VSS) capacitor c=7.61208e-17
C23 (\4\:CKbb VSS) capacitor c=5.0134e-17
C24 (\9\:CKbb VSS) capacitor c=4.34035e-17
C25 (\5\:Eint VSS) capacitor c=6.78596e-17
C26 (\6\:CKb VSS) capacitor c=4.32618e-17
C27 (\3\:E VSS) capacitor c=7.45277e-17
C28 (\3\:CK VSS) capacitor c=3.41547e-17
C29 (\8\:ECKb VSS) capacitor c=2.46152e-17
C30 (\6\:Eint VSS) capacitor c=3.98892e-16
C31 (\2\:n0 VSS) capacitor c=3.72981e-17
C32 (\7\:CKb VSS) capacitor c=2.06802e-17
C33 (\4\:Eint VSS) capacitor c=2.53291e-17
C34 (\2\:CKbb VSS) capacitor c=6.33692e-17
C35 (\4\:CKb VSS) capacitor c=4.67195e-17
C36 (\2\:CKb VSS) capacitor c=3.29397e-17
C37 (\2\:E VSS) capacitor c=4.7859e-17
C38 (\2\:CK VSS) capacitor c=3.62494e-17
C39 (\1\:VDD VSS) capacitor c=3.07012e-16
C40 (\18\:ECKb VSS) capacitor c=1.93384e-16
C41 (\17\:VDD VSS) capacitor c=4.17238e-17
C42 (\18\:Eint VSS) capacitor c=2.94145e-17
C43 (\10\:CKbb VSS) capacitor c=8.99459e-17
C44 (\21\:VDD VSS) capacitor c=1.88402e-17
C45 (\6\:n0 VSS) capacitor c=2.14848e-16
C46 (\23\:VDD VSS) capacitor c=5.36065e-17
C47 (\15\:CKb VSS) capacitor c=7.18874e-17
C48 (\4\:VDD VSS) capacitor c=6.57802e-17
C49 (\25\:ECKb VSS) capacitor c=6.57095e-17
C50 (\14\:Eint VSS) capacitor c=3.92143e-17
C51 (\13\:CKbb VSS) capacitor c=1.50255e-16
C52 (\4\:n0 VSS) capacitor c=9.50887e-17
C53 (\11\:CKb VSS) capacitor c=8.81211e-17
C54 (\2\:Eint VSS) capacitor c=3.86869e-17
C55 (\5\:CKbb VSS) capacitor c=1.4354e-16
C56 (\4\:CK VSS) capacitor c=7.91926e-17
C57 (\4\:E VSS) capacitor c=4.10777e-17
C58 (\8\:CKb VSS) capacitor c=8.87615e-17
C59 (\9\:CKb VSS) capacitor c=7.90012e-17
C60 (\10\:CKb VSS) capacitor c=5.20544e-17
C61 (\13\:CKb VSS) capacitor c=6.13026e-17
C62 (\14\:CKb VSS) capacitor c=3.58602e-17
C63 (\8\:n0 VSS) capacitor c=1.30909e-16
C64 (\12\:CKbb VSS) capacitor c=1.2052e-16
C65 (\15\:CKbb VSS) capacitor c=1.46332e-16
C66 (\13\:Eint VSS) capacitor c=2.84035e-17
C67 (\16\:Eint VSS) capacitor c=4.35949e-17
C68 (\17\:Eint VSS) capacitor c=7.78426e-17
C69 (\24\:ECKb VSS) capacitor c=8.79788e-17
C70 (\10\:VDD VSS) capacitor c=1.53286e-17
C71 (\12\:VDD VSS) capacitor c=1.10885e-17
Rk1 (\4\:CK CK) resistor r=0.06253 c=0
Rk39 (\1\:VDD \9\:VDD) resistor r=0.2129 c=0
Rk40 (\9\:VDD \10\:VDD) resistor r=0.1969 c=0
Rk41 (\10\:VDD \11\:VDD) resistor r=0.3523 c=0
Rk43 (\12\:VDD VDD) resistor r=0.2277 c=0
Rk42 (\11\:VDD \12\:VDD) resistor r=0.07251 c=0
Rk46 (\1\:VDD \18\:VDD) resistor r=0.2503 c=0
Rk48 (\10\:VDD \22\:VDD) resistor r=0.04329 c=0
Rk49 (\12\:VDD \24\:VDD) resistor r=0.2983 c=0
Rk2 (\4\:E E) resistor r=0.03231 c=0
Rk53 (\1\:VSS \7\:VSS) resistor r=0.2954 c=0
Rk54 (\7\:VSS \8\:VSS) resistor r=0.1226 c=0
Rk55 (\8\:VSS \9\:VSS) resistor r=0.411 c=0
Rk56 (\9\:VSS \10\:VSS) resistor r=0.1903 c=0
Rk57 (\10\:VSS \11\:VSS) resistor r=0.2355 c=0
Rk59 (\12\:VSS VSS) resistor r=0.1 c=0
Rk58 (\11\:VSS \12\:VSS) resistor r=0.1151 c=0
Rk62 (\7\:VSS \18\:VSS) resistor r=0.2504 c=0
Rk63 (\9\:VSS \20\:VSS) resistor r=0.07369 c=0
Rk64 (\11\:VSS \22\:VSS) resistor r=0.07369 c=0
Rk3 (\8\:CKb \9\:CKb) resistor r=0.3969 c=0
Rk4 (\9\:CKb \10\:CKb) resistor r=0.371 c=0
Rk5 (\10\:CKb \12\:CKb) resistor r=0.286 c=0
Rk6 (\9\:CKb \13\:CKb) resistor r=0.3772 c=0
Rk7 (\10\:CKb \14\:CKb) resistor r=0.1307 c=0
Rk8 (\12\:CKb \16\:CKb) resistor r=0.6733 c=0
Rk9 (\5\:n0 \7\:n0) resistor r=0.4581 c=0
Rk10 (\7\:n0 \8\:n0) resistor r=1.223 c=0
Rk11 (\11\:CKbb \12\:CKbb) resistor r=0.576 c=0
Rk12 (\12\:CKbb \14\:CKbb) resistor r=0.4481 c=0
Rk13 (\14\:CKbb \15\:CKbb) resistor r=0.9734 c=0
Rk15 (\6\:Eint \13\:Eint) resistor r=0.2725 c=0
Rk16 (\13\:Eint \15\:Eint) resistor r=0.1276 c=0
Rk17 (\13\:Eint \16\:Eint) resistor r=0.1282 c=0
Rk18 (\16\:Eint \17\:Eint) resistor r=0.4083 c=0
Rk19 (\16\:Eint \19\:Eint) resistor r=0.127 c=0
Rk23 (\18\:ECKb \24\:ECKb) resistor r=0.422 c=0
Rk24 (\24\:ECKb \26\:ECKb) resistor r=0.4254 c=0
Rl1 (\1\:CK \2\:CK) resistor r=86.5385 c=0
Rl2 (\2\:CK \3\:CK) resistor r=58.7912 c=0
Rl3 (\1\:E \2\:E) resistor r=30.7692 c=0
Rl4 (\2\:E \3\:E) resistor r=114.56 c=0
Rl12 (\5\:CKb \6\:CKb) resistor r=167.678 c=0
Rl13 (\6\:CKb \7\:CKb) resistor r=29.5379 c=0
Rl6 (\3\:CKb \4\:CKb) resistor r=44.9225 c=0
Rl5 (CKb \2\:CKb) resistor r=29.5379 c=0
Rl14 (n0 \2\:n0) resistor r=96.1538 c=0
Rl15 (\2\:n0 \3\:n0) resistor r=26.3736 c=0
Rl7 (\2\:CKbb CKbb) resistor r=24.7951 c=0
Rl8 (\2\:CKbb \3\:CKbb) resistor r=201.466 c=0
Rl18 (\5\:CKbb \4\:CKbb) resistor r=65.3625 c=0
Rl22 (\5\:CKbb \9\:CKbb) resistor r=24.7951 c=0
Rl24 (\6\:Eint \10\:Eint) resistor r=91.4835 c=0
Rl16 (\6\:Eint \5\:Eint) resistor r=71.131 c=0
Rl9 (\2\:Eint Eint) resistor r=74.4619 c=0
Rl10 (\2\:Eint \3\:Eint) resistor r=84.125 c=0
Rl11 (\2\:Eint \4\:Eint) resistor r=4.5402 c=0
Rl31 (ECKb \8\:ECKb) resistor r=3.3229 c=0
Rz9 (\1\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz10 (\9\:VDD \4\:VDD) resistor r=18.75 c=0
Rz11 (\11\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz15 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz16 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz17 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz1 (\11\:CKb \12\:CKb) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz3 (\14\:CKbb \13\:CKbb) resistor r=75 c=0
Rz4 (\15\:Eint \14\:Eint) resistor r=75 c=0
Rz5 (\26\:ECKb \25\:ECKb) resistor r=75 c=0
Ry15 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry17 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry18 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry19 (\1\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry20 (\8\:VSS \3\:VSS) resistor r=7.75 c=0
Ry21 (\10\:VSS \3\:VSS) resistor r=15.5 c=0
Ry22 (\12\:VSS \3\:VSS) resistor r=20.6667 c=0
Ry1 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry2 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\11\:CKbb \10\:CKbb) resistor r=62 c=0
Ry4 (\19\:Eint \18\:Eint) resistor r=62 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\2\:E \4\:E) resistor r=45 c=0
Rx3 (\4\:CKb \8\:CKb) resistor r=45 c=0
Rx4 (\7\:CKb \13\:CKb) resistor r=45 c=0
Rx5 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx6 (\2\:n0 \8\:n0) resistor r=45 c=0
Rx7 (\12\:CKbb \2\:CKbb) resistor r=45 c=0
Rx8 (\15\:CKbb \5\:CKbb) resistor r=45 c=0
Rx11 (\17\:Eint \4\:Eint) resistor r=45 c=0
Rx12 (\24\:ECKb \8\:ECKb) resistor r=45 c=0
mn0 (\11\:CKb \3\:CK \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.285e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.34e-06 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn5 (net254 \3\:E \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.285e-14 ad=8.7e-15 ps=1.6e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.135e-06 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn6 (\4\:n0 CKb net254 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=6.307e-14 ps=4.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.03e-06 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn16 (\4\:n0 CKbb net230 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.667e-14 ad=6.307e-14 ps=5.2e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=5.5e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn15 (net230 Eint \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.5e-14 ad=1.667e-14 ps=1.64e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09e-06 sb=3.9e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn1 (\13\:CKbb \6\:CKb \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.5e-14 ad=2.827e-14 ps=1.64e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.285e-06 sb=1.95e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn10 (\14\:Eint n0 \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.69e-14 ad=4.817e-14 ps=1e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=1.915e-06 sd=160n sca=14.2182 \
        scb=0.0146528 scc=0.000922757 m=(1)
mn20_1__rcx (15 \5\:Eint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.69e-14 ad=1.56e-14 ps=1e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.39615e-07 sb=1.63e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn21_1__rcx (\25\:ECKb \9\:CKbb 15 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.44615e-07 sb=1.525e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn21 (\25\:ECKb \4\:CKbb 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.49615e-07 sb=1.32e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn20 (16 \10\:Eint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.44e-14 ad=1.56e-14 ps=1e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.54615e-07 sb=1.215e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn22_1__rcx (ECK ECKb \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.056e-14 ad=5.084e-14 ps=9.52e-07 pd=9.48e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=9.8e-07 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(5)
mp5 (net217 \1\:E \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.02e-06 sd=160n sca=13.1118 \
        scb=0.0113121 scc=0.000332541 m=(1)
mp6 (\6\:n0 \3\:CKbb net217 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=8e-07 sd=160n sca=12.3059 scb=0.0108395 \
        scc=0.000332115 m=(1)
mp16 (\6\:n0 \3\:CKb net205 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.44e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=5.95e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp15 (net205 \3\:Eint \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=3.118e-14 ps=1.52e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=4.05e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp1 (\10\:CKbb \5\:CKb \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.63e-14 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.225e-06 sb=1.4e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp10 (\18\:Eint \3\:n0 \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.695e-14 ad=5.89e-14 ps=1.73e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=1.99e-06 sd=160n sca=16.415 \
        scb=0.0153923 scc=0.00118075 m=(1)
mp20_1__rcx (\18\:ECKb \6\:Eint \1\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=7.367e-14 ad=6.435e-14 ps=1.495e-06 pd=1.11e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.30513e-07 sb=1.79e-06 sd=160n \
        sca=15.0636 scb=0.0136086 scc=0.000948136 m=(2)
mp21_1__rcx (\18\:ECKb \5\:CKbb \17\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=6.435e-14 ps=1.1e-06 pd=1.11e-06 \
        nrd=1.16667 nrs=1.16667 sa=5.45513e-07 sb=1.575e-06 sd=160n \
        sca=15.0636 scb=0.0136086 scc=0.000948136 m=(2)
mp22_1__rcx (ECK ECKb \1\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.424e-14 ad=7.332e-14 ps=1.26e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=9.6e-07 sd=160n sca=24.1706 \
        scb=0.0172692 scc=0.00246758 m=(5)
ends TLATNCAX6
// End of subcircuit definition.

// Generated for: spectre (May  9 18:24:39 2012 )
// Library name: gsclib045
// Cell name: TLATNCAX8
// View name: extracted

simulator lang=spectre

subckt TLATNCAX8 CK E ECK VDD VSS
mp0 (\15\:CKb \1\:CK \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.315e-06 sd=160n sca=13.7363 \
        scb=0.0116912 scc=0.000146315 m=(1)
C1 (CK VSS) capacitor c=7.48545e-17
C2 (ECK VSS) capacitor c=4.75359e-16
C3 (VDD VSS) capacitor c=2.62037e-16
C4 (E VSS) capacitor c=7.75498e-17
C5 (CKb VSS) capacitor c=5.21334e-17
C6 (n0 VSS) capacitor c=4.80011e-17
C7 (CKbb VSS) capacitor c=2.70269e-17
C8 (Eint VSS) capacitor c=5.22849e-17
C9 (15 VSS) capacitor c=1.86308e-18
C10 (ECKb VSS) capacitor c=3.30254e-16
C11 (16 VSS) capacitor c=3.42446e-18
C12 (net205 VSS) capacitor c=4.56641e-18
C13 (\3\:n0 VSS) capacitor c=4.6121e-17
C14 (\5\:CKb VSS) capacitor c=6.46562e-17
C15 (\3\:Eint VSS) capacitor c=5.33807e-17
C16 (\3\:CKb VSS) capacitor c=3.73029e-17
C17 (\3\:CKbb VSS) capacitor c=8.23327e-17
C18 (\1\:E VSS) capacitor c=4.09839e-17
C19 (\1\:CK VSS) capacitor c=4.13433e-17
C20 (\10\:Eint VSS) capacitor c=7.72496e-17
C21 (\4\:CKbb VSS) capacitor c=5.00269e-17
C22 (\9\:CKbb VSS) capacitor c=4.33352e-17
C23 (\5\:Eint VSS) capacitor c=6.91343e-17
C24 (\6\:CKb VSS) capacitor c=5.6966e-17
C25 (\3\:E VSS) capacitor c=7.10876e-17
C26 (\3\:CK VSS) capacitor c=3.56433e-17
C27 (\10\:ECKb VSS) capacitor c=2.68965e-17
C28 (\6\:Eint VSS) capacitor c=4.11406e-16
C29 (\2\:n0 VSS) capacitor c=3.96949e-17
C30 (\7\:CKb VSS) capacitor c=2.1764e-17
C31 (\4\:Eint VSS) capacitor c=2.66296e-17
C32 (\2\:CKbb VSS) capacitor c=5.79022e-17
C33 (\4\:CKb VSS) capacitor c=3.91044e-17
C34 (\2\:CKb VSS) capacitor c=3.75483e-17
C35 (\2\:E VSS) capacitor c=6.25514e-17
C36 (\2\:CK VSS) capacitor c=5.24993e-17
C37 (\1\:VDD VSS) capacitor c=3.58973e-16
C38 (\24\:ECKb VSS) capacitor c=1.94685e-16
C39 (\19\:VDD VSS) capacitor c=4.19003e-17
C40 (\18\:Eint VSS) capacitor c=4.00822e-17
C41 (\10\:CKbb VSS) capacitor c=1.00894e-16
C42 (\23\:VDD VSS) capacitor c=2.40904e-17
C43 (\6\:n0 VSS) capacitor c=2.08491e-16
C44 (\25\:VDD VSS) capacitor c=4.2726e-17
C45 (\15\:CKb VSS) capacitor c=9.49726e-17
C46 (\5\:VDD VSS) capacitor c=3.77325e-17
C47 (\31\:ECKb VSS) capacitor c=6.56263e-17
C48 (\14\:Eint VSS) capacitor c=4.02853e-17
C49 (\13\:CKbb VSS) capacitor c=1.36107e-16
C50 (\4\:n0 VSS) capacitor c=1.06253e-16
C51 (\12\:CKb VSS) capacitor c=1.86684e-17
C52 (\2\:Eint VSS) capacitor c=4.2402e-17
C53 (\5\:CKbb VSS) capacitor c=1.45836e-16
C54 (\4\:CK VSS) capacitor c=3.74307e-17
C55 (\4\:E VSS) capacitor c=3.46634e-17
C56 (\8\:CKb VSS) capacitor c=8.44053e-17
C57 (\9\:CKb VSS) capacitor c=1.3587e-16
C58 (\10\:CKb VSS) capacitor c=7.94276e-17
C59 (\11\:CKb VSS) capacitor c=8.14909e-17
C60 (\14\:CKb VSS) capacitor c=6.15427e-17
C61 (\8\:n0 VSS) capacitor c=1.52852e-16
C62 (\12\:CKbb VSS) capacitor c=1.13569e-16
C63 (\15\:CKbb VSS) capacitor c=1.27537e-16
C64 (\13\:Eint VSS) capacitor c=6.09787e-17
C65 (\17\:Eint VSS) capacitor c=6.2002e-17
C66 (\27\:ECKb VSS) capacitor c=8.90295e-17
C67 (\10\:VDD VSS) capacitor c=2.53825e-17
C68 (\12\:VDD VSS) capacitor c=1.81021e-17
Rk1 (\4\:CK CK) resistor r=0.1839 c=0
Rk43 (\1\:VDD \10\:VDD) resistor r=0.3698 c=0
Rk44 (\10\:VDD \11\:VDD) resistor r=0.1869 c=0
Rk46 (\12\:VDD VDD) resistor r=0.2177 c=0
Rk45 (\11\:VDD \12\:VDD) resistor r=0.2832 c=0
Rk50 (\1\:VDD \20\:VDD) resistor r=0.241 c=0
Rk52 (\10\:VDD \24\:VDD) resistor r=0.04331 c=0
Rk53 (\12\:VDD \26\:VDD) resistor r=0.2477 c=0
Rk2 (\4\:E E) resistor r=0.1326 c=0
Rk58 (\1\:VSS \8\:VSS) resistor r=0.1578 c=0
Rk59 (\8\:VSS \9\:VSS) resistor r=0.1377 c=0
Rk60 (\9\:VSS \10\:VSS) resistor r=0.213 c=0
Rk61 (\10\:VSS \11\:VSS) resistor r=0.2508 c=0
Rk65 (\9\:VSS \19\:VSS) resistor r=0.2612 c=0
Rk66 (\11\:VSS \20\:VSS) resistor r=0.4019 c=0
Rk68 (\21\:VSS VSS) resistor r=0.1901 c=0
Rk67 (\20\:VSS \21\:VSS) resistor r=0.1101 c=0
Rk69 (\11\:VSS \23\:VSS) resistor r=0.1203 c=0
Rk70 (\21\:VSS \25\:VSS) resistor r=0.2775 c=0
Rk3 (\8\:CKb \9\:CKb) resistor r=0.5087 c=0
Rk4 (\9\:CKb \10\:CKb) resistor r=0.538 c=0
Rk5 (\10\:CKb \11\:CKb) resistor r=0.3165 c=0
Rk6 (\11\:CKb \13\:CKb) resistor r=0.09732 c=0
Rk7 (\9\:CKb \14\:CKb) resistor r=0.4658 c=0
Rk8 (\11\:CKb \16\:CKb) resistor r=0.7415 c=0
Rk9 (\5\:n0 \7\:n0) resistor r=0.589 c=0
Rk10 (\7\:n0 \8\:n0) resistor r=1.2583 c=0
Rk11 (\11\:CKbb \12\:CKbb) resistor r=0.7069 c=0
Rk12 (\12\:CKbb \14\:CKbb) resistor r=0.4952 c=0
Rk13 (\14\:CKbb \15\:CKbb) resistor r=0.8129 c=0
Rk15 (\6\:Eint \13\:Eint) resistor r=0.2885 c=0
Rk16 (\13\:Eint \15\:Eint) resistor r=0.1216 c=0
Rk17 (\13\:Eint \16\:Eint) resistor r=0.05755 c=0
Rk18 (\16\:Eint \17\:Eint) resistor r=0.3649 c=0
Rk19 (\16\:Eint \19\:Eint) resistor r=0.2004 c=0
Rk21 (\24\:ECKb \27\:ECKb) resistor r=0.4344 c=0
Rk24 (\27\:ECKb \32\:ECKb) resistor r=0.3826 c=0
Rl1 (\1\:CK \2\:CK) resistor r=121.154 c=0
Rl2 (\2\:CK \3\:CK) resistor r=101.099 c=0
Rl3 (\1\:E \2\:E) resistor r=98.0769 c=0
Rl4 (\2\:E \3\:E) resistor r=124.176 c=0
Rl12 (\5\:CKb \6\:CKb) resistor r=246.154 c=0
Rl13 (\6\:CKb \7\:CKb) resistor r=29.5379 c=0
Rl6 (\3\:CKb \4\:CKb) resistor r=71.8456 c=0
Rl5 (CKb \2\:CKb) resistor r=39.1533 c=0
Rl14 (n0 \2\:n0) resistor r=96.1538 c=0
Rl15 (\2\:n0 \3\:n0) resistor r=26.3736 c=0
Rl7 (\2\:CKbb CKbb) resistor r=24.7951 c=0
Rl8 (\2\:CKbb \3\:CKbb) resistor r=289.927 c=0
Rl18 (\5\:CKbb \4\:CKbb) resistor r=65.3625 c=0
Rl22 (\5\:CKbb \9\:CKbb) resistor r=24.7951 c=0
Rl24 (\6\:Eint \10\:Eint) resistor r=91.4835 c=0
Rl16 (\6\:Eint \5\:Eint) resistor r=64.001 c=0
Rl9 (\2\:Eint Eint) resistor r=86.0004 c=0
Rl10 (\2\:Eint \3\:Eint) resistor r=147.587 c=0
Rl11 (\2\:Eint \4\:Eint) resistor r=5.1652 c=0
Rl33 (ECKb \10\:ECKb) resistor r=3.3229 c=0
Rz10 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz11 (\11\:VDD \5\:VDD) resistor r=6.8182 c=0
Rz16 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz17 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz18 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz1 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz3 (\14\:CKbb \13\:CKbb) resistor r=75 c=0
Rz4 (\15\:Eint \14\:Eint) resistor r=75 c=0
Rz5 (\32\:ECKb \31\:ECKb) resistor r=75 c=0
Ry17 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry19 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry20 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry21 (\1\:VSS \4\:VSS) resistor r=7.75 c=0
Ry22 (\8\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry23 (\10\:VSS \4\:VSS) resistor r=15.5 c=0
Ry24 (\11\:VSS \4\:VSS) resistor r=62 c=0
Ry25 (\20\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry1 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry2 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\11\:CKbb \10\:CKbb) resistor r=62 c=0
Ry4 (\19\:Eint \18\:Eint) resistor r=62 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\2\:E \4\:E) resistor r=45 c=0
Rx3 (\4\:CKb \8\:CKb) resistor r=45 c=0
Rx4 (\2\:CKb \10\:CKb) resistor r=45 c=0
Rx5 (\7\:CKb \14\:CKb) resistor r=45 c=0
Rx6 (\2\:n0 \8\:n0) resistor r=45 c=0
Rx7 (\12\:CKbb \2\:CKbb) resistor r=45 c=0
Rx8 (\15\:CKbb \5\:CKbb) resistor r=45 c=0
Rx11 (\17\:Eint \4\:Eint) resistor r=45 c=0
Rx12 (\27\:ECKb \10\:ECKb) resistor r=45 c=0
mn0 (\12\:CKb \3\:CK \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.425e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn5 (net254 \3\:E \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.22e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn6 (\4\:n0 CKb net254 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=7.177e-14 ps=4.1e-07 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.115e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn16 (\4\:n0 CKbb net230 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=7.177e-14 ps=5.7e-07 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=5.75e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn15 (net230 Eint \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.825e-14 ad=2.03e-14 ps=1.37e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=3.9e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (\13\:CKbb \6\:CKb \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.825e-14 ad=2.828e-14 ps=1.37e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=1.95e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn10 (\14\:Eint n0 \18\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.383e-14 ad=5.125e-14 ps=9.7e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.5e-07 sb=2e-06 sd=160n sca=15.5643 scb=0.0161016 \
        scc=0.00117276 m=(1)
mn20_1__rcx (15 \5\:Eint \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.383e-14 ad=1.56e-14 ps=9.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.39615e-07 sb=2e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn21_1__rcx (\31\:ECKb \9\:CKbb 15 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.44615e-07 sb=1.935e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn21 (\31\:ECKb \4\:CKbb 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.49615e-07 sb=1.73e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn20 (16 \10\:Eint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.29e-14 ad=1.56e-14 ps=9.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.54615e-07 sb=1.625e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn22_1__rcx (ECK ECKb \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.801e-14 ad=4.804e-14 ps=9.1857e-07 pd=9.1571e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.72203e-07 sb=1.39e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mp5 (net217 \1\:E \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.408e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.11e-06 sd=160n sca=11.6626 \
        scb=0.00875241 scc=0.000120261 m=(1)
mp6 (\6\:n0 \3\:CKbb net217 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=3.44e-14 ps=8.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=8.6e-07 sd=160n sca=10.7195 \
        scb=0.00816954 scc=0.000119639 m=(1)
mp16 (\6\:n0 \3\:CKb net205 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=3.44e-14 ps=8.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=6.55e-07 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp15 (net205 \3\:Eint \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.85e-14 ad=4.408e-14 ps=1.39e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05e-06 sb=4.05e-07 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp1 (\10\:CKbb \5\:CKb \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.85e-14 ad=3.01e-14 ps=1.39e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.315e-06 sb=1.4e-07 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp10 (\18\:Eint \3\:n0 \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.465e-14 ad=5.89e-14 ps=1.69e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=2e-06 sd=160n sca=15.1875 scb=0.0142433 \
        scc=0.000935749 m=(1)
mp20_1__rcx (\24\:ECKb \6\:Eint \1\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=7.127e-14 ad=6.24e-14 ps=1.45e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.26538e-07 sb=2e-06 sd=160n \
        sca=14.1011 scb=0.0127228 scc=0.000754417 m=(2)
mp21_1__rcx (\24\:ECKb \5\:CKbb \19\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=5.31538e-07 sb=1.985e-06 sd=160n \
        sca=14.1011 scb=0.0127228 scc=0.000754417 m=(2)
mp22_1__rcx (ECK ECKb \1\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.01719e-06 sb=1.37e-06 sd=160n sca=17.9041 \
        scb=0.0151963 scc=0.00151053 m=(7)
ends TLATNCAX8
// End of subcircuit definition.

// Generated for: spectre (May  9 18:25:18 2012 )
// Library name: gsclib045
// Cell name: TLATNSRX1
// View name: extracted

simulator lang=spectre

subckt TLATNSRX1 D GN Q QN RN SN VDD VSS
mp21 (\1\:Q \4\:qbint \23\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.435e-14 ps=1.1e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=34.23 \
        scb=0.0247192 scc=0.00340661 m=(1)
C1 (D VSS) capacitor c=6.67445e-17
C2 (SN VSS) capacitor c=6.26739e-17
C3 (Q VSS) capacitor c=2.20857e-17
C4 (GN VSS) capacitor c=6.42343e-17
C5 (VDD VSS) capacitor c=2.47681e-16
C6 (RN VSS) capacitor c=2.21843e-17
C7 (qbint VSS) capacitor c=2.25862e-17
C8 (qint VSS) capacitor c=3.99637e-17
C9 (net342 VSS) capacitor c=1.40714e-18
C10 (n5 VSS) capacitor c=3.80538e-17
C11 (GNbb VSS) capacitor c=1.82285e-17
C12 (net366 VSS) capacitor c=3.1154e-18
C13 (GNb VSS) capacitor c=4.39595e-17
C14 (GNbp VSS) capacitor c=3.50532e-17
C15 (net270 VSS) capacitor c=6.32342e-17
C16 (\1\:GN VSS) capacitor c=4.03405e-17
C17 (\4\:RN VSS) capacitor c=4.37776e-17
C18 (\4\:GNbp VSS) capacitor c=4.00573e-17
C19 (\3\:GNbb VSS) capacitor c=5.5649e-17
C20 (\1\:D VSS) capacitor c=5.24577e-17
C21 (\4\:GNbb VSS) capacitor c=1.17224e-16
C22 (\8\:qint VSS) capacitor c=5.14853e-17
C23 (\3\:RN VSS) capacitor c=8.81057e-17
C24 (\1\:SN VSS) capacitor c=3.18716e-17
C25 (\7\:qint VSS) capacitor c=3.51015e-17
C26 (\4\:qbint VSS) capacitor c=3.98333e-17
C27 (\3\:GN VSS) capacitor c=3.64743e-17
C28 (\7\:RN VSS) capacitor c=4.48909e-17
C29 (\3\:GNbp VSS) capacitor c=3.2416e-17
C30 (\6\:GNbb VSS) capacitor c=3.48977e-17
C31 (\3\:D VSS) capacitor c=7.14049e-17
C32 (\3\:GNb VSS) capacitor c=6.349e-17
C33 (\5\:GNbb VSS) capacitor c=8.51987e-17
C34 (\10\:qint VSS) capacitor c=4.52843e-17
C35 (\2\:RN VSS) capacitor c=5.14105e-17
C36 (\3\:n5 VSS) capacitor c=6.03236e-17
C37 (\3\:SN VSS) capacitor c=5.53417e-17
C38 (\5\:qint VSS) capacitor c=2.71313e-17
C39 (\4\:qint VSS) capacitor c=2.46768e-17
C40 (\3\:qbint VSS) capacitor c=2.97446e-17
C41 (\2\:GN VSS) capacitor c=4.58565e-17
C42 (\6\:RN VSS) capacitor c=3.94531e-17
C43 (\2\:D VSS) capacitor c=5.78961e-17
C44 (\4\:GNb VSS) capacitor c=5.92692e-17
C45 (\2\:GNb VSS) capacitor c=5.66448e-17
C46 (\9\:qint VSS) capacitor c=4.449e-17
C47 (\1\:RN VSS) capacitor c=2.54101e-17
C48 (\2\:n5 VSS) capacitor c=4.4142e-17
C49 (\2\:SN VSS) capacitor c=4.79253e-17
C50 (\6\:qint VSS) capacitor c=1.96607e-17
C51 (\5\:GNbp VSS) capacitor c=4.95085e-17
C52 (\1\:VDD VSS) capacitor c=4.18803e-17
C53 (\7\:GNbb VSS) capacitor c=9.22726e-17
C54 (\13\:VDD VSS) capacitor c=2.11869e-17
C55 (\5\:GNb VSS) capacitor c=7.0581e-17
C56 (\15\:VDD VSS) capacitor c=3.38263e-17
C57 (\4\:n5 VSS) capacitor c=6.06455e-17
C58 (\17\:VDD VSS) capacitor c=9.17282e-18
C59 (\3\:net270 VSS) capacitor c=4.6442e-17
C60 (\19\:VDD VSS) capacitor c=3.27701e-18
C61 (\17\:qint VSS) capacitor c=4.42305e-17
C62 (\21\:VDD VSS) capacitor c=3.9302e-17
C63 (\1\:QN VSS) capacitor c=1.10239e-16
C64 (\5\:qbint VSS) capacitor c=7.95119e-17
C65 (\23\:VDD VSS) capacitor c=8.9437e-17
C66 (\1\:Q VSS) capacitor c=4.69646e-17
C67 (\4\:VDD VSS) capacitor c=3.06149e-17
C68 (\9\:GNbp VSS) capacitor c=1.81354e-17
C69 (\11\:GNbb VSS) capacitor c=4.49121e-17
C70 (\8\:n5 VSS) capacitor c=8.65066e-17
C71 (\15\:qint VSS) capacitor c=1.02863e-17
C72 (\3\:QN VSS) capacitor c=6.89847e-17
C73 (\9\:qbint VSS) capacitor c=2.15381e-17
C74 (\3\:Q VSS) capacitor c=3.30269e-17
C75 (\2\:qbint VSS) capacitor c=1.19967e-17
C76 (\2\:qint VSS) capacitor c=1.84777e-17
C77 (\3\:qint VSS) capacitor c=3.61721e-17
C78 (\2\:GNbb VSS) capacitor c=3.56294e-17
C79 (\2\:GNbp VSS) capacitor c=4.21197e-17
C80 (\5\:RN VSS) capacitor c=4.56563e-17
C81 (\7\:qbint VSS) capacitor c=2.57263e-17
C82 (\8\:qbint VSS) capacitor c=3.62292e-17
C83 (\4\:SN VSS) capacitor c=4.86129e-17
C84 (\11\:qint VSS) capacitor c=6.33176e-17
C85 (\13\:qint VSS) capacitor c=8.32701e-17
C86 (\14\:qint VSS) capacitor c=6.43597e-17
C87 (\6\:n5 VSS) capacitor c=1.30014e-16
C88 (\7\:n5 VSS) capacitor c=7.09074e-17
C89 (\4\:D VSS) capacitor c=4.77902e-17
C90 (\7\:GNb VSS) capacitor c=1.1959e-16
C91 (\8\:GNb VSS) capacitor c=8.95482e-17
C92 (\11\:GNb VSS) capacitor c=5.62378e-17
C93 (\9\:GNbb VSS) capacitor c=7.58033e-17
C94 (\10\:GNbb VSS) capacitor c=1.98833e-17
C95 (\8\:RN VSS) capacitor c=2.14299e-16
C96 (\9\:RN VSS) capacitor c=2.15102e-16
C97 (\10\:RN VSS) capacitor c=3.75119e-17
C98 (\4\:GN VSS) capacitor c=4.22448e-17
C99 (\7\:GNbp VSS) capacitor c=6.57387e-17
C100 (\8\:GNbp VSS) capacitor c=6.31044e-17
C101 (\3\:VDD VSS) capacitor c=1.69275e-17
C102 (\6\:VDD VSS) capacitor c=2.45504e-17
C103 (\7\:VDD VSS) capacitor c=1.19149e-17
C104 (\9\:VDD VSS) capacitor c=1.18609e-17
C105 (\10\:VDD VSS) capacitor c=1.11557e-17
C106 (\12\:VDD VSS) capacitor c=9.86406e-18
Rk18 (\4\:D D) resistor r=0.01286 c=0
Rk6 (\2\:QN QN) resistor r=0.507 c=0
Rk7 (QN \4\:QN) resistor r=0.002987 c=0
Rk49 (\2\:VSS \4\:VSS) resistor r=0.5105 c=0
Rk50 (\4\:VSS \5\:VSS) resistor r=0.4074 c=0
Rk51 (\5\:VSS \6\:VSS) resistor r=0.1423 c=0
Rk52 (\6\:VSS \7\:VSS) resistor r=0.4674 c=0
Rk53 (\7\:VSS \8\:VSS) resistor r=0.2323 c=0
Rk54 (\8\:VSS \9\:VSS) resistor r=0.04231 c=0
Rk56 (\10\:VSS VSS) resistor r=0.2021 c=0
Rk55 (\9\:VSS \10\:VSS) resistor r=0.3046 c=0
Rk57 (\5\:VSS \12\:VSS) resistor r=0.073 c=0
Rk58 (\7\:VSS \14\:VSS) resistor r=0.4008 c=0
Rk59 (\9\:VSS \16\:VSS) resistor r=0.2881 c=0
Rk60 (\10\:VSS \18\:VSS) resistor r=0.2844 c=0
Rk8 (SN \4\:SN) resistor r=0.168 c=0
Rk2 (\4\:Q Q) resistor r=0.08298 c=0
Rk1 (\2\:Q \4\:Q) resistor r=0.3044 c=0
Rk29 (\4\:GN GN) resistor r=0.1513 c=0
Rk33 (\2\:VDD \3\:VDD) resistor r=0.4635 c=0
Rk34 (\3\:VDD \5\:VDD) resistor r=0.1323 c=0
Rk35 (\5\:VDD \6\:VDD) resistor r=0.2373 c=0
Rk36 (\6\:VDD \7\:VDD) resistor r=0.3972 c=0
Rk37 (\7\:VDD \8\:VDD) resistor r=0.06481 c=0
Rk38 (\8\:VDD \9\:VDD) resistor r=0.1373 c=0
Rk39 (\9\:VDD \10\:VDD) resistor r=0.3046 c=0
Rk40 (\10\:VDD \11\:VDD) resistor r=0.1073 c=0
Rk42 (\12\:VDD VDD) resistor r=0.2021 c=0
Rk41 (\11\:VDD \12\:VDD) resistor r=0.1973 c=0
Rk43 (\3\:VDD \14\:VDD) resistor r=0.225 c=0
Rk44 (\6\:VDD \16\:VDD) resistor r=0.291 c=0
Rk45 (\7\:VDD \18\:VDD) resistor r=0.073 c=0
Rk46 (\9\:VDD \20\:VDD) resistor r=0.073 c=0
Rk47 (\10\:VDD \22\:VDD) resistor r=0.2756 c=0
Rk48 (\12\:VDD \24\:VDD) resistor r=0.4123 c=0
Rk27 (\9\:RN RN) resistor r=0.02612 c=0
Rk26 (\8\:RN \9\:RN) resistor r=1.6574 c=0
Rk28 (\9\:RN \10\:RN) resistor r=0.1317 c=0
Rk3 (\6\:qbint \7\:qbint) resistor r=0.2723 c=0
Rk4 (\7\:qbint \8\:qbint) resistor r=0.1507 c=0
Rk5 (\7\:qbint \10\:qbint) resistor r=0.1259 c=0
Rk9 (\11\:qint \12\:qint) resistor r=0.4125 c=0
Rk10 (\12\:qint \13\:qint) resistor r=0.04866 c=0
Rk11 (\13\:qint \14\:qint) resistor r=0.332 c=0
Rk12 (\12\:qint \16\:qint) resistor r=0.03731 c=0
Rk13 (\13\:qint \18\:qint) resistor r=0.2648 c=0
Rk15 (\5\:n5 \6\:n5) resistor r=0.4167 c=0
Rk16 (\6\:n5 \7\:n5) resistor r=0.4245 c=0
Rk17 (\6\:n5 \9\:n5) resistor r=0.4863 c=0
Rk23 (\8\:GNbb \9\:GNbb) resistor r=0.6583 c=0
Rk24 (\9\:GNbb \10\:GNbb) resistor r=0.1463 c=0
Rk25 (\9\:GNbb \12\:GNbb) resistor r=0.1369 c=0
Rk19 (\6\:GNb \7\:GNb) resistor r=0.4613 c=0
Rk20 (\7\:GNb \8\:GNb) resistor r=0.5054 c=0
Rk21 (\7\:GNb \10\:GNb) resistor r=0.04923 c=0
Rk22 (\8\:GNb \11\:GNb) resistor r=0.2124 c=0
Rk30 (\6\:GNbp \7\:GNbp) resistor r=0.4207 c=0
Rk31 (\7\:GNbp \8\:GNbp) resistor r=0.31 c=0
Rk32 (\7\:GNbp \10\:GNbp) resistor r=0.1209 c=0
Rk14 (\2\:net270 \4\:net270) resistor r=0.2718 c=0
Rl20 (\1\:D \2\:D) resistor r=73.7687 c=0
Rl21 (\2\:D \3\:D) resistor r=94.9225 c=0
Rl10 (\1\:SN \2\:SN) resistor r=37.6944 c=0
Rl11 (\2\:SN \3\:SN) resistor r=55.0021 c=0
Rl33 (\1\:GN \2\:GN) resistor r=117.999 c=0
Rl34 (\2\:GN \3\:GN) resistor r=100.692 c=0
Rl15 (\2\:RN \3\:RN) resistor r=172.643 c=0
Rl14 (\1\:RN \2\:RN) resistor r=26.1559 c=0
Rl30 (\4\:RN \5\:RN) resistor r=114.264 c=0
Rl32 (\5\:RN \7\:RN) resistor r=120.033 c=0
Rl31 (\5\:RN \6\:RN) resistor r=11.592 c=0
Rl1 (qbint \2\:qbint) resistor r=2.0213 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=49.7141 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=34.3295 c=0
Rl16 (\8\:qint \9\:qint) resistor r=99.2328 c=0
Rl17 (\9\:qint \10\:qint) resistor r=24.2328 c=0
Rl4 (qint \2\:qint) resistor r=64.2065 c=0
Rl7 (\2\:qint \5\:qint) resistor r=33.4373 c=0
Rl8 (\2\:qint \6\:qint) resistor r=4.8851 c=0
Rl9 (\3\:qint \7\:qint) resistor r=60.772 c=0
Rl6 (\3\:qint \4\:qint) resistor r=28.0797 c=0
Rl5 (\2\:qint \3\:qint) resistor r=146.395 c=0
Rl12 (n5 \2\:n5) resistor r=26.1559 c=0
Rl13 (\2\:n5 \3\:n5) resistor r=132.246 c=0
Rl24 (\3\:GNbb \4\:GNbb) resistor r=280.335 c=0
Rl25 (\4\:GNbb \5\:GNbb) resistor r=247.208 c=0
Rl22 (GNbb \2\:GNbb) resistor r=29.0533 c=0
Rl23 (\2\:GNbb \3\:GNbb) resistor r=151.637 c=0
Rl26 (\2\:GNbb \6\:GNbb) resistor r=34.3295 c=0
Rl19 (\3\:GNb \4\:GNb) resistor r=64.1533 c=0
Rl18 (GNb \2\:GNb) resistor r=91.5405 c=0
Rl27 (GNbp \2\:GNbp) resistor r=12.2979 c=0
Rl29 (\2\:GNbp \4\:GNbp) resistor r=188.176 c=0
Rl28 (\2\:GNbp \3\:GNbp) resistor r=47.791 c=0
Rz3 (\3\:QN \4\:QN) resistor r=75 c=0
Rz12 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz13 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz14 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz15 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz16 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz9 (\4\:VDD \5\:VDD) resistor r=6.25 c=0
Rz10 (\4\:VDD \8\:VDD) resistor r=37.5 c=0
Rz11 (\4\:VDD \11\:VDD) resistor r=8.3333 c=0
Rz2 (\9\:qbint \10\:qbint) resistor r=75 c=0
Rz4 (\15\:qint \16\:qint) resistor r=75 c=0
Rz5 (\8\:n5 \9\:n5) resistor r=75 c=0
Rz7 (\11\:GNbb \12\:GNbb) resistor r=75 c=0
Rz6 (\9\:GNb \10\:GNb) resistor r=75 c=0
Rz8 (\9\:GNbp \10\:GNbp) resistor r=75 c=0
Ry3 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry18 (\3\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry19 (\3\:VSS \6\:VSS) resistor r=31 c=0
Ry20 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry11 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry12 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry13 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry14 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry15 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry16 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry17 (\23\:VDD \24\:VDD) resistor r=20.6667 c=0
Ry2 (\5\:qbint \6\:qbint) resistor r=20.6667 c=0
Ry4 (\17\:qint \18\:qint) resistor r=62 c=0
Ry7 (\4\:n5 \5\:n5) resistor r=62 c=0
Ry9 (\7\:GNbb \8\:GNbb) resistor r=62 c=0
Ry8 (\5\:GNb \6\:GNb) resistor r=62 c=0
Ry10 (\5\:GNbp \6\:GNbp) resistor r=62 c=0
Ry5 (net270 \2\:net270) resistor r=62 c=0
Ry6 (\3\:net270 \4\:net270) resistor r=62 c=0
Rx6 (\2\:D \4\:D) resistor r=45 c=0
Rx2 (\2\:SN \4\:SN) resistor r=45 c=0
Rx12 (\2\:GN \4\:GN) resistor r=45 c=0
Rx10 (\1\:RN \8\:RN) resistor r=45 c=0
Rx11 (\6\:RN \10\:RN) resistor r=45 c=0
Rx1 (qbint \8\:qbint) resistor r=45 c=0
Rx3 (\9\:qint \11\:qint) resistor r=45 c=0
Rx4 (\6\:qint \14\:qint) resistor r=45 c=0
Rx5 (\2\:n5 \7\:n5) resistor r=45 c=0
Rx9 (GNbb \10\:GNbb) resistor r=45 c=0
Rx7 (\4\:GNb \8\:GNb) resistor r=45 c=0
Rx8 (\2\:GNb \11\:GNb) resistor r=45 c=0
Rx13 (GNbp \8\:GNbp) resistor r=45 c=0
mn21 (\3\:Q \3\:qbint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.29e-14 ps=8.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (\9\:qbint \4\:qint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn22 (\3\:QN \5\:qint \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=3.64e-14 ps=1e-06 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=3.575e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn10 (net342 \3\:SN \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.09e-14 ad=8.7e-15 ps=1e-06 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.25e-07 sb=2.45e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn11 (\15\:qint \3\:n5 net342 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn15 (net350 \2\:RN \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.275e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn16 (net354 \10\:qint net350 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=5.583e-14 ps=4.1e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.17e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn17 (\8\:n5 \5\:GNbb net354 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.583e-14 ad=3.553e-14 ps=1.06e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=7.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn6 (\8\:n5 \3\:GNb net366 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.553e-14 ps=4.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=4.5e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn5 (net366 \3\:D \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.935e-14 ad=8.7e-15 ps=1.46e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn3 (\9\:GNb \6\:GNbb \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.935e-14 ad=2.03e-14 ps=1.46e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn2 (\11\:GNbb \3\:GNbp net326 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.263e-14 ad=3.77e-14 ps=7.4e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.6e-07 sb=6.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn1 (net326 \7\:RN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.263e-14 ps=6.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=3.75e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn0 (\9\:GNbp \3\:GN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.465e-14 ps=6.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=1.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp20 (\5\:qbint \7\:qint \23\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=31.7909 \
        scb=0.0210107 scc=0.00336206 m=(1)
mp22 (\1\:QN qint \21\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.47e-14 ad=5.46e-14 ps=1.26e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.57372e-07 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(1)
mp10 (\17\:qint \1\:SN \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.47e-14 ad=5.375e-14 ps=1.26e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=8e-07 sd=160n sca=21.1782 scb=0.0203295 \
        scc=0.00208843 m=(1)
mp11 (\17\:qint n5 \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.373e-14 ad=5.375e-14 ps=1.76e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=5.05e-07 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp15 (\3\:net270 \3\:RN \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.373e-14 ad=3.44e-14 ps=1.76e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=3.05e-07 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp16 (\3\:net270 \8\:qint \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.44e-14 ps=1.65e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=1e-07 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp17 (\4\:n5 GNb net270 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.63e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=7.15e-07 sd=160n sca=12.3081 \
        scb=0.0110829 scc=0.000360616 m=(1)
mp6 (\4\:n5 \4\:GNbb net313 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.58e-14 ad=3.44e-14 ps=6.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.27326e-07 sb=5.1e-07 sd=160n sca=12.3081 \
        scb=0.0110829 scc=0.000360616 m=(1)
mp5 (net313 \1\:D \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.58e-14 ps=7.5e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.92326e-07 sb=3.45e-07 sd=160n sca=12.3081 \
        scb=0.0110829 scc=0.000360616 m=(1)
mp3 (\5\:GNb \3\:GNbb \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.97326e-07 sb=1.4e-07 sd=160n sca=12.3081 \
        scb=0.0110829 scc=0.000360616 m=(1)
mp2 (\7\:GNbb \4\:GNbp \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=4.838e-14 ps=7.1e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.45e-07 sd=160n sca=10.5424 \
        scb=0.00761774 scc=8.40197e-05 m=(1)
mp1 (\7\:GNbb \4\:RN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.837e-14 ps=7.5e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=3.75e-07 sd=160n sca=11.8701 \
        scb=0.00873744 scc=8.65118e-05 m=(1)
mp0 (\5\:GNbp \1\:GN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.655e-14 ps=7.5e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=1.7e-07 sd=160n sca=15.0399 \
        scb=0.0139456 scc=0.00018525 m=(1)
ends TLATNSRX1
// End of subcircuit definition.

// Generated for: spectre (May  9 18:25:57 2012 )
// Library name: gsclib045
// Cell name: TLATNSRX2
// View name: extracted

simulator lang=spectre

subckt TLATNSRX2 D GN Q QN RN SN VDD VSS
mp3 (\4\:GNb GNbb \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9e-07 sd=160n sca=15.0072 scb=0.0138831 \
        scc=0.00018176 m=(1)
C1 (QN VSS) capacitor c=2.54819e-17
C2 (GN VSS) capacitor c=7.65249e-17
C3 (VDD VSS) capacitor c=2.86434e-16
C4 (SN VSS) capacitor c=8.09255e-17
C5 (Q VSS) capacitor c=4.10676e-17
C6 (GNbb VSS) capacitor c=5.14059e-17
C7 (GNb VSS) capacitor c=7.03619e-17
C8 (n5 VSS) capacitor c=6.34991e-17
C9 (net354 VSS) capacitor c=1.07233e-18
C10 (net350 VSS) capacitor c=6.0807e-19
C11 (qint VSS) capacitor c=5.25856e-17
C12 (net326 VSS) capacitor c=6.47048e-19
C13 (GNbp VSS) capacitor c=2.64743e-17
C14 (net342 VSS) capacitor c=1.46331e-18
C15 (qbint VSS) capacitor c=1.52692e-16
C16 (net270 VSS) capacitor c=5.81342e-17
C17 (\1\:GN VSS) capacitor c=1.91154e-17
C18 (\4\:qint VSS) capacitor c=1.25042e-16
C19 (\1\:SN VSS) capacitor c=3.88394e-17
C20 (\4\:n5 VSS) capacitor c=4.15622e-17
C21 (\2\:GNbp VSS) capacitor c=6.6037e-17
C22 (\1\:RN VSS) capacitor c=3.65259e-17
C23 (\5\:RN VSS) capacitor c=2.78403e-17
C24 (\4\:GNbb VSS) capacitor c=4.02062e-17
C25 (\1\:D VSS) capacitor c=4.46809e-17
C26 (\4\:GN VSS) capacitor c=2.75387e-17
C27 (\3\:SN VSS) capacitor c=6.03475e-17
C28 (\3\:GNbp VSS) capacitor c=6.37106e-17
C29 (\6\:RN VSS) capacitor c=4.69917e-17
C30 (\4\:RN VSS) capacitor c=4.42989e-17
C31 (\2\:qint VSS) capacitor c=4.86939e-17
C32 (\6\:GNbb VSS) capacitor c=3.5902e-17
C33 (\3\:GNb VSS) capacitor c=2.79209e-17
C34 (\3\:D VSS) capacitor c=3.64662e-17
C35 (\3\:GNbb VSS) capacitor c=2.38974e-17
C36 (\3\:GN VSS) capacitor c=2.74739e-17
C37 (\2\:SN VSS) capacitor c=4.0532e-17
C38 (\3\:n5 VSS) capacitor c=2.05615e-17
C39 (\2\:RN VSS) capacitor c=2.1247e-17
C40 (\3\:qint VSS) capacitor c=2.92604e-17
C41 (\7\:GNbb VSS) capacitor c=2.16786e-17
C42 (\5\:GNbb VSS) capacitor c=5.32967e-17
C43 (\2\:GNb VSS) capacitor c=7.43754e-17
C44 (\2\:D VSS) capacitor c=5.84825e-17
C45 (\2\:GNbb VSS) capacitor c=5.10427e-17
C46 (\4\:GNbp VSS) capacitor c=2.29424e-16
C47 (\1\:VDD VSS) capacitor c=1.59615e-16
C48 (\3\:Q VSS) capacitor c=6.37317e-17
C49 (\11\:qbint VSS) capacitor c=3.44951e-17
C50 (\1\:QN VSS) capacitor c=5.76801e-17
C51 (\21\:VDD VSS) capacitor c=2.00154e-17
C52 (\23\:qint VSS) capacitor c=6.34124e-17
C53 (\12\:GNbb VSS) capacitor c=5.57141e-17
C54 (\23\:VDD VSS) capacitor c=1.61184e-17
C55 (\25\:VDD VSS) capacitor c=2.58535e-17
C56 (\3\:net270 VSS) capacitor c=8.79346e-17
C57 (\6\:n5 VSS) capacitor c=2.18589e-16
C58 (\27\:VDD VSS) capacitor c=3.33186e-17
C59 (\4\:GNb VSS) capacitor c=1.33847e-17
C60 (\3\:VDD VSS) capacitor c=8.6688e-17
C61 (\7\:GNbp VSS) capacitor c=3.23411e-17
C62 (\1\:Q VSS) capacitor c=1.68549e-17
C63 (\9\:qbint VSS) capacitor c=1.96343e-17
C64 (\3\:QN VSS) capacitor c=2.15647e-17
C65 (\20\:qint VSS) capacitor c=7.87257e-17
C66 (\8\:GNbb VSS) capacitor c=2.56462e-17
C67 (\8\:n5 VSS) capacitor c=1.09251e-16
C68 (\7\:GNb VSS) capacitor c=6.96623e-17
C69 (\3\:RN VSS) capacitor c=2.3756e-17
C70 (\2\:n5 VSS) capacitor c=2.70941e-17
C71 (\8\:qint VSS) capacitor c=1.26787e-16
C72 (\4\:D VSS) capacitor c=4.07885e-17
C73 (\6\:D VSS) capacitor c=5.82834e-17
C74 (\6\:GNb VSS) capacitor c=9.50763e-17
C75 (\9\:GNb VSS) capacitor c=9.58085e-17
C76 (\7\:RN VSS) capacitor c=1.24334e-16
C77 (\10\:GNbb VSS) capacitor c=9.12515e-17
C78 (\11\:GNbb VSS) capacitor c=1.33114e-16
C79 (\14\:GNbb VSS) capacitor c=1.17894e-16
C80 (\15\:GNbb VSS) capacitor c=8.33687e-17
C81 (\16\:GNbb VSS) capacitor c=4.91506e-17
C82 (\5\:n5 VSS) capacitor c=1.94306e-16
C83 (\4\:SN VSS) capacitor c=2.98433e-17
C84 (\18\:qint VSS) capacitor c=6.25809e-17
C85 (\19\:qint VSS) capacitor c=6.02271e-17
C86 (\22\:qint VSS) capacitor c=1.15229e-16
C87 (\7\:qbint VSS) capacitor c=3.28307e-17
C88 (\8\:qbint VSS) capacitor c=2.73249e-17
C89 (\5\:GN VSS) capacitor c=5.23996e-17
C90 (\6\:GNbp VSS) capacitor c=2.52591e-16
C91 (\11\:VDD VSS) capacitor c=9.2451e-18
C92 (\12\:VDD VSS) capacitor c=1.89856e-17
C93 (\14\:VDD VSS) capacitor c=1.68312e-17
Rk24 (QN \2\:QN) resistor r=0.194 c=0
Rk25 (QN \4\:QN) resistor r=0.0569 c=0
Rk53 (\2\:VSS \3\:VSS) resistor r=0.1401 c=0
Rk58 (\3\:VSS \8\:VSS) resistor r=0.5284 c=0
Rk59 (\8\:VSS \9\:VSS) resistor r=0.3532 c=0
Rk60 (\9\:VSS \10\:VSS) resistor r=0.3607 c=0
Rk62 (\11\:VSS VSS) resistor r=0.04987 c=0
Rk61 (\10\:VSS \11\:VSS) resistor r=0.09003 c=0
Rk67 (\8\:VSS \21\:VSS) resistor r=0.122 c=0
Rk68 (\10\:VSS \23\:VSS) resistor r=0.287 c=0
Rk8 (\7\:RN RN) resistor r=0.02928 c=0
Rk1 (\4\:D \5\:D) resistor r=0.002943 c=0
Rk2 (D \6\:D) resistor r=0.002825 c=0
Rk3 (\4\:D \6\:D) resistor r=0.01545 c=0
Rk31 (\5\:GN GN) resistor r=0.01957 c=0
Rk38 (\1\:VDD \8\:VDD) resistor r=0.06496 c=0
Rk39 (\8\:VDD \9\:VDD) resistor r=0.04491 c=0
Rk40 (\9\:VDD \10\:VDD) resistor r=0.1552 c=0
Rk41 (\10\:VDD \11\:VDD) resistor r=0.1828 c=0
Rk42 (\11\:VDD \12\:VDD) resistor r=0.1992 c=0
Rk43 (\12\:VDD \13\:VDD) resistor r=0.267 c=0
Rk45 (\14\:VDD VDD) resistor r=0.18 c=0
Rk44 (\13\:VDD \14\:VDD) resistor r=0.2705 c=0
Rk49 (\9\:VDD \22\:VDD) resistor r=0.07937 c=0
Rk50 (\11\:VDD \24\:VDD) resistor r=0.07346 c=0
Rk51 (\12\:VDD \26\:VDD) resistor r=0.04327 c=0
Rk52 (\14\:VDD \28\:VDD) resistor r=0.223 c=0
Rk19 (\4\:SN SN) resistor r=0.02695 c=0
Rk29 (Q \2\:Q) resistor r=0.03074 c=0
Rk30 (Q \4\:Q) resistor r=0.189 c=0
Rk9 (\9\:GNbb \10\:GNbb) resistor r=0.2005 c=0
Rk10 (\10\:GNbb \11\:GNbb) resistor r=0.549 c=0
Rk11 (\10\:GNbb \13\:GNbb) resistor r=0.2021 c=0
Rk12 (\11\:GNbb \14\:GNbb) resistor r=0.7169 c=0
Rk13 (\14\:GNbb \15\:GNbb) resistor r=0.4251 c=0
Rk14 (\14\:GNbb \16\:GNbb) resistor r=0.2083 c=0
Rk4 (\5\:GNb \6\:GNb) resistor r=0.04758 c=0
Rk5 (\6\:GNb \8\:GNb) resistor r=0.5623 c=0
Rk6 (\6\:GNb \9\:GNb) resistor r=0.6156 c=0
Rk15 (\5\:n5 \7\:n5) resistor r=1.3953 c=0
Rk16 (\7\:n5 \9\:n5) resistor r=0.6286 c=0
Rk20 (\18\:qint \19\:qint) resistor r=0.37 c=0
Rk21 (\19\:qint \21\:qint) resistor r=0.1351 c=0
Rk22 (\21\:qint \22\:qint) resistor r=0.8444 c=0
Rk23 (\19\:qint \24\:qint) resistor r=0.2567 c=0
Rk32 (\5\:GNbp \6\:GNbp) resistor r=1.9338 c=0
Rk33 (\5\:GNbp \8\:GNbp) resistor r=0.2905 c=0
Rk26 (\7\:qbint \8\:qbint) resistor r=0.176 c=0
Rk27 (\8\:qbint \10\:qbint) resistor r=0.1474 c=0
Rk28 (\8\:qbint \12\:qbint) resistor r=0.1055 c=0
Rk7 (\2\:net270 \4\:net270) resistor r=0.3525 c=0
Rl11 (\1\:RN \2\:RN) resistor r=71.4298 c=0
Rl14 (\2\:RN \5\:RN) resistor r=24.2328 c=0
Rl15 (\3\:RN \6\:RN) resistor r=90.3625 c=0
Rl13 (\3\:RN \4\:RN) resistor r=65.3625 c=0
Rl12 (\2\:RN \3\:RN) resistor r=45.0682 c=0
Rl3 (\1\:D \2\:D) resistor r=130.002 c=0
Rl4 (\2\:D \3\:D) resistor r=87.6944 c=0
Rl41 (\1\:GN \2\:GN) resistor r=49.7185 c=0
Rl43 (\2\:GN \4\:GN) resistor r=65.1031 c=0
Rl42 (\2\:GN \3\:GN) resistor r=3.3229 c=0
Rl21 (\1\:SN \2\:SN) resistor r=29.5379 c=0
Rl22 (\2\:SN \3\:SN) resistor r=56.461 c=0
Rl8 (\6\:GNbb \7\:GNbb) resistor r=29.5379 c=0
Rl5 (\4\:GNbb \5\:GNbb) resistor r=106.02 c=0
Rl1 (GNbb \2\:GNbb) resistor r=188.462 c=0
Rl2 (\2\:GNbb \3\:GNbb) resistor r=32.8815 c=0
Rl6 (GNb \2\:GNb) resistor r=279.579 c=0
Rl7 (\2\:GNb \3\:GNb) resistor r=76.1559 c=0
Rl18 (n5 \2\:n5) resistor r=111.847 c=0
Rl20 (\2\:n5 \4\:n5) resistor r=23.7402 c=0
Rl19 (\2\:n5 \3\:n5) resistor r=5.1011 c=0
Rl9 (\2\:qint qint) resistor r=142.308 c=0
Rl10 (\3\:qint \2\:qint) resistor r=24.2328 c=0
Rl26 (\8\:qint \4\:qint) resistor r=72.3971 c=0
Rl16 (GNbp \2\:GNbp) resistor r=81.461 c=0
Rl17 (\2\:GNbp \3\:GNbp) resistor r=170.72 c=0
Rz5 (\4\:QN \3\:QN) resistor r=75 c=0
Rz17 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz18 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz9 (\1\:VDD \3\:VDD) resistor r=7.5 c=0
Rz10 (\8\:VDD \3\:VDD) resistor r=75 c=0
Rz11 (\10\:VDD \3\:VDD) resistor r=25 c=0
Rz12 (\13\:VDD \3\:VDD) resistor r=7.5 c=0
Rz7 (\2\:Q \1\:Q) resistor r=75 c=0
Rz2 (\8\:GNbb \9\:GNbb) resistor r=75 c=0
Rz1 (\7\:GNb \8\:GNb) resistor r=75 c=0
Rz3 (\8\:n5 \9\:n5) resistor r=75 c=0
Rz4 (\21\:qint \20\:qint) resistor r=75 c=0
Rz8 (\7\:GNbp \8\:GNbp) resistor r=75 c=0
Rz6 (\10\:qbint \9\:qbint) resistor r=75 c=0
Ry7 (\2\:QN \1\:QN) resistor r=62 c=0
Ry19 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry20 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry21 (\9\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry22 (\11\:VSS \1\:VSS) resistor r=31 c=0
Ry15 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry16 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry17 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry18 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry9 (\4\:Q \3\:Q) resistor r=62 c=0
Ry4 (\12\:GNbb \13\:GNbb) resistor r=62 c=0
Ry1 (\4\:GNb \5\:GNb) resistor r=62 c=0
Ry5 (\6\:n5 \7\:n5) resistor r=62 c=0
Ry6 (\24\:qint \23\:qint) resistor r=62 c=0
Ry10 (\4\:GNbp \5\:GNbp) resistor r=62 c=0
Ry8 (\12\:qbint \11\:qbint) resistor r=62 c=0
Ry2 (net270 \2\:net270) resistor r=62 c=0
Ry3 (\3\:net270 \4\:net270) resistor r=62 c=0
Rx3 (\2\:RN \7\:RN) resistor r=45 c=0
Rx1 (\2\:D \5\:D) resistor r=45 c=0
Rx12 (\3\:GN \5\:GN) resistor r=45 c=0
Rx8 (\2\:SN \4\:SN) resistor r=45 c=0
Rx4 (\7\:GNbb \11\:GNbb) resistor r=45 c=0
Rx5 (\2\:GNbb \15\:GNbb) resistor r=45 c=0
Rx6 (\5\:GNbb \16\:GNbb) resistor r=45 c=0
Rx2 (\2\:GNb \9\:GNb) resistor r=45 c=0
Rx7 (\3\:n5 \5\:n5) resistor r=45 c=0
Rx9 (\18\:qint \8\:qint) resistor r=45 c=0
Rx10 (\22\:qint \3\:qint) resistor r=45 c=0
Rx13 (GNbp \6\:GNbp) resistor r=45 c=0
Rx11 (\7\:qbint qbint) resistor r=45 c=0
mn3 (\7\:GNb \3\:GNbb \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.03e-14 ps=7.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.915e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn5 (net366 \3\:D \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=2.9e-14 ps=7.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=1.66e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn6 (\8\:n5 \3\:GNb net366 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=6.235e-14 ps=6.9e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.415e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn17 (\8\:n5 \6\:GNbb net354 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=6.235e-14 ps=8.3e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=9.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn16 (net354 \2\:qint net350 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.915e-14 ps=4.1e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=6.25e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn15 (net350 \4\:RN \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.13e-14 ad=8.7e-15 ps=1.22e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=5.2e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn1 (net326 \6\:RN \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.13e-14 ad=1.015e-14 ps=1.22e-06 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-06 sb=2.55e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn2 (\8\:GNbb \3\:GNbp net326 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=2.03e-14 ps=4.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.915e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (\20\:qint n5 net342 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.87e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.90634e-06 sd=160n sca=16.0682 \
        scb=0.0166045 scc=0.00126927 m=(1)
mn10 (net342 \3\:SN \3\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.587e-14 ad=1.23e-14 ps=9.9e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.81549e-06 sd=160n sca=16.0682 \
        scb=0.0166045 scc=0.00126927 m=(1)
mn22 (\3\:QN \8\:qint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.874e-14 ad=4.81e-14 ps=9.15e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.43558e-07 sb=1.48462e-06 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(2)
mn20 (\9\:qbint \4\:qint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.07e-14 ad=5.07e-14 ps=9.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.78558e-07 sb=1.04962e-06 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(2)
mn21 (\1\:Q qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.789e-14 ad=4.16e-14 ps=1.025e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39356e-06 sb=5.34615e-07 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(2)
mn0 (\7\:GNbp \4\:GN \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.597e-14 ad=2.32e-14 ps=1.07e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.6e-07 sd=160n sca=18.4982 scb=0.0194884 \
        scc=0.00168796 m=(1)
mp5 (net313 \1\:D \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.558e-14 ps=7.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.95e-07 sd=160n sca=11.8374 \
        scb=0.00867489 scc=8.30219e-05 m=(1)
mp6 (\6\:n5 \4\:GNbb net313 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.558e-14 ad=3.44e-14 ps=1.04e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=3.45e-07 sd=160n sca=10.3113 \
        scb=0.00749421 scc=8.05171e-05 m=(1)
mp17 (\6\:n5 GNb \3\:net270 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=1.4e-07 sd=160n sca=10.2104 scb=0.00747301 \
        scc=8.05149e-05 m=(1)
mp16 (net270 qint \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.465e-14 ad=3.44e-14 ps=1.76e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2e-06 sd=160n sca=35.2411 scb=0.0263265 \
        scc=0.00456529 m=(1)
mp15 (net270 \5\:RN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.54e-14 ad=3.44e-14 ps=1.86e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=2e-06 sd=160n sca=35.2411 scb=0.0263265 \
        scc=0.00456529 m=(1)
mp1 (\12\:GNbb \1\:RN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.54e-14 ad=3.44e-14 ps=1.86e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=2e-06 sd=160n sca=35.2411 scb=0.0263265 \
        scc=0.00456529 m=(1)
mp2 (\12\:GNbb \2\:GNbp \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.06e-13 ad=3.44e-14 ps=2.41e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=2e-06 sd=160n sca=35.2411 scb=0.0263265 \
        scc=0.00456529 m=(1)
mp11 (\23\:qint \4\:n5 \21\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.06e-13 ad=6.51e-14 ps=2.41e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.75645e-07 sb=1.98008e-06 sd=160n sca=28.1356 \
        scb=0.0216057 scc=0.00325451 m=(1)
mp10 (\23\:qint \1\:SN \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.0525e-13 ad=6.51e-14 ps=2.03e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.30645e-07 sb=1.84298e-06 sd=160n sca=28.1356 \
        scb=0.0216057 scc=0.00325451 m=(1)
mp22 (\1\:QN \8\:qint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0033e-13 ad=6.24e-14 ps=1.705e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.82821e-07 sb=1.52955e-06 sd=160n sca=24.4353 \
        scb=0.0186618 scc=0.00260099 m=(2)
mp20 (\11\:qbint \4\:qint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.735e-14 ad=6.24e-14 ps=1.39e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.45282e-06 sb=1.05955e-06 sd=160n sca=24.4353 \
        scb=0.0186618 scc=0.00260099 m=(2)
mp21 (\3\:Q qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.477e-14 ad=9.165e-14 ps=1.42e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.70404e-06 sb=5.79551e-07 sd=160n sca=24.5929 \
        scb=0.0186977 scc=0.00260099 m=(2)
mp0 (\4\:GNbp \1\:GN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.025e-14 ad=3.01e-14 ps=1.44e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=40.4761 scb=0.0335098 \
        scc=0.004697 m=(1)
ends TLATNSRX2
// End of subcircuit definition.

// Generated for: spectre (May  9 18:26:36 2012 )
// Library name: gsclib045
// Cell name: TLATNSRX4
// View name: extracted

simulator lang=spectre

subckt TLATNSRX4 D GN Q QN RN SN VDD VSS
mp0 (\7\:GNbp \3\:GN \47\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.912e-14 ad=4.408e-14 ps=1.58e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=6.35e-07 sd=160n sca=19.5246 \
        scb=0.021512 scc=0.000667372 m=(1)
C1 (D VSS) capacitor c=6.70439e-17
C2 (Q VSS) capacitor c=1.10981e-17
C3 (SN VSS) capacitor c=3.58341e-16
C4 (GN VSS) capacitor c=6.73744e-17
C5 (QN VSS) capacitor c=1.7415e-16
C6 (VDD VSS) capacitor c=3.17985e-16
C7 (RN VSS) capacitor c=2.76283e-16
C8 (GNbp VSS) capacitor c=5.0962e-17
C9 (GNbb VSS) capacitor c=3.44933e-17
C10 (GNb VSS) capacitor c=4.15651e-17
C11 (net366 VSS) capacitor c=7.11238e-18
C12 (n5 VSS) capacitor c=4.81054e-17
C13 (net354 VSS) capacitor c=2.44456e-19
C14 (qint VSS) capacitor c=2.76285e-17
C15 (qbint VSS) capacitor c=2.12794e-16
C16 (net270 VSS) capacitor c=6.13848e-17
C17 (\5\:qint VSS) capacitor c=1.93849e-16
C18 (\4\:RN VSS) capacitor c=7.86242e-17
C19 (\4\:qint VSS) capacitor c=3.19062e-17
C20 (\4\:GNbb VSS) capacitor c=5.85618e-17
C21 (\3\:D VSS) capacitor c=7.0132e-17
C22 (\1\:RN VSS) capacitor c=4.63455e-17
C23 (\3\:GN VSS) capacitor c=3.90353e-17
C24 (\6\:SN VSS) capacitor c=6.16304e-17
C25 (\4\:n5 VSS) capacitor c=3.30008e-17
C26 (\1\:SN VSS) capacitor c=5.67299e-17
C27 (\5\:RN VSS) capacitor c=4.11814e-17
C28 (\3\:qint VSS) capacitor c=4.8669e-17
C29 (\6\:GNbb VSS) capacitor c=4.41166e-17
C30 (\3\:GNb VSS) capacitor c=2.5384e-17
C31 (\1\:D VSS) capacitor c=3.21157e-17
C32 (\3\:GNbb VSS) capacitor c=2.91276e-17
C33 (\4\:GNbp VSS) capacitor c=2.52071e-17
C34 (\3\:RN VSS) capacitor c=6.17029e-17
C35 (\1\:GN VSS) capacitor c=3.61202e-17
C36 (\6\:RN VSS) capacitor c=2.23441e-17
C37 (\7\:GNbb VSS) capacitor c=3.95299e-17
C38 (\2\:GNb VSS) capacitor c=3.75151e-17
C39 (\5\:GNbb VSS) capacitor c=3.4473e-17
C40 (\2\:D VSS) capacitor c=5.02303e-17
C41 (\2\:GNbb VSS) capacitor c=2.63568e-17
C42 (\3\:GNbp VSS) capacitor c=2.39945e-17
C43 (\2\:RN VSS) capacitor c=5.19478e-17
C44 (\2\:GN VSS) capacitor c=4.78325e-17
C45 (\1\:Q VSS) capacitor c=1.66557e-16
C46 (\33\:qint VSS) capacitor c=1.28887e-16
C47 (\37\:VDD VSS) capacitor c=8.87823e-18
C48 (\41\:VDD VSS) capacitor c=2.1025e-17
C49 (\3\:net270 VSS) capacitor c=6.96138e-17
C50 (\11\:n5 VSS) capacitor c=1.34906e-16
C51 (\43\:VDD VSS) capacitor c=2.03065e-17
C52 (\4\:GNb VSS) capacitor c=8.02331e-17
C53 (\45\:VDD VSS) capacitor c=5.55961e-18
C54 (\15\:GNbb VSS) capacitor c=5.62712e-17
C55 (\47\:VDD VSS) capacitor c=7.32794e-18
C56 (\7\:GNbp VSS) capacitor c=5.23453e-17
C57 (\1\:VDD VSS) capacitor c=7.86965e-17
C58 (\6\:QN VSS) capacitor c=8.12344e-17
C59 (\30\:qint VSS) capacitor c=6.21365e-17
C60 (\9\:n5 VSS) capacitor c=6.31378e-17
C61 (\6\:GNb VSS) capacitor c=1.16358e-16
C62 (\13\:GNbb VSS) capacitor c=7.86531e-17
C63 (\9\:GNbp VSS) capacitor c=2.03302e-17
C64 (\2\:GNbp VSS) capacitor c=3.17593e-17
C65 (\2\:qint VSS) capacitor c=2.31851e-17
C66 (\2\:n5 VSS) capacitor c=1.27687e-16
C67 (\4\:GN VSS) capacitor c=2.7781e-17
C68 (\10\:qint VSS) capacitor c=2.12514e-16
C69 (\5\:GNbp VSS) capacitor c=4.49467e-17
C70 (\6\:GNbp VSS) capacitor c=7.90073e-17
C71 (\4\:D VSS) capacitor c=5.31997e-17
C72 (\8\:GNb VSS) capacitor c=9.47299e-17
C73 (\8\:GNbb VSS) capacitor c=7.85559e-17
C74 (\9\:GNbb VSS) capacitor c=1.11409e-16
C75 (\10\:GNbb VSS) capacitor c=1.19213e-16
C76 (\11\:GNbb VSS) capacitor c=6.53949e-17
C77 (\12\:GNbb VSS) capacitor c=1.04447e-16
C78 (\7\:RN VSS) capacitor c=2.2153e-16
C79 (\8\:RN VSS) capacitor c=2.74985e-17
C80 (\7\:n5 VSS) capacitor c=8.48216e-17
C81 (\8\:n5 VSS) capacitor c=1.16936e-16
C82 (\32\:qint VSS) capacitor c=1.16684e-16
C83 (\37\:qint VSS) capacitor c=6.17162e-17
C84 (\15\:qbint VSS) capacitor c=3.92013e-17
C85 (\16\:qbint VSS) capacitor c=2.4184e-16
C86 (\4\:Q VSS) capacitor c=6.64436e-17
C87 (\3\:VDD VSS) capacitor c=5.46235e-16
C88 (\16\:VDD VSS) capacitor c=1.0197e-17
C89 (\18\:VDD VSS) capacitor c=2.87679e-17
C90 (\20\:VDD VSS) capacitor c=8.85596e-18
C91 (\21\:VDD VSS) capacitor c=6.05733e-18
Rk5 (D \4\:D) resistor r=0.1737 c=0
Rk38 (\1\:Q Q) resistor r=0.01968 c=0
Rk39 (Q \4\:Q) resistor r=0.08608 c=0
Rk1 (GN \4\:GN) resistor r=0.0569 c=0
Rk29 (QN \6\:QN) resistor r=0.2591 c=0
Rk43 (\2\:VDD \3\:VDD) resistor r=0.04241 c=0
Rk56 (\3\:VDD \16\:VDD) resistor r=0.2577 c=0
Rk57 (\16\:VDD \17\:VDD) resistor r=0.1151 c=0
Rk58 (\17\:VDD \18\:VDD) resistor r=0.3522 c=0
Rk59 (\18\:VDD \19\:VDD) resistor r=0.2971 c=0
Rk60 (\19\:VDD \20\:VDD) resistor r=0.06652 c=0
Rk61 (\20\:VDD \21\:VDD) resistor r=0.2668 c=0
Rk63 (\22\:VDD VDD) resistor r=0.04987 c=0
Rk62 (\21\:VDD \22\:VDD) resistor r=0.06496 c=0
Rk71 (\3\:VDD \38\:VDD) resistor r=0.07346 c=0
Rk73 (\16\:VDD \42\:VDD) resistor r=0.1864 c=0
Rk74 (\18\:VDD \44\:VDD) resistor r=0.04327 c=0
Rk75 (\20\:VDD \46\:VDD) resistor r=0.04327 c=0
Rk76 (\21\:VDD \48\:VDD) resistor r=0.07346 c=0
Rk84 (\1\:VSS \11\:VSS) resistor r=0.3881 c=0
Rk85 (\11\:VSS \12\:VSS) resistor r=0.0399 c=0
Rk86 (\12\:VSS \13\:VSS) resistor r=0.5938 c=0
Rk87 (\13\:VSS \14\:VSS) resistor r=0.05745 c=0
Rk94 (\11\:VSS \28\:VSS) resistor r=0.2905 c=0
Rk95 (\13\:VSS \30\:VSS) resistor r=0.07937 c=0
Rk96 (\14\:VSS \31\:VSS) resistor r=0.3515 c=0
Rk97 (\31\:VSS \32\:VSS) resistor r=0.288 c=0
Rk99 (\33\:VSS VSS) resistor r=0.04987 c=0
Rk98 (\32\:VSS \33\:VSS) resistor r=0.1126 c=0
Rk100 (\14\:VSS \34\:VSS) resistor r=0.1255 c=0
Rk101 (\32\:VSS \36\:VSS) resistor r=0.2355 c=0
Rk15 (\7\:RN RN) resistor r=2.01 c=0
Rk16 (RN \8\:RN) resistor r=0.1354 c=0
Rk2 (\5\:GNbp \6\:GNbp) resistor r=0.3201 c=0
Rk3 (\6\:GNbp \8\:GNbp) resistor r=0.5995 c=0
Rk4 (\6\:GNbp \10\:GNbp) resistor r=0.09668 c=0
Rk8 (\8\:GNbb \9\:GNbb) resistor r=0.3959 c=0
Rk9 (\9\:GNbb \10\:GNbb) resistor r=0.6083 c=0
Rk10 (\10\:GNbb \11\:GNbb) resistor r=0.3361 c=0
Rk11 (\10\:GNbb \12\:GNbb) resistor r=0.5411 c=0
Rk12 (\12\:GNbb \14\:GNbb) resistor r=0.4521 c=0
Rk13 (\12\:GNbb \16\:GNbb) resistor r=0.3661 c=0
Rk6 (\5\:GNb \7\:GNb) resistor r=0.4341 c=0
Rk7 (\7\:GNb \8\:GNb) resistor r=0.6402 c=0
Rk17 (\7\:n5 \8\:n5) resistor r=0.5218 c=0
Rk18 (\8\:n5 \10\:n5) resistor r=0.2596 c=0
Rk19 (\8\:n5 \12\:n5) resistor r=0.7179 c=0
Rk23 (\32\:qint \33\:qint) resistor r=0.4442 c=0
Rk22 (\31\:qint \32\:qint) resistor r=0.4463 c=0
Rk25 (\33\:qint \37\:qint) resistor r=0.3766 c=0
Rk31 (\15\:qbint \16\:qbint) resistor r=0.2653 c=0
Rk14 (\2\:net270 \4\:net270) resistor r=0.3174 c=0
Rl11 (\2\:D \3\:D) resistor r=94.3956 c=0
Rl10 (\1\:D \2\:D) resistor r=49.46 c=0
Rl29 (SN \6\:SN) resistor r=68.4066 c=0
Rl21 (SN \1\:SN) resistor r=73.0769 c=0
Rl2 (\2\:GN \3\:GN) resistor r=128.022 c=0
Rl1 (\1\:GN \2\:GN) resistor r=101.923 c=0
Rl19 (\4\:RN \5\:RN) resistor r=165.385 c=0
Rl20 (\5\:RN \6\:RN) resistor r=35.7713 c=0
Rl3 (\1\:RN \2\:RN) resistor r=94.9225 c=0
Rl4 (\2\:RN \3\:RN) resistor r=133.384 c=0
Rl5 (GNbp \2\:GNbp) resistor r=209.329 c=0
Rl7 (\2\:GNbp \4\:GNbp) resistor r=36.2526 c=0
Rl6 (\2\:GNbp \3\:GNbp) resistor r=2.0166 c=0
Rl15 (\6\:GNbb \7\:GNbb) resistor r=87.6944 c=0
Rl12 (\4\:GNbb \5\:GNbb) resistor r=39.1533 c=0
Rl8 (GNbb \2\:GNbb) resistor r=56.9251 c=0
Rl9 (\2\:GNbb \3\:GNbb) resistor r=80.0021 c=0
Rl13 (GNb \2\:GNb) resistor r=110.771 c=0
Rl14 (\2\:GNb \3\:GNb) resistor r=26.1559 c=0
Rl23 (\2\:n5 n5) resistor r=80.7471 c=0
Rl25 (\2\:n5 \4\:n5) resistor r=24.7951 c=0
Rl16 (\2\:qint qint) resistor r=9.1065 c=0
Rl18 (\2\:qint \4\:qint) resistor r=34.3295 c=0
Rl17 (\2\:qint \3\:qint) resistor r=122.791 c=0
Rl34 (\10\:qint \5\:qint) resistor r=76.1151 c=0
Rz12 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz16 (\3\:VDD \1\:VDD) resistor r=4.4118 c=0
Rz17 (\17\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz18 (\19\:VDD \1\:VDD) resistor r=12.5 c=0
Rz19 (\22\:VDD \1\:VDD) resistor r=37.5 c=0
Rz27 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz28 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz29 (\34\:VSS \29\:VSS) resistor r=75 c=0
Rz30 (\36\:VSS \35\:VSS) resistor r=75 c=0
Rz1 (\9\:GNbp \10\:GNbp) resistor r=75 c=0
Rz3 (\13\:GNbb \14\:GNbb) resistor r=75 c=0
Rz2 (\6\:GNb \7\:GNb) resistor r=75 c=0
Rz4 (\10\:n5 \9\:n5) resistor r=75 c=0
Rz5 (\31\:qint \30\:qint) resistor r=75 c=0
Ry22 (\38\:VDD \37\:VDD) resistor r=62 c=0
Ry24 (\42\:VDD \41\:VDD) resistor r=62 c=0
Ry25 (\44\:VDD \43\:VDD) resistor r=62 c=0
Ry26 (\46\:VDD \45\:VDD) resistor r=62 c=0
Ry27 (\48\:VDD \47\:VDD) resistor r=62 c=0
Ry28 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry29 (\12\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry30 (\14\:VSS \5\:VSS) resistor r=62 c=0
Ry31 (\31\:VSS \5\:VSS) resistor r=10.3333 c=0
Ry32 (\33\:VSS \5\:VSS) resistor r=31 c=0
Ry1 (\7\:GNbp \8\:GNbp) resistor r=62 c=0
Ry3 (\15\:GNbb \16\:GNbb) resistor r=62 c=0
Ry2 (\4\:GNb \5\:GNb) resistor r=62 c=0
Ry6 (\12\:n5 \11\:n5) resistor r=62 c=0
Ry4 (net270 \2\:net270) resistor r=62 c=0
Ry5 (\3\:net270 \4\:net270) resistor r=62 c=0
Rx3 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:GN \4\:GN) resistor r=45 c=0
Rx8 (\6\:RN \7\:RN) resistor r=45 c=0
Rx9 (\2\:RN \8\:RN) resistor r=45 c=0
Rx2 (\3\:GNbp \5\:GNbp) resistor r=45 c=0
Rx5 (\7\:GNbb \8\:GNbb) resistor r=45 c=0
Rx6 (\5\:GNbb \9\:GNbb) resistor r=45 c=0
Rx7 (\2\:GNbb \11\:GNbb) resistor r=45 c=0
Rx4 (\2\:GNb \8\:GNb) resistor r=45 c=0
Rx10 (\7\:n5 \2\:n5) resistor r=45 c=0
Rx13 (\32\:qint \10\:qint) resistor r=45 c=0
Rx14 (\37\:qint qint) resistor r=45 c=0
Rx15 (\15\:qbint qbint) resistor r=45 c=0
mn0 (\9\:GNbp \1\:GN \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.65e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn1 (net326 \3\:RN \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.6e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn2 (\13\:GNbb \4\:GNbp net326 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.147e-14 ps=6.1e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.55e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn3 (\6\:GNb \3\:GNbb \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.78e-14 ad=2.03e-14 ps=2.12e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55172e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn5 (net366 \1\:D \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.78e-14 ad=4.35e-14 ps=2.12e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25862e-07 sb=2e-06 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn6 (\9\:n5 \3\:GNb net366 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.35e-14 ad=3.625e-14 ps=8.9e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.70862e-07 sb=2e-06 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn17 (\9\:n5 \6\:GNbb net354 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=3.625e-14 ps=6.7e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65862e-07 sb=2e-06 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn16 (net354 \3\:qint net350 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.973e-14 ad=2.755e-14 ps=7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.10086e-06 sb=2e-06 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn15 (net350 \5\:RN \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.103e-14 ad=2.973e-14 ps=8.6e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35086e-06 sb=2e-06 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn10_1__rcx (21 \1\:SN \27\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.103e-14 ad=1.64e-14 ps=8.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18744e-06 sb=2e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn11_1__rcx (\30\:qint \4\:n5 21 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=1.64e-14 ad=5.023e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31244e-06 sb=2e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn11 (\30\:qint n5 22 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.023e-14 ps=5.3e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.53537e-06 sb=2e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn10 (22 \6\:SN \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.855e-14 ad=1.23e-14 ps=9.4e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6078e-06 sb=2e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn22_1__rcx (\6\:QN \10\:qint \1\:VSS VSS) g45n1svt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=4.334e-14 ad=4.42e-14 ps=8.65e-07 pd=8.6e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.34769e-06 sb=2e-06 sd=160n \
        sca=17.5885 scb=0.0172826 scc=0.00162584 m=(4)
mn20_1__rcx (\16\:qbint \5\:qint \1\:VSS VSS) g45n1svt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.71923e-06 sb=1.575e-06 sd=160n \
        sca=17.5885 scb=0.0172826 scc=0.00162584 m=(4)
mn21_1__rcx (\4\:Q qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.94923e-06 sb=7.55e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mp1 (\15\:GNbb \1\:RN \47\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.912e-14 ad=3.44e-14 ps=1.58e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=3.75e-07 sd=160n sca=13.0584 \
        scb=0.0107457 scc=0.000192732 m=(1)
mp2 (\15\:GNbb GNbp \45\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.135e-14 ad=3.44e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.7e-07 sd=160n sca=11.7504 \
        scb=0.00937467 scc=0.000188073 m=(1)
mp3 (\4\:GNb GNbb \43\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.505e-14 ad=4.73e-14 ps=1.65e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.2e-07 sb=8.1e-07 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp5 (net313 \3\:D \43\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.505e-14 ad=1.29e-14 ps=1.65e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=5.35e-07 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp6 (\11\:n5 \4\:GNbb net313 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.268e-14 ps=5.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=4.3e-07 sd=160n sca=14.8993 scb=0.0146069 \
        scc=0.000816972 m=(1)
mp17 (\11\:n5 GNb \3\:net270 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.268e-14 ps=7.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.9e-07 sb=1.4e-07 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp16 (net270 \4\:qint \41\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.175e-14 ad=4.408e-14 ps=1.19e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.88488e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp15 (net270 \4\:RN \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.99e-14 ad=4.407e-14 ps=1.85e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.2e-07 sb=1.86744e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp10 (\33\:qint SN \3\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7e-14 ad=5.658e-14 ps=1.505e-06 pd=9.85e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.32258e-07 sb=2e-06 sd=160n sca=26.7199 \
        scb=0.0211429 scc=0.00304348 m=(2)
mp11_1__rcx (\33\:qint \2\:n5 \37\:VDD VDD) g45p1svt w=(3.1e-07) \
        l=4.5e-08 nf=1 as=7.465e-14 ad=5.658e-14 ps=1.85e-06 pd=9.85e-07 \
        nrd=1.16667 nrs=1.16667 sa=6.37258e-07 sb=2e-06 sd=160n \
        sca=26.7199 scb=0.0211429 scc=0.00304348 m=(2)
mp22_1__rcx (QN \10\:qint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.432e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.07577e-06 sb=2e-06 sd=160n sca=23.2995 \
        scb=0.0182724 scc=0.00243236 m=(4)
mp20_1__rcx (\16\:qbint \5\:qint \3\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.825e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.73167e-06 sb=1.64e-06 sd=160n \
        sca=23.2995 scb=0.0182724 scc=0.00243236 m=(4)
mp21_1__rcx (\1\:Q qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.63e-14 ad=6.337e-14 ps=1.12e-06 pd=1.105e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.96718e-06 sb=7.6e-07 sd=160n sca=23.4114 \
        scb=0.0182963 scc=0.00243236 m=(4)
ends TLATNSRX4
// End of subcircuit definition.

// Generated for: spectre (May  9 18:27:15 2012 )
// Library name: gsclib045
// Cell name: TLATNSRXL
// View name: extracted

simulator lang=spectre

subckt TLATNSRXL D GN Q QN RN SN VDD VSS
mp21 (\1\:Q \4\:qbint \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.73e-14 ad=3.548e-14 ps=1.47e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=49.1385 \
        scb=0.0321853 scc=0.00591609 m=(1)
C1 (D VSS) capacitor c=5.27083e-17
C2 (QN VSS) capacitor c=5.14703e-17
C3 (SN VSS) capacitor c=5.36231e-17
C4 (Q VSS) capacitor c=2.29744e-17
C5 (GN VSS) capacitor c=5.11178e-17
C6 (VDD VSS) capacitor c=2.76171e-16
C7 (RN VSS) capacitor c=2.28567e-16
C8 (qbint VSS) capacitor c=2.14119e-17
C9 (qint VSS) capacitor c=3.8844e-17
C10 (n5 VSS) capacitor c=3.73782e-17
C11 (net354 VSS) capacitor c=6.22382e-18
C12 (GNbb VSS) capacitor c=2.19295e-17
C13 (net366 VSS) capacitor c=2.05963e-18
C14 (GNb VSS) capacitor c=3.64848e-17
C15 (GNbp VSS) capacitor c=5.07513e-17
C16 (net270 VSS) capacitor c=6.85046e-17
C17 (\1\:GN VSS) capacitor c=4.18629e-17
C18 (\4\:RN VSS) capacitor c=5.05471e-17
C19 (\3\:GNbb VSS) capacitor c=4.47898e-17
C20 (\4\:D VSS) capacitor c=7.3061e-17
C21 (\4\:GNbb VSS) capacitor c=1.10721e-16
C22 (\7\:qint VSS) capacitor c=4.45062e-17
C23 (\3\:RN VSS) capacitor c=7.19623e-17
C24 (\1\:SN VSS) capacitor c=3.35762e-17
C25 (\6\:qint VSS) capacitor c=3.51163e-17
C26 (\4\:qbint VSS) capacitor c=3.66335e-17
C27 (\3\:GN VSS) capacitor c=3.63459e-17
C28 (\6\:RN VSS) capacitor c=4.31415e-17
C29 (\3\:GNbp VSS) capacitor c=2.26414e-17
C30 (\6\:GNbb VSS) capacitor c=2.97502e-17
C31 (\3\:D VSS) capacitor c=4.23323e-17
C32 (\3\:GNb VSS) capacitor c=5.38274e-17
C33 (\5\:GNbb VSS) capacitor c=8.57418e-17
C34 (\9\:qint VSS) capacitor c=4.45137e-17
C35 (\2\:RN VSS) capacitor c=6.52667e-17
C36 (\3\:n5 VSS) capacitor c=6.92473e-17
C37 (\3\:SN VSS) capacitor c=6.37287e-17
C38 (\5\:qint VSS) capacitor c=2.15157e-17
C39 (\4\:qint VSS) capacitor c=2.22006e-17
C40 (\3\:qbint VSS) capacitor c=2.53878e-17
C41 (\2\:GN VSS) capacitor c=4.69729e-17
C42 (\5\:RN VSS) capacitor c=6.34657e-17
C43 (\2\:GNbp VSS) capacitor c=5.16461e-17
C44 (\1\:D VSS) capacitor c=1.82756e-17
C45 (\4\:GNb VSS) capacitor c=4.84196e-17
C46 (\2\:GNb VSS) capacitor c=4.15287e-17
C47 (\8\:qint VSS) capacitor c=3.95334e-17
C48 (\1\:RN VSS) capacitor c=2.73763e-17
C49 (\2\:n5 VSS) capacitor c=5.34044e-17
C50 (\2\:SN VSS) capacitor c=5.02024e-17
C51 (\2\:qint VSS) capacitor c=4.06069e-17
C52 (\6\:GNbp VSS) capacitor c=6.60045e-17
C53 (\14\:VDD VSS) capacitor c=2.33282e-17
C54 (\7\:GNbb VSS) capacitor c=8.75653e-17
C55 (\16\:VDD VSS) capacitor c=2.09738e-17
C56 (\5\:GNb VSS) capacitor c=5.36204e-17
C57 (\18\:VDD VSS) capacitor c=3.86378e-17
C58 (\8\:n5 VSS) capacitor c=5.18665e-17
C59 (\20\:VDD VSS) capacitor c=2.62992e-17
C60 (\3\:net270 VSS) capacitor c=5.61151e-17
C61 (\22\:VDD VSS) capacitor c=3.30177e-18
C62 (\10\:qint VSS) capacitor c=5.33822e-17
C63 (\24\:VDD VSS) capacitor c=1.18946e-17
C64 (\3\:QN VSS) capacitor c=2.32681e-17
C65 (\5\:qbint VSS) capacitor c=3.20356e-17
C66 (\26\:VDD VSS) capacitor c=7.4969e-18
C67 (\1\:Q VSS) capacitor c=1.56166e-17
C68 (\1\:VDD VSS) capacitor c=9.042e-17
C69 (\8\:GNbp VSS) capacitor c=2.36084e-17
C70 (\10\:GNbb VSS) capacitor c=5.73714e-17
C71 (\10\:GNb VSS) capacitor c=1.4201e-16
C72 (\4\:n5 VSS) capacitor c=9.34376e-17
C73 (\15\:qint VSS) capacitor c=2.96905e-17
C74 (\1\:QN VSS) capacitor c=7.91351e-17
C75 (\9\:qbint VSS) capacitor c=4.01766e-17
C76 (\3\:Q VSS) capacitor c=4.28673e-17
C77 (\2\:qbint VSS) capacitor c=1.32914e-17
C78 (\3\:qint VSS) capacitor c=4.00319e-17
C79 (\2\:D VSS) capacitor c=2.73356e-17
C80 (\2\:GNbb VSS) capacitor c=3.05808e-17
C81 (\7\:qbint VSS) capacitor c=3.3642e-17
C82 (\8\:qbint VSS) capacitor c=3.44818e-17
C83 (\4\:SN VSS) capacitor c=4.83382e-17
C84 (\12\:qint VSS) capacitor c=6.85731e-17
C85 (\13\:qint VSS) capacitor c=3.97843e-17
C86 (\17\:qint VSS) capacitor c=6.92479e-17
C87 (\6\:n5 VSS) capacitor c=1.38318e-16
C88 (\7\:n5 VSS) capacitor c=6.32482e-17
C89 (\5\:D VSS) capacitor c=6.4532e-17
C90 (\8\:GNb VSS) capacitor c=9.79129e-17
C91 (\9\:GNb VSS) capacitor c=6.19793e-17
C92 (\9\:GNbb VSS) capacitor c=9.04551e-17
C93 (\7\:RN VSS) capacitor c=4.45498e-17
C94 (\8\:RN VSS) capacitor c=1.94358e-16
C95 (\4\:GN VSS) capacitor c=5.81908e-17
C96 (\4\:GNbp VSS) capacitor c=5.53461e-17
C97 (\5\:GNbp VSS) capacitor c=8.14265e-17
C98 (\3\:VDD VSS) capacitor c=1.30142e-17
C99 (\4\:VDD VSS) capacitor c=1.24862e-17
C100 (\6\:VDD VSS) capacitor c=1.1384e-17
C101 (\10\:VDD VSS) capacitor c=2.31495e-18
C102 (\12\:VDD VSS) capacitor c=1.66706e-17
Rk18 (D \5\:D) resistor r=0.02903 c=0
Rk6 (\2\:QN QN) resistor r=0.3325 c=0
Rk7 (QN \4\:QN) resistor r=0.07502 c=0
Rk50 (\2\:VSS \3\:VSS) resistor r=0.07988 c=0
Rk51 (\3\:VSS \4\:VSS) resistor r=0.3201 c=0
Rk52 (\4\:VSS \5\:VSS) resistor r=0.2751 c=0
Rk53 (\5\:VSS \6\:VSS) resistor r=0.4753 c=0
Rk54 (\6\:VSS \7\:VSS) resistor r=0.195 c=0
Rk55 (\7\:VSS \8\:VSS) resistor r=0.2398 c=0
Rk56 (\8\:VSS \9\:VSS) resistor r=0.3151 c=0
Rk58 (\10\:VSS VSS) resistor r=0.2123 c=0
Rk57 (\9\:VSS \10\:VSS) resistor r=0.03734 c=0
Rk59 (\3\:VSS \12\:VSS) resistor r=0.3179 c=0
Rk60 (\5\:VSS \14\:VSS) resistor r=0.07311 c=0
Rk61 (\7\:VSS \16\:VSS) resistor r=0.4521 c=0
Rk62 (\8\:VSS \18\:VSS) resistor r=0.3551 c=0
Rk63 (\10\:VSS \20\:VSS) resistor r=0.3655 c=0
Rk8 (\4\:SN SN) resistor r=0.1627 c=0
Rk2 (\4\:Q Q) resistor r=0.0927 c=0
Rk1 (\2\:Q \4\:Q) resistor r=0.2238 c=0
Rk27 (GN \4\:GN) resistor r=0.06224 c=0
Rk31 (\2\:VDD \3\:VDD) resistor r=0.07988 c=0
Rk32 (\3\:VDD \4\:VDD) resistor r=0.2448 c=0
Rk33 (\4\:VDD \5\:VDD) resistor r=0.07488 c=0
Rk34 (\5\:VDD \6\:VDD) resistor r=0.2901 c=0
Rk35 (\6\:VDD \7\:VDD) resistor r=0.21 c=0
Rk36 (\7\:VDD \8\:VDD) resistor r=0.2125 c=0
Rk37 (\8\:VDD \9\:VDD) resistor r=0.08739 c=0
Rk38 (\9\:VDD \10\:VDD) resistor r=0.1124 c=0
Rk39 (\10\:VDD \11\:VDD) resistor r=0.1374 c=0
Rk40 (\11\:VDD \12\:VDD) resistor r=0.1199 c=0
Rk49 (\13\:VDD VDD) resistor r=0.2506 c=0
Rk41 (\12\:VDD \13\:VDD) resistor r=0.3301 c=0
Rk42 (\3\:VDD \15\:VDD) resistor r=0.1724 c=0
Rk43 (\4\:VDD \17\:VDD) resistor r=0.1724 c=0
Rk44 (\6\:VDD \19\:VDD) resistor r=0.3378 c=0
Rk45 (\8\:VDD \21\:VDD) resistor r=0.2352 c=0
Rk46 (\10\:VDD \23\:VDD) resistor r=0.07311 c=0
Rk47 (\12\:VDD \25\:VDD) resistor r=0.07311 c=0
Rk48 (\13\:VDD \27\:VDD) resistor r=0.268 c=0
Rk25 (\7\:RN RN) resistor r=0.2616 c=0
Rk26 (RN \8\:RN) resistor r=1.6297 c=0
Rk3 (\6\:qbint \7\:qbint) resistor r=0.1143 c=0
Rk4 (\7\:qbint \8\:qbint) resistor r=0.1188 c=0
Rk5 (\7\:qbint \10\:qbint) resistor r=0.1083 c=0
Rk9 (\11\:qint \12\:qint) resistor r=0.2456 c=0
Rk10 (\12\:qint \13\:qint) resistor r=0.246 c=0
Rk11 (\12\:qint \14\:qint) resistor r=0.0611 c=0
Rk12 (\14\:qint \16\:qint) resistor r=0.09803 c=0
Rk13 (\14\:qint \17\:qint) resistor r=0.4002 c=0
Rk15 (\5\:n5 \6\:n5) resistor r=0.5033 c=0
Rk16 (\6\:n5 \7\:n5) resistor r=0.4294 c=0
Rk17 (\6\:n5 \9\:n5) resistor r=0.3233 c=0
Rk23 (\8\:GNbb \9\:GNbb) resistor r=0.7038 c=0
Rk24 (\9\:GNbb \11\:GNbb) resistor r=0.1521 c=0
Rk19 (\6\:GNb \7\:GNb) resistor r=0.3439 c=0
Rk20 (\7\:GNb \8\:GNb) resistor r=0.6335 c=0
Rk21 (\8\:GNb \9\:GNb) resistor r=0.2322 c=0
Rk22 (\7\:GNb \11\:GNb) resistor r=0.0319 c=0
Rk28 (\4\:GNbp \5\:GNbp) resistor r=0.388 c=0
Rk29 (\5\:GNbp \7\:GNbp) resistor r=0.4723 c=0
Rk30 (\5\:GNbp \9\:GNbp) resistor r=0.09291 c=0
Rk14 (\2\:net270 \4\:net270) resistor r=0.2421 c=0
Rl21 (\2\:D \4\:D) resistor r=95.868 c=0
Rl20 (\2\:D \3\:D) resistor r=34.3295 c=0
Rl19 (\1\:D \2\:D) resistor r=1.2713 c=0
Rl9 (\1\:SN \2\:SN) resistor r=29.5379 c=0
Rl10 (\2\:SN \3\:SN) resistor r=102.615 c=0
Rl31 (\1\:GN \2\:GN) resistor r=131.461 c=0
Rl32 (\2\:GN \3\:GN) resistor r=100.692 c=0
Rl14 (\2\:RN \3\:RN) resistor r=174.566 c=0
Rl29 (\4\:RN \5\:RN) resistor r=130.002 c=0
Rl30 (\5\:RN \6\:RN) resistor r=99.2328 c=0
Rl13 (\1\:RN \2\:RN) resistor r=37.6944 c=0
Rl1 (qbint \2\:qbint) resistor r=2.0213 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=47.791 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=36.2526 c=0
Rl15 (\7\:qint \8\:qint) resistor r=98.7687 c=0
Rl16 (\8\:qint \9\:qint) resistor r=29.5379 c=0
Rl4 (qint \2\:qint) resistor r=97.872 c=0
Rl7 (\2\:qint \5\:qint) resistor r=25.4178 c=0
Rl8 (\3\:qint \6\:qint) resistor r=60.772 c=0
Rl6 (\3\:qint \4\:qint) resistor r=28.0797 c=0
Rl5 (\2\:qint \3\:qint) resistor r=181.607 c=0
Rl11 (n5 \2\:n5) resistor r=24.2328 c=0
Rl12 (\2\:n5 \3\:n5) resistor r=173.381 c=0
Rl24 (\3\:GNbb \4\:GNbb) resistor r=280.335 c=0
Rl25 (\4\:GNbb \5\:GNbb) resistor r=216.506 c=0
Rl22 (GNbb \2\:GNbb) resistor r=42.6171 c=0
Rl23 (\2\:GNbb \3\:GNbb) resistor r=93.9449 c=0
Rl26 (\2\:GNbb \6\:GNbb) resistor r=36.2526 c=0
Rl18 (\3\:GNb \4\:GNb) resistor r=35.7713 c=0
Rl17 (GNb \2\:GNb) resistor r=71.8456 c=0
Rl27 (GNbp \2\:GNbp) resistor r=203.079 c=0
Rl28 (\2\:GNbp \3\:GNbp) resistor r=26.1559 c=0
Rz3 (\1\:QN \2\:QN) resistor r=75 c=0
Rz15 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz16 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz17 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz18 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz19 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz9 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz10 (\1\:VDD \5\:VDD) resistor r=12.5 c=0
Rz11 (\1\:VDD \7\:VDD) resistor r=18.75 c=0
Rz12 (\1\:VDD \9\:VDD) resistor r=37.5 c=0
Rz13 (\1\:VDD \11\:VDD) resistor r=25 c=0
Rz14 (\1\:VDD \13\:VDD) resistor r=12.5 c=0
Rz2 (\9\:qbint \10\:qbint) resistor r=75 c=0
Rz4 (\15\:qint \16\:qint) resistor r=75 c=0
Rz5 (\4\:n5 \5\:n5) resistor r=75 c=0
Rz7 (\10\:GNbb \11\:GNbb) resistor r=75 c=0
Rz6 (\10\:GNb \11\:GNb) resistor r=75 c=0
Rz8 (\8\:GNbp \9\:GNbp) resistor r=75 c=0
Ry3 (\3\:QN \4\:QN) resistor r=62 c=0
Ry18 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry19 (\1\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry20 (\1\:VSS \6\:VSS) resistor r=6.8889 c=0
Ry21 (\1\:VSS \9\:VSS) resistor r=10.3333 c=0
Ry1 (\1\:Q \2\:Q) resistor r=62 c=0
Ry11 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry12 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry13 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry14 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry15 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry16 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry17 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry2 (\5\:qbint \6\:qbint) resistor r=62 c=0
Ry4 (\10\:qint \11\:qint) resistor r=62 c=0
Ry7 (\8\:n5 \9\:n5) resistor r=62 c=0
Ry9 (\7\:GNbb \8\:GNbb) resistor r=62 c=0
Ry8 (\5\:GNb \6\:GNb) resistor r=62 c=0
Ry10 (\6\:GNbp \7\:GNbp) resistor r=62 c=0
Ry5 (net270 \2\:net270) resistor r=62 c=0
Ry6 (\3\:net270 \4\:net270) resistor r=62 c=0
Rx6 (\1\:D \5\:D) resistor r=45 c=0
Rx2 (\2\:SN \4\:SN) resistor r=45 c=0
Rx12 (\2\:GN \4\:GN) resistor r=45 c=0
Rx10 (\5\:RN \7\:RN) resistor r=45 c=0
Rx11 (\1\:RN \8\:RN) resistor r=45 c=0
Rx1 (qbint \8\:qbint) resistor r=45 c=0
Rx3 (\2\:qint \13\:qint) resistor r=45 c=0
Rx4 (\8\:qint \17\:qint) resistor r=45 c=0
Rx5 (\2\:n5 \7\:n5) resistor r=45 c=0
Rx9 (GNbb \9\:GNbb) resistor r=45 c=0
Rx7 (\4\:GNb \8\:GNb) resistor r=45 c=0
Rx8 (\2\:GNb \9\:GNb) resistor r=45 c=0
Rx13 (\2\:GNbp \4\:GNbp) resistor r=45 c=0
mn21 (\3\:Q \3\:qbint \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (\9\:qbint \4\:qint \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn22 (\1\:QN \5\:qint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.03e-14 ps=6.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=20.6444 \
        scb=0.0212501 scc=0.00213091 m=(1)
mn10 (net342 \3\:SN \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=8.7e-15 ps=6.3e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=2.45e-07 sd=160n sca=20.6444 \
        scb=0.0212501 scc=0.00213091 m=(1)
mn11 (\15\:qint \3\:n5 net342 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=20.6444 \
        scb=0.0212501 scc=0.00213091 m=(1)
mn15 (net350 \2\:RN \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.47e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn16 (net354 \9\:qint net350 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=6.743e-14 ps=4.1e-07 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.365e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn5 (net366 \3\:D \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.35e-14 ad=1.668e-14 ps=1.59e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=4.9e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn17 (\4\:n5 \5\:GNbb net354 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.743e-14 ad=2.32e-14 ps=1.22e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=8.55e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn6 (\4\:n5 \3\:GNb net366 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.668e-14 ad=2.32e-14 ps=5.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=6.5e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn3 (\10\:GNb \6\:GNbb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.35e-14 ad=3.263e-14 ps=1.59e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=2.25e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn2 (\10\:GNbb \3\:GNbp net326 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=5.51e-14 ps=6.5e-07 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=6.25e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn1 (net326 \6\:RN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.61e-14 ps=6.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=4e-07 sd=160n sca=14.7993 scb=0.0157101 \
        scc=0.000964917 m=(1)
mn0 (\8\:GNbp \3\:GN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.828e-14 ps=6.1e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.95e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mp20 (\5\:qbint \6\:qint \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.73e-14 ad=3.01e-14 ps=1.47e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=46.9517 scb=0.029008 \
        scc=0.00588492 m=(1)
mp22 (\3\:QN qint \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.295e-14 ad=3.01e-14 ps=1.63e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.01663e-06 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp10 (\10\:qint \1\:SN \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.295e-14 ad=5.483e-14 ps=1.63e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=8.01628e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp11 (\10\:qint n5 \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.865e-14 ad=5.483e-14 ps=1.59e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=5.01628e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp15 (\3\:net270 \3\:RN \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.865e-14 ad=3.44e-14 ps=1.59e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=3.06628e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp16 (\3\:net270 \7\:qint \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.565e-14 ad=3.44e-14 ps=1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.055e-06 sb=1.01628e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp17 (\8\:n5 GNb net270 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.79e-14 ad=6.88e-14 ps=7.1e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.29767e-07 sb=9e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp6 (\8\:n5 \4\:GNbb net313 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.88e-14 ps=5.5e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.94767e-07 sb=5.35e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp5 (net313 \4\:D \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=1.29e-14 ps=8.7e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.99767e-07 sb=4.3e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp3 (\5\:GNb \3\:GNbb \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.548e-14 ps=8.7e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.64767e-07 sb=1.65e-07 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp2 (\7\:GNbb GNbp \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.87e-14 ps=8.3e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=5.95e-07 sd=160n sca=11.21 scb=0.00817575 \
        scc=9.87005e-05 m=(1)
mp1 (\7\:GNbb \4\:RN \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.87e-14 ps=7.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=3.7e-07 sd=160n sca=13.0884 \
        scb=0.0105751 scc=0.000113994 m=(1)
mp0 (\6\:GNbp \1\:GN \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=1.65e-07 sd=160n sca=19.3888 \
        scb=0.0210602 scc=0.000665938 m=(1)
ends TLATNSRXL
// End of subcircuit definition.

// Generated for: spectre (May  9 18:27:54 2012 )
// Library name: gsclib045
// Cell name: TLATNTSCAX12
// View name: extracted

simulator lang=spectre

subckt TLATNTSCAX12 CK E ECK SE VDD VSS
mp1 (\5\:Eb \1\:E net246 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.65e-07 sd=160n sca=16.4413 \
        scb=0.0164604 scc=0.000341327 m=(1)
C1 (CK VSS) capacitor c=8.97166e-17
C2 (SE VSS) capacitor c=1.34974e-16
C3 (VDD VSS) capacitor c=3.53594e-16
C4 (ECK VSS) capacitor c=9.67427e-16
C5 (Eb VSS) capacitor c=7.91507e-17
C6 (CKb VSS) capacitor c=2.54328e-17
C7 (n5 VSS) capacitor c=5.11852e-17
C8 (net263 VSS) capacitor c=9.54971e-20
C9 (CKbb VSS) capacitor c=5.10568e-17
C10 (Eint VSS) capacitor c=9.04719e-17
C11 (16 VSS) capacitor c=2.31897e-18
C12 (ECKb VSS) capacitor c=5.02348e-16
C13 (17 VSS) capacitor c=1.81972e-18
C14 (18 VSS) capacitor c=1.81972e-18
C15 (net234 VSS) capacitor c=1.57238e-18
C16 (\5\:CKbb VSS) capacitor c=5.62781e-16
C17 (\3\:n5 VSS) capacitor c=3.66583e-17
C18 (\5\:CKb VSS) capacitor c=5.79315e-17
C19 (\3\:CKb VSS) capacitor c=6.52083e-17
C20 (\3\:CKbb VSS) capacitor c=6.54073e-17
C21 (\3\:CK VSS) capacitor c=5.21862e-17
C22 (\1\:SE VSS) capacitor c=8.46717e-17
C23 (\1\:E VSS) capacitor c=9.57755e-17
C24 (\13\:CKbb VSS) capacitor c=5.56243e-17
C25 (\13\:Eint VSS) capacitor c=4.56691e-17
C26 (\12\:Eint VSS) capacitor c=4.56162e-17
C27 (\9\:CKbb VSS) capacitor c=4.4582e-17
C28 (\8\:CKbb VSS) capacitor c=3.25891e-17
C29 (\5\:Eint VSS) capacitor c=5.39622e-17
C30 (\6\:CKb VSS) capacitor c=5.798e-17
C31 (\3\:Eint VSS) capacitor c=8.67339e-17
C32 (\1\:CK VSS) capacitor c=2.45445e-17
C33 (\3\:SE VSS) capacitor c=3.87406e-17
C34 (\4\:E VSS) capacitor c=2.59383e-17
C35 (\12\:ECKb VSS) capacitor c=1.16594e-17
C36 (\6\:Eint VSS) capacitor c=4.1348e-16
C37 (\2\:n5 VSS) capacitor c=3.81389e-17
C38 (\7\:CKb VSS) capacitor c=1.62981e-17
C39 (\4\:Eint VSS) capacitor c=9.29021e-17
C40 (\4\:CKbb VSS) capacitor c=5.18655e-17
C41 (\4\:CKb VSS) capacitor c=4.68529e-17
C42 (\2\:CKb VSS) capacitor c=1.87066e-17
C43 (\2\:CK VSS) capacitor c=5.19076e-17
C44 (\2\:SE VSS) capacitor c=8.67616e-17
C45 (\3\:E VSS) capacitor c=1.22132e-17
C46 (\1\:VDD VSS) capacitor c=7.47003e-16
C47 (\23\:Eint VSS) capacitor c=7.84267e-17
C48 (\19\:CKbb VSS) capacitor c=1.11308e-16
C49 (\34\:VDD VSS) capacitor c=2.62441e-17
C50 (\5\:n5 VSS) capacitor c=2.1714e-16
C51 (\7\:Eb VSS) capacitor c=1.38887e-16
C52 (\14\:CKb VSS) capacitor c=1.05563e-16
C53 (\36\:VDD VSS) capacitor c=4.59146e-17
C54 (\5\:Eb VSS) capacitor c=9.67365e-18
C55 (\3\:VDD VSS) capacitor c=1.11482e-16
C56 (\38\:ECKb VSS) capacitor c=7.95055e-17
C57 (\44\:ECKb VSS) capacitor c=1.02748e-16
C58 (\21\:Eint VSS) capacitor c=3.40453e-17
C59 (\16\:CKbb VSS) capacitor c=1.55906e-16
C60 (\7\:n5 VSS) capacitor c=1.04055e-16
C61 (\12\:CKb VSS) capacitor c=1.03007e-16
C62 (\9\:Eb VSS) capacitor c=9.50906e-17
C63 (\2\:E VSS) capacitor c=6.01132e-17
C64 (\2\:CKbb VSS) capacitor c=4.10985e-17
C65 (\10\:Eint VSS) capacitor c=2.84424e-17
C66 (\11\:Eint VSS) capacitor c=2.65271e-17
C67 (\5\:E VSS) capacitor c=4.72795e-17
C68 (\7\:E VSS) capacitor c=5.02884e-17
C69 (\4\:CK VSS) capacitor c=4.35162e-17
C70 (\4\:Eb VSS) capacitor c=1.58889e-16
C71 (\8\:CKb VSS) capacitor c=8.97427e-17
C72 (\9\:CKb VSS) capacitor c=7.25201e-17
C73 (\10\:CKb VSS) capacitor c=4.9791e-17
C74 (\11\:CKb VSS) capacitor c=6.29845e-17
C75 (\4\:n5 VSS) capacitor c=1.70933e-16
C76 (\20\:Eint VSS) capacitor c=5.40528e-17
C77 (\25\:Eint VSS) capacitor c=6.61207e-17
C78 (\18\:CKbb VSS) capacitor c=1.14433e-16
C79 (\32\:ECKb VSS) capacitor c=1.71402e-17
C80 (\33\:ECKb VSS) capacitor c=4.27124e-17
C81 (\34\:ECKb VSS) capacitor c=2.65898e-16
C82 (\14\:VDD VSS) capacitor c=2.12057e-17
C83 (\16\:VDD VSS) capacitor c=1.40003e-17
Rk5 (\4\:CK CK) resistor r=0.09973 c=0
Rk81 (\1\:VSS \10\:VSS) resistor r=0.2306 c=0
Rk82 (\10\:VSS \11\:VSS) resistor r=0.1227 c=0
Rk83 (\11\:VSS \12\:VSS) resistor r=0.3282 c=0
Rk84 (\12\:VSS \13\:VSS) resistor r=0.5139 c=0
Rk85 (\13\:VSS \14\:VSS) resistor r=0.2381 c=0
Rk87 (\15\:VSS VSS) resistor r=0.2284 c=0
Rk86 (\14\:VSS \15\:VSS) resistor r=0.3234 c=0
Rk88 (VSS \17\:VSS) resistor r=0.1799 c=0
Rk94 (\11\:VSS \29\:VSS) resistor r=0.2705 c=0
Rk95 (\12\:VSS \31\:VSS) resistor r=0.229 c=0
Rk96 (\13\:VSS \33\:VSS) resistor r=0.1632 c=0
Rk97 (\15\:VSS \35\:VSS) resistor r=0.1769 c=0
Rk4 (\4\:SE SE) resistor r=0.003006 c=0
Rk59 (\1\:VDD \13\:VDD) resistor r=0.198 c=0
Rk60 (\13\:VDD \14\:VDD) resistor r=0.203 c=0
Rk61 (\14\:VDD \15\:VDD) resistor r=0.4489 c=0
Rk63 (\16\:VDD VDD) resistor r=0.2278 c=0
Rk62 (\15\:VDD \16\:VDD) resistor r=0.1729 c=0
Rk73 (\14\:VDD \35\:VDD) resistor r=0.1029 c=0
Rk74 (\16\:VDD \37\:VDD) resistor r=0.2845 c=0
Rk1 (\5\:E \6\:E) resistor r=0.003108 c=0
Rk2 (E \7\:E) resistor r=0.00303 c=0
Rk3 (\5\:E \7\:E) resistor r=0.1198 c=0
Rk6 (\2\:Eb \3\:Eb) resistor r=0.5121 c=0
Rk7 (\3\:Eb \4\:Eb) resistor r=0.771 c=0
Rk8 (\4\:Eb \6\:Eb) resistor r=0.1318 c=0
Rk9 (\3\:Eb \8\:Eb) resistor r=0.03276 c=0
Rk10 (\4\:Eb \10\:Eb) resistor r=0.578 c=0
Rk11 (\8\:CKb \9\:CKb) resistor r=0.4779 c=0
Rk12 (\9\:CKb \10\:CKb) resistor r=0.2858 c=0
Rk13 (\9\:CKb \11\:CKb) resistor r=0.3374 c=0
Rk14 (\10\:CKb \13\:CKb) resistor r=0.2398 c=0
Rk15 (\13\:CKb \15\:CKb) resistor r=0.6458 c=0
Rk16 (\4\:n5 \6\:n5) resistor r=1.2303 c=0
Rk17 (\6\:n5 \8\:n5) resistor r=0.565 c=0
Rk24 (\5\:CKbb \17\:CKbb) resistor r=1.0511 c=0
Rk25 (\17\:CKbb \18\:CKbb) resistor r=0.4421 c=0
Rk26 (\18\:CKbb \20\:CKbb) resistor r=0.5519 c=0
Rk19 (\6\:Eint \20\:Eint) resistor r=0.2793 c=0
Rk20 (\20\:Eint \22\:Eint) resistor r=0.07904 c=0
Rk21 (\20\:Eint \24\:Eint) resistor r=0.3136 c=0
Rk22 (\24\:Eint \25\:Eint) resistor r=0.2793 c=0
Rk27 (\32\:ECKb \33\:ECKb) resistor r=0.06154 c=0
Rk28 (\33\:ECKb \34\:ECKb) resistor r=0.3873 c=0
Rk31 (\33\:ECKb \39\:ECKb) resistor r=0.2 c=0
Rk34 (\39\:ECKb \45\:ECKb) resistor r=0.5909 c=0
Rl7 (\2\:CK \3\:CK) resistor r=220.33 c=0
Rl6 (\1\:CK \2\:CK) resistor r=40.3846 c=0
Rl4 (\1\:SE \2\:SE) resistor r=160.771 c=0
Rl5 (\2\:SE \3\:SE) resistor r=95.3867 c=0
Rl1 (\1\:E \2\:E) resistor r=259.924 c=0
Rl3 (\2\:E \4\:E) resistor r=37.2017 c=0
Rl2 (\2\:E \3\:E) resistor r=9.7447 c=0
Rl16 (\5\:CKb \6\:CKb) resistor r=216.873 c=0
Rl17 (\6\:CKb \7\:CKb) resistor r=29.5379 c=0
Rl9 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl8 (CKb \2\:CKb) resistor r=74.2328 c=0
Rl18 (n5 \2\:n5) resistor r=80.7692 c=0
Rl19 (\2\:n5 \3\:n5) resistor r=26.3736 c=0
Rl38 (\5\:CKbb \13\:CKbb) resistor r=31.9251 c=0
Rl25 (\5\:CKbb \9\:CKbb) resistor r=33.8489 c=0
Rl24 (\5\:CKbb \8\:CKbb) resistor r=31.9251 c=0
Rl10 (\2\:CKbb CKbb) resistor r=70.8353 c=0
Rl11 (\2\:CKbb \3\:CKbb) resistor r=167.286 c=0
Rl12 (\2\:CKbb \4\:CKbb) resistor r=67.233 c=0
Rl20 (\6\:Eint \5\:Eint) resistor r=55.7464 c=0
Rl13 (\2\:Eint Eint) resistor r=135.914 c=0
Rl14 (\2\:Eint \3\:Eint) resistor r=196.745 c=0
Rl15 (\2\:Eint \4\:Eint) resistor r=3.7936 c=0
Rl31 (\10\:Eint \13\:Eint) resistor r=28.0797 c=0
Rl28 (\10\:Eint \6\:Eint) resistor r=87.5028 c=0
Rl30 (\11\:Eint \12\:Eint) resistor r=25.0634 c=0
Rl32 (\11\:Eint \6\:Eint) resistor r=28.0958 c=0
Rl29 (\11\:Eint \10\:Eint) resistor r=109.96 c=0
Rl49 (ECKb \12\:ECKb) resistor r=5.6351 c=0
Rz19 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz25 (\29\:VSS \28\:VSS) resistor r=75 c=0
Rz26 (\31\:VSS \30\:VSS) resistor r=75 c=0
Rz27 (\33\:VSS \32\:VSS) resistor r=75 c=0
Rz28 (\35\:VSS \34\:VSS) resistor r=75 c=0
Rz14 (\1\:VDD \3\:VDD) resistor r=3.9474 c=0
Rz16 (\13\:VDD \3\:VDD) resistor r=18.75 c=0
Rz17 (\15\:VDD \3\:VDD) resistor r=8.3333 c=0
Rz1 (Eb \2\:Eb) resistor r=75 c=0
Rz2 (\9\:Eb \10\:Eb) resistor r=75 c=0
Rz3 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz4 (\7\:n5 \8\:n5) resistor r=75 c=0
Rz6 (\17\:CKbb \16\:CKbb) resistor r=75 c=0
Rz5 (\22\:Eint \21\:Eint) resistor r=75 c=0
Rz7 (\39\:ECKb \38\:ECKb) resistor r=75 c=0
Rz8 (\45\:ECKb \44\:ECKb) resistor r=75 c=0
Ry27 (\1\:VSS \4\:VSS) resistor r=7.75 c=0
Ry28 (\10\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry29 (\14\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry25 (\35\:VDD \34\:VDD) resistor r=62 c=0
Ry26 (\37\:VDD \36\:VDD) resistor r=62 c=0
Ry1 (\5\:Eb \6\:Eb) resistor r=62 c=0
Ry2 (\7\:Eb \8\:Eb) resistor r=62 c=0
Ry3 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry4 (\5\:n5 \6\:n5) resistor r=62 c=0
Ry6 (\20\:CKbb \19\:CKbb) resistor r=62 c=0
Ry5 (\24\:Eint \23\:Eint) resistor r=62 c=0
Rx3 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\2\:SE \4\:SE) resistor r=45 c=0
Rx1 (\3\:E \6\:E) resistor r=45 c=0
Rx4 (\4\:CKb \8\:CKb) resistor r=45 c=0
Rx5 (\2\:CKb \10\:CKb) resistor r=45 c=0
Rx6 (\7\:CKb \11\:CKb) resistor r=45 c=0
Rx7 (\2\:n5 \4\:n5) resistor r=45 c=0
Rx13 (\18\:CKbb \4\:CKbb) resistor r=45 c=0
Rx10 (\25\:Eint \4\:Eint) resistor r=45 c=0
Rx14 (\32\:ECKb \12\:ECKb) resistor r=45 c=0
mn1 (\9\:Eb \4\:E \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.61e-14 ps=5.7e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.6e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn0 (\9\:Eb \3\:SE \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.61e-14 ps=7.3e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=4.35e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (\12\:CKb \1\:CK \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.465e-14 ps=7.3e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=1.7e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn5 (Eb CKb \7\:n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=3.48e-14 \
        ad=2.03e-14 ps=7.7e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.1e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn16 (\7\:n5 CKbb net263 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.48e-14 ps=4.1e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=6.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn15 (net263 \3\:Eint \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.398e-14 ad=8.7e-15 ps=1.55e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=5.2e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn3 (\16\:CKbb \6\:CKb \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.398e-14 ad=2.03e-14 ps=1.55e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn10 (\21\:Eint n5 \30\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.56e-14 ad=5.85e-14 ps=1.1e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=1.33e-06 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn20 (16 \5\:Eint \30\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.56e-14 ad=2.47e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.065e-06 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn21 (\44\:ECKb \8\:CKbb 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.47e-14 ad=4.16e-14 ps=7.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=9.25e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn21_1__rcx (\44\:ECKb \9\:CKbb 17 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=7.2e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn20_1__rcx (17 \12\:Eint \28\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.45e-14 ad=1.56e-14 ps=1.17e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=6.15e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn20_2__rcx (18 \13\:Eint \28\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.45e-14 ad=1.56e-14 ps=1.17e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31e-06 sb=2.45e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn21_2__rcx (\38\:ECKb \13\:CKbb 18 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.415e-06 sb=1.4e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn22_1__rcx (ECK ECKb \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.836e-14 ad=4.96e-14 ps=9.32e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.985e-06 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(10)
mp0 (net246 \1\:SE \36\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=1.29e-14 ps=7.6e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.6e-07 sd=160n sca=14.2155 \
        scb=0.0125694 scc=0.000239267 m=(1)
mp2 (\14\:CKb \3\:CK \36\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=5.375e-14 ps=7.6e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=2.5e-07 sd=160n sca=12.3184 \
        scb=0.0100356 scc=0.000221045 m=(1)
mp5 (\5\:n5 \3\:CKbb \7\:Eb VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=3.44e-14 ps=8.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=8.6e-07 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp16 (\5\:n5 \3\:CKb net234 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=6.55e-07 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp15 (net234 Eint \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0667e-13 ad=1.29e-14 ps=1.63e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=5.5e-07 sd=160n sca=10.2815 scb=0.00760864 \
        scc=8.81378e-05 m=(1)
mp3 (\19\:CKbb \5\:CKb \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.0667e-13 ad=3.01e-14 ps=1.63e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=1.4e-07 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp10 (\23\:Eint \3\:n5 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.76e-14 ps=1.1e-06 pd=1.29e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.47692e-07 sb=1.78269e-06 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(1)
mp20_1__rcx (\34\:ECKb \6\:Eint \1\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=7.93e-14 ad=7.1e-14 ps=1.18667e-06 pd=1.18e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.52692e-07 sb=1.75641e-06 sd=160n \
        sca=15.8351 scb=0.0142471 scc=0.00110276 m=(3)
mp21 (\34\:ECKb \5\:CKbb \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.807e-14 ad=7.1e-14 ps=1.22e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.46282e-07 sb=2e-06 sd=160n sca=12.8992 \
        scb=0.0114532 scc=0.000515529 m=(3)
mp22_1__rcx (ECK ECKb \1\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.768e-14 ad=7.52e-14 ps=1.276e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.45777e-06 sb=1.985e-06 sd=160n sca=17.506 \
        scb=0.014809 scc=0.00143528 m=(10)
ends TLATNTSCAX12
// End of subcircuit definition.

// Generated for: spectre (May  9 18:28:34 2012 )
// Library name: gsclib045
// Cell name: TLATNTSCAX16
// View name: extracted

simulator lang=spectre

subckt TLATNTSCAX16 CK E ECK SE VDD VSS
mp1 (\6\:Eb \1\:E net246 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.74186e-07 sd=160n sca=21.6445 \
        scb=0.0248175 scc=0.000977801 m=(1)
C1 (CK VSS) capacitor c=8.6328e-17
C2 (VDD VSS) capacitor c=4.32286e-16
C3 (SE VSS) capacitor c=9.21178e-17
C4 (E VSS) capacitor c=5.53884e-17
C5 (ECK VSS) capacitor c=9.84952e-16
C6 (Eb VSS) capacitor c=7.51078e-17
C7 (CKb VSS) capacitor c=1.87967e-17
C8 (n5 VSS) capacitor c=8.0736e-17
C9 (net263 VSS) capacitor c=1.9635e-18
C10 (CKbb VSS) capacitor c=3.34778e-17
C11 (Eint VSS) capacitor c=4.09264e-17
C12 (ECKb VSS) capacitor c=6.9656e-16
C13 (17 VSS) capacitor c=3.7193e-18
C14 (18 VSS) capacitor c=1.79722e-18
C15 (19 VSS) capacitor c=2.59478e-18
C16 (net246 VSS) capacitor c=1.43799e-18
C17 (net234 VSS) capacitor c=1.33795e-18
C18 (\5\:CKb VSS) capacitor c=6.4608e-17
C19 (\3\:Eint VSS) capacitor c=9.82125e-17
C20 (\3\:CKb VSS) capacitor c=7.11737e-17
C21 (\3\:CKbb VSS) capacitor c=5.81446e-17
C22 (\1\:CK VSS) capacitor c=4.41636e-17
C23 (\3\:SE VSS) capacitor c=8.99483e-17
C24 (\1\:E VSS) capacitor c=5.65319e-17
C25 (\15\:Eint VSS) capacitor c=6.70468e-17
C26 (\14\:CKbb VSS) capacitor c=3.50791e-17
C27 (\13\:CKbb VSS) capacitor c=4.6026e-17
C28 (\7\:Eint VSS) capacitor c=6.06655e-17
C29 (\11\:Eint VSS) capacitor c=3.88115e-17
C30 (\4\:CKbb VSS) capacitor c=4.55835e-17
C31 (\6\:CKbb VSS) capacitor c=4.66411e-17
C32 (\4\:Eint VSS) capacitor c=8.66323e-17
C33 (\6\:CKb VSS) capacitor c=3.64595e-17
C34 (\3\:CK VSS) capacitor c=2.81568e-17
C35 (\1\:SE VSS) capacitor c=3.16034e-17
C36 (\4\:E VSS) capacitor c=5.0835e-17
C37 (\5\:CKbb VSS) capacitor c=5.8499e-16
C38 (\5\:Eint VSS) capacitor c=6.67567e-16
C39 (\7\:CKb VSS) capacitor c=1.60325e-17
C40 (\2\:Eint VSS) capacitor c=6.45068e-17
C41 (\2\:CKbb VSS) capacitor c=8.12652e-17
C42 (\4\:CKb VSS) capacitor c=5.53778e-17
C43 (\2\:CKb VSS) capacitor c=1.94455e-17
C44 (\2\:CK VSS) capacitor c=4.41005e-17
C45 (\2\:SE VSS) capacitor c=7.20446e-17
C46 (\3\:E VSS) capacitor c=1.3957e-17
C47 (\1\:VDD VSS) capacitor c=1.0191e-15
C48 (\56\:ECKb VSS) capacitor c=4.08893e-16
C49 (\22\:Eint VSS) capacitor c=6.96848e-17
C50 (\21\:CKbb VSS) capacitor c=1.02182e-16
C51 (\46\:VDD VSS) capacitor c=4.01244e-17
C52 (\12\:n5 VSS) capacitor c=1.74554e-16
C53 (\3\:Eb VSS) capacitor c=1.30131e-16
C54 (\15\:CKb VSS) capacitor c=1.02709e-16
C55 (\48\:VDD VSS) capacitor c=5.2662e-17
C56 (\6\:Eb VSS) capacitor c=2.60762e-17
C57 (\5\:VDD VSS) capacitor c=7.26773e-17
C58 (\64\:ECKb VSS) capacitor c=9.81304e-17
C59 (\70\:ECKb VSS) capacitor c=8.21529e-17
C60 (\24\:Eint VSS) capacitor c=4.27825e-17
C61 (\18\:CKbb VSS) capacitor c=1.61422e-16
C62 (\10\:n5 VSS) capacitor c=8.48586e-17
C63 (\12\:CKb VSS) capacitor c=2.56793e-17
C64 (\8\:Eb VSS) capacitor c=9.13544e-17
C65 (\2\:E VSS) capacitor c=5.02384e-17
C66 (\3\:n5 VSS) capacitor c=8.66333e-17
C67 (\5\:E VSS) capacitor c=4.62373e-17
C68 (\4\:SE VSS) capacitor c=4.71792e-17
C69 (\4\:CK VSS) capacitor c=4.3098e-17
C70 (\5\:Eb VSS) capacitor c=1.49372e-16
C71 (\8\:CKb VSS) capacitor c=1.0773e-16
C72 (\9\:CKb VSS) capacitor c=9.09281e-17
C73 (\10\:CKb VSS) capacitor c=5.04552e-17
C74 (\11\:CKb VSS) capacitor c=7.89207e-17
C75 (\14\:CKb VSS) capacitor c=7.4239e-17
C76 (\8\:n5 VSS) capacitor c=1.2693e-16
C77 (\20\:CKbb VSS) capacitor c=1.40182e-16
C78 (\19\:Eint VSS) capacitor c=2.97148e-17
C79 (\20\:Eint VSS) capacitor c=7.71097e-17
C80 (\21\:Eint VSS) capacitor c=1.00191e-16
C81 (\59\:ECKb VSS) capacitor c=9.24487e-17
C82 (\19\:VDD VSS) capacitor c=1.9168e-17
C83 (\21\:VDD VSS) capacitor c=1.90341e-17
Rk3 (CK \4\:CK) resistor r=0.09313 c=0
Rk74 (\1\:VDD \19\:VDD) resistor r=0.3056 c=0
Rk75 (\19\:VDD \20\:VDD) resistor r=0.2481 c=0
Rk77 (\21\:VDD VDD) resistor r=0.1952 c=0
Rk76 (\20\:VDD \21\:VDD) resistor r=0.356 c=0
Rk90 (\19\:VDD \47\:VDD) resistor r=0.2266 c=0
Rk91 (\21\:VDD \49\:VDD) resistor r=0.295 c=0
Rk101 (\1\:VSS \13\:VSS) resistor r=0.3533 c=0
Rk102 (\13\:VSS \14\:VSS) resistor r=0.1679 c=0
Rk103 (\14\:VSS \15\:VSS) resistor r=0.1528 c=0
Rk105 (\15\:VSS \17\:VSS) resistor r=0.2821 c=0
Rk106 (\17\:VSS \18\:VSS) resistor r=0.3735 c=0
Rk108 (\19\:VSS VSS) resistor r=0.2284 c=0
Rk107 (\18\:VSS \19\:VSS) resistor r=0.3234 c=0
Rk109 (VSS \21\:VSS) resistor r=0.1797 c=0
Rk117 (\13\:VSS \37\:VSS) resistor r=0.2601 c=0
Rk120 (\17\:VSS \43\:VSS) resistor r=0.1229 c=0
Rk121 (\19\:VSS \45\:VSS) resistor r=0.1816 c=0
Rk2 (SE \4\:SE) resistor r=0.09313 c=0
Rk1 (E \5\:E) resistor r=0.08156 c=0
Rk4 (\2\:Eb \4\:Eb) resistor r=0.5484 c=0
Rk5 (\4\:Eb \5\:Eb) resistor r=0.7217 c=0
Rk6 (\5\:Eb \7\:Eb) resistor r=0.1755 c=0
Rk7 (\5\:Eb \9\:Eb) resistor r=0.577 c=0
Rk8 (\8\:CKb \9\:CKb) resistor r=0.5513 c=0
Rk9 (\9\:CKb \10\:CKb) resistor r=0.1623 c=0
Rk10 (\10\:CKb \11\:CKb) resistor r=0.2864 c=0
Rk11 (\11\:CKb \13\:CKb) resistor r=0.05533 c=0
Rk12 (\9\:CKb \14\:CKb) resistor r=0.5877 c=0
Rk13 (\11\:CKb \16\:CKb) resistor r=0.5857 c=0
Rk14 (\8\:n5 \9\:n5) resistor r=0.9943 c=0
Rk15 (\9\:n5 \11\:n5) resistor r=0.5515 c=0
Rk16 (\9\:n5 \13\:n5) resistor r=0.02462 c=0
Rk18 (\5\:CKbb \19\:CKbb) resistor r=1.0401 c=0
Rk19 (\19\:CKbb \20\:CKbb) resistor r=0.6329 c=0
Rk20 (\20\:CKbb \22\:CKbb) resistor r=0.5273 c=0
Rk23 (\5\:Eint \19\:Eint) resistor r=0.1784 c=0
Rk24 (\19\:Eint \20\:Eint) resistor r=0.04306 c=0
Rk25 (\20\:Eint \21\:Eint) resistor r=0.6125 c=0
Rk26 (\19\:Eint \23\:Eint) resistor r=0.3377 c=0
Rk27 (\20\:Eint \25\:Eint) resistor r=0.1622 c=0
Rk29 (\56\:ECKb \59\:ECKb) resistor r=0.403 c=0
Rk33 (\59\:ECKb \65\:ECKb) resistor r=0.417 c=0
Rk36 (\65\:ECKb \71\:ECKb) resistor r=0.4983 c=0
Rl6 (\1\:CK \2\:CK) resistor r=208.384 c=0
Rl7 (\2\:CK \3\:CK) resistor r=39.1533 c=0
Rl5 (\2\:SE \3\:SE) resistor r=236.093 c=0
Rl4 (\1\:SE \2\:SE) resistor r=37.6944 c=0
Rl1 (\1\:E \2\:E) resistor r=74.5896 c=0
Rl3 (\2\:E \4\:E) resistor r=192.814 c=0
Rl2 (\2\:E \3\:E) resistor r=7.6506 c=0
Rl14 (\5\:CKb \6\:CKb) resistor r=168.796 c=0
Rl15 (\6\:CKb \7\:CKb) resistor r=35.3072 c=0
Rl9 (\3\:CKb \4\:CKb) resistor r=60.3072 c=0
Rl8 (CKb \2\:CKb) resistor r=93.4636 c=0
Rl17 (\3\:n5 n5) resistor r=77.3132 c=0
Rl37 (\5\:CKbb \14\:CKbb) resistor r=30.0028 c=0
Rl36 (\5\:CKbb \13\:CKbb) resistor r=29.579 c=0
Rl24 (\5\:CKbb \4\:CKbb) resistor r=85.3597 c=0
Rl25 (\5\:CKbb \6\:CKbb) resistor r=28.5806 c=0
Rl10 (\2\:CKbb CKbb) resistor r=45.9489 c=0
Rl11 (\2\:CKbb \3\:CKbb) resistor r=234.593 c=0
Rl40 (\5\:Eint \15\:Eint) resistor r=90.1797 c=0
Rl29 (\5\:Eint \7\:Eint) resistor r=124.51 c=0
Rl32 (\5\:Eint \11\:Eint) resistor r=94.6154 c=0
Rl22 (\5\:Eint \4\:Eint) resistor r=153.412 c=0
Rl12 (\2\:Eint Eint) resistor r=41.0764 c=0
Rl13 (\2\:Eint \3\:Eint) resistor r=182.95 c=0
Rz16 (\1\:VDD \5\:VDD) resistor r=2.8846 c=0
Rz19 (\20\:VDD \5\:VDD) resistor r=6.25 c=0
Rz21 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz29 (\37\:VSS \36\:VSS) resistor r=75 c=0
Rz32 (\43\:VSS \42\:VSS) resistor r=75 c=0
Rz33 (\45\:VSS \44\:VSS) resistor r=75 c=0
Rz1 (Eb \2\:Eb) resistor r=75 c=0
Rz2 (\8\:Eb \9\:Eb) resistor r=75 c=0
Rz3 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz4 (\11\:n5 \10\:n5) resistor r=75 c=0
Rz5 (\19\:CKbb \18\:CKbb) resistor r=75 c=0
Rz6 (\25\:Eint \24\:Eint) resistor r=75 c=0
Rz7 (\65\:ECKb \64\:ECKb) resistor r=75 c=0
Rz8 (\71\:ECKb \70\:ECKb) resistor r=75 c=0
Ry31 (\47\:VDD \46\:VDD) resistor r=62 c=0
Ry32 (\49\:VDD \48\:VDD) resistor r=62 c=0
Ry35 (\14\:VSS \1\:VSS) resistor r=6.2 c=0
Ry36 (\18\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\3\:Eb \4\:Eb) resistor r=62 c=0
Ry2 (\6\:Eb \7\:Eb) resistor r=62 c=0
Ry3 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry4 (\13\:n5 \12\:n5) resistor r=62 c=0
Ry5 (\22\:CKbb \21\:CKbb) resistor r=62 c=0
Ry6 (\23\:Eint \22\:Eint) resistor r=31 c=0
Rx3 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\2\:SE \4\:SE) resistor r=45 c=0
Rx1 (\3\:E \5\:E) resistor r=45 c=0
Rx4 (\4\:CKb \8\:CKb) resistor r=45 c=0
Rx5 (\2\:CKb \10\:CKb) resistor r=45 c=0
Rx6 (\7\:CKb \14\:CKb) resistor r=45 c=0
Rx7 (\8\:n5 \3\:n5) resistor r=45 c=0
Rx10 (\20\:CKbb \2\:CKbb) resistor r=45 c=0
Rx14 (\21\:Eint \2\:Eint) resistor r=45 c=0
Rx15 (\59\:ECKb ECKb) resistor r=45 c=0
mn1 (\8\:Eb \4\:E \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.61e-14 ps=5.7e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.75e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn0 (\8\:Eb \1\:SE \44\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.393e-14 ad=2.61e-14 ps=6.2e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=3.5e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (\12\:CKb \3\:CK \44\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.393e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn5 (Eb CKb \10\:n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.075e-14 ad=2.03e-14 ps=9.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.075e-06 sd=160n sca=20.6444 \
        scb=0.0212501 scc=0.00213091 m=(1)
mn16 (\10\:n5 CKbb net263 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.668e-14 ad=5.075e-14 ps=5.2e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=6.8e-07 sd=160n sca=20.6444 \
        scb=0.0212501 scc=0.00213091 m=(1)
mn15 (net263 Eint \42\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.14e-14 ad=1.667e-14 ps=1.53e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=5.2e-07 sd=160n sca=20.6444 \
        scb=0.0212501 scc=0.00213091 m=(1)
mn3 (\18\:CKbb \6\:CKb \42\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.14e-14 ad=2.827e-14 ps=1.53e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02e-06 sb=1.95e-07 sd=160n sca=20.6444 \
        scb=0.0212501 scc=0.00213091 m=(1)
mn10_1__rcx (\24\:Eint n5 \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.21e-14 ad=3.28e-14 ps=1.35e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.71061e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(2)
mn20_1__rcx (16 \4\:Eint \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.435e-14 ad=1.56e-14 ps=1.2e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.08654e-07 sb=2e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn21_1__rcx (\70\:ECKb \6\:CKbb 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.13654e-07 sb=2e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn21 (\70\:ECKb \4\:CKbb 17 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.86e-14 ad=4.16e-14 ps=7.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.18654e-07 sb=2e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn20 (17 \11\:Eint \36\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=2.86e-14 ps=8.4e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.73654e-07 sb=2e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn20_2__rcx (18 \7\:Eint \36\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17865e-06 sb=2e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn21_2__rcx (\64\:ECKb \13\:CKbb 18 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28365e-06 sb=2e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn21_3__rcx (\64\:ECKb \14\:CKbb 19 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=2.34e-14 ad=4.16e-14 ps=7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48865e-06 sb=2e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn20_3__rcx (19 \15\:Eint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.16e-14 ad=2.34e-14 ps=9.6e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.62365e-06 sb=2e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn22_1__rcx (ECK ECKb \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.709e-14 ad=4.72e-14 ps=9.1071e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.60525e-06 sb=2e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(14)
mp0 (net246 \3\:SE \48\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=1.29e-14 ps=9.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.69186e-07 sd=160n sca=17.1049 \
        scb=0.017493 scc=0.000461861 m=(1)
mp2 (\15\:CKb \1\:CK \48\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=3.53e-14 ps=9.5e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.64186e-07 sd=160n sca=13.2687 \
        scb=0.0115749 scc=0.000361009 m=(1)
mp5 (\12\:n5 \3\:CKbb \3\:Eb VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.65e-14 ad=3.44e-14 ps=8.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69767e-07 sb=5.56047e-07 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp16 (\12\:n5 \3\:CKb net234 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.74767e-07 sb=3.51047e-07 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp15 (net234 \3\:Eint \46\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.73e-14 ad=1.29e-14 ps=1.41e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.79767e-07 sb=2.46047e-07 sd=160n sca=10.2815 \
        scb=0.00760864 scc=8.81378e-05 m=(1)
mp3 (\21\:CKbb \5\:CKb \46\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.73e-14 ad=3.01e-14 ps=1.41e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.92558e-07 sb=1.4e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp10 (\22\:Eint \3\:n5 \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.415e-14 ad=4.96e-14 ps=1.355e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=11.3312 scb=0.00941412 \
        scc=0.000228915 m=(2)
mp20_1__rcx (\56\:ECKb \5\:Eint \1\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=7.033e-14 ad=6.24e-14 ps=1.1775e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=5.61026e-07 sb=2e-06 sd=160n \
        sca=13.5671 scb=0.012183 scc=0.000647513 m=(4)
mp21_1__rcx (\56\:ECKb \5\:CKbb \1\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=7.66026e-07 sb=2e-06 sd=160n \
        sca=13.5671 scb=0.012183 scc=0.000647513 m=(4)
mp22_1__rcx (ECK ECKb \1\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.033e-14 ad=7.12e-14 ps=1.20714e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.71843e-06 sb=2e-06 sd=160n sca=16.8284 \
        scb=0.0145775 scc=0.00130846 m=(14)
ends TLATNTSCAX16
// End of subcircuit definition.

// Generated for: spectre (May  9 18:29:13 2012 )
// Library name: gsclib045
// Cell name: TLATNTSCAX2
// View name: extracted

simulator lang=spectre

subckt TLATNTSCAX2 CK E ECK SE VDD VSS
mp1 (\4\:Eb \1\:E net246 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.65e-07 sd=160n sca=16.5928 \
        scb=0.0167268 scc=0.000352369 m=(1)
C1 (CK VSS) capacitor c=1.3319e-16
C2 (VDD VSS) capacitor c=2.51743e-16
C3 (ECK VSS) capacitor c=4.55021e-17
C4 (Eb VSS) capacitor c=9.10593e-17
C5 (CKb VSS) capacitor c=2.46288e-17
C6 (n5 VSS) capacitor c=3.11236e-17
C7 (net263 VSS) capacitor c=1.44726e-18
C8 (CKbb VSS) capacitor c=3.32832e-17
C9 (Eint VSS) capacitor c=5.05882e-17
C10 (ECKb VSS) capacitor c=1.24802e-16
C11 (net234 VSS) capacitor c=2.53537e-18
C12 (\4\:CKbb VSS) capacitor c=5.40965e-17
C13 (\5\:Eint VSS) capacitor c=3.41762e-17
C14 (\5\:CKb VSS) capacitor c=5.80687e-17
C15 (\3\:Eint VSS) capacitor c=7.32311e-17
C16 (\3\:CKb VSS) capacitor c=7.05975e-17
C17 (\3\:CKbb VSS) capacitor c=6.96358e-17
C18 (\1\:CK VSS) capacitor c=4.99973e-17
C19 (\1\:SE VSS) capacitor c=8.36086e-17
C20 (\1\:E VSS) capacitor c=9.0124e-17
C21 (\5\:CKbb VSS) capacitor c=4.92902e-17
C22 (\7\:Eint VSS) capacitor c=5.01828e-17
C23 (\3\:n5 VSS) capacitor c=4.36087e-17
C24 (\6\:CKb VSS) capacitor c=3.72527e-17
C25 (\3\:CK VSS) capacitor c=3.78389e-17
C26 (\3\:SE VSS) capacitor c=4.0005e-17
C27 (\4\:E VSS) capacitor c=2.94917e-17
C28 (\5\:ECKb VSS) capacitor c=1.70585e-17
C29 (\6\:CKbb VSS) capacitor c=2.67475e-17
C30 (\6\:Eint VSS) capacitor c=3.19745e-17
C31 (\2\:n5 VSS) capacitor c=2.20664e-17
C32 (\7\:CKb VSS) capacitor c=2.09026e-17
C33 (\4\:Eint VSS) capacitor c=2.75039e-17
C34 (\2\:CKbb VSS) capacitor c=7.5905e-17
C35 (\4\:CKb VSS) capacitor c=5.54056e-17
C36 (\2\:CKb VSS) capacitor c=2.00052e-17
C37 (\2\:CK VSS) capacitor c=4.84094e-17
C38 (\2\:SE VSS) capacitor c=8.33523e-17
C39 (\3\:E VSS) capacitor c=1.25314e-17
C40 (\1\:VDD VSS) capacitor c=1.05072e-16
C41 (\1\:ECK VSS) capacitor c=1.0463e-16
C42 (\11\:ECKb VSS) capacitor c=3.50496e-17
C43 (\13\:VDD VSS) capacitor c=5.2203e-17
C44 (\10\:Eint VSS) capacitor c=6.17987e-17
C45 (\11\:CKbb VSS) capacitor c=1.21046e-16
C46 (\15\:VDD VSS) capacitor c=3.49108e-17
C47 (\5\:n5 VSS) capacitor c=2.18405e-16
C48 (\6\:Eb VSS) capacitor c=1.4472e-16
C49 (\15\:CKb VSS) capacitor c=1.14099e-16
C50 (\17\:VDD VSS) capacitor c=4.65692e-17
C51 (\4\:Eb VSS) capacitor c=9.72735e-18
C52 (\3\:VDD VSS) capacitor c=8.49455e-17
C53 (\13\:ECKb VSS) capacitor c=2.97182e-17
C54 (\12\:Eint VSS) capacitor c=3.05573e-17
C55 (\8\:CKbb VSS) capacitor c=1.62062e-16
C56 (\7\:n5 VSS) capacitor c=1.09477e-16
C57 (\8\:Eb VSS) capacitor c=1.10751e-16
C58 (\12\:CKb VSS) capacitor c=2.5206e-17
C59 (\2\:E VSS) capacitor c=5.96186e-17
C60 (\2\:Eint VSS) capacitor c=5.81725e-17
C61 (\5\:E VSS) capacitor c=3.43129e-17
C62 (\7\:E VSS) capacitor c=6.64912e-17
C63 (\4\:SE VSS) capacitor c=1.36667e-16
C64 (\3\:Eb VSS) capacitor c=1.60961e-16
C65 (\8\:CKb VSS) capacitor c=1.63258e-16
C66 (\9\:CKb VSS) capacitor c=1.20986e-16
C67 (\10\:CKb VSS) capacitor c=3.4868e-17
C68 (\11\:CKb VSS) capacitor c=8.70635e-17
C69 (\14\:CKb VSS) capacitor c=9.20285e-17
C70 (\4\:n5 VSS) capacitor c=1.29287e-16
C71 (\8\:Eint VSS) capacitor c=3.7108e-17
C72 (\9\:Eint VSS) capacitor c=3.61434e-17
C73 (\14\:Eint VSS) capacitor c=9.15827e-17
C74 (\7\:CKbb VSS) capacitor c=7.32826e-17
C75 (\10\:CKbb VSS) capacitor c=1.6014e-16
C76 (\9\:ECKb VSS) capacitor c=1.92025e-17
C77 (\10\:ECKb VSS) capacitor c=2.38956e-17
C78 (\6\:VDD VSS) capacitor c=2.11107e-17
C79 (\8\:VDD VSS) capacitor c=3.70403e-17
C80 (\10\:VDD VSS) capacitor c=2.2317e-17
Rk5 (CK \4\:CK) resistor r=0.003006 c=0
Rk4 (\4\:SE SE) resistor r=0.003006 c=0
Rk46 (\1\:VDD \6\:VDD) resistor r=0.2229 c=0
Rk47 (\6\:VDD \7\:VDD) resistor r=0.07005 c=0
Rk48 (\7\:VDD \8\:VDD) resistor r=0.4162 c=0
Rk49 (\8\:VDD \9\:VDD) resistor r=0.2356 c=0
Rk51 (\10\:VDD VDD) resistor r=0.2253 c=0
Rk50 (\9\:VDD \10\:VDD) resistor r=0.3259 c=0
Rk53 (\6\:VDD \14\:VDD) resistor r=0.4307 c=0
Rk54 (\8\:VDD \16\:VDD) resistor r=0.1029 c=0
Rk55 (\10\:VDD \18\:VDD) resistor r=0.2845 c=0
Rk1 (\5\:E \6\:E) resistor r=0.00514 c=0
Rk2 (E \7\:E) resistor r=0.005066 c=0
Rk3 (\5\:E \7\:E) resistor r=0.04072 c=0
Rk28 (\2\:ECK ECK) resistor r=0.3743 c=0
Rk29 (ECK \4\:ECK) resistor r=0.0029 c=0
Rk32 (\1\:VSS \6\:VSS) resistor r=0.09764 c=0
Rk33 (\6\:VSS \7\:VSS) resistor r=0.1007 c=0
Rk34 (\7\:VSS \8\:VSS) resistor r=0.2512 c=0
Rk35 (\8\:VSS \9\:VSS) resistor r=0.2206 c=0
Rk36 (\9\:VSS \10\:VSS) resistor r=0.4313 c=0
Rk38 (\11\:VSS VSS) resistor r=0.2259 c=0
Rk37 (\10\:VSS \11\:VSS) resistor r=0.1754 c=0
Rk39 (VSS \13\:VSS) resistor r=0.1799 c=0
Rk41 (\7\:VSS \17\:VSS) resistor r=0.1206 c=0
Rk42 (\9\:VSS \19\:VSS) resistor r=0.4317 c=0
Rk43 (\11\:VSS \21\:VSS) resistor r=0.1824 c=0
Rk6 (\2\:Eb \3\:Eb) resistor r=0.5812 c=0
Rk7 (\3\:Eb \5\:Eb) resistor r=0.1352 c=0
Rk8 (\3\:Eb \7\:Eb) resistor r=0.7285 c=0
Rk9 (\7\:Eb \9\:Eb) resistor r=0.6692 c=0
Rk10 (\8\:CKb \9\:CKb) resistor r=1.133 c=0
Rk11 (\9\:CKb \10\:CKb) resistor r=0.1779 c=0
Rk12 (\10\:CKb \11\:CKb) resistor r=0.2197 c=0
Rk13 (\11\:CKb \13\:CKb) resistor r=0.05534 c=0
Rk14 (\9\:CKb \14\:CKb) resistor r=0.5919 c=0
Rk15 (\11\:CKb \16\:CKb) resistor r=0.6745 c=0
Rk16 (\4\:n5 \6\:n5) resistor r=1.0584 c=0
Rk17 (\6\:n5 \8\:n5) resistor r=0.6524 c=0
Rk22 (\7\:CKbb \9\:CKbb) resistor r=0.6176 c=0
Rk23 (\9\:CKbb \10\:CKbb) resistor r=0.713 c=0
Rk24 (\10\:CKbb \12\:CKbb) resistor r=0.61 c=0
Rk18 (\8\:Eint \9\:Eint) resistor r=0.209 c=0
Rk19 (\9\:Eint \11\:Eint) resistor r=0.2238 c=0
Rk20 (\9\:Eint \13\:Eint) resistor r=0.1352 c=0
Rk21 (\11\:Eint \14\:Eint) resistor r=0.4754 c=0
Rk25 (\9\:ECKb \10\:ECKb) resistor r=0.05321 c=0
Rk26 (\10\:ECKb \12\:ECKb) resistor r=0.1336 c=0
Rk27 (\10\:ECKb \14\:ECKb) resistor r=0.1116 c=0
Rl6 (\1\:CK \2\:CK) resistor r=158.384 c=0
Rl7 (\2\:CK \3\:CK) resistor r=100.692 c=0
Rl4 (\1\:SE \2\:SE) resistor r=158.79 c=0
Rl5 (\2\:SE \3\:SE) resistor r=93.4057 c=0
Rl1 (\1\:E \2\:E) resistor r=234.924 c=0
Rl3 (\2\:E \4\:E) resistor r=60.2786 c=0
Rl2 (\2\:E \3\:E) resistor r=5.1011 c=0
Rl15 (\5\:CKb \6\:CKb) resistor r=228.846 c=0
Rl16 (\6\:CKb \7\:CKb) resistor r=29.5379 c=0
Rl9 (\3\:CKb \4\:CKb) resistor r=62.6944 c=0
Rl8 (CKb \2\:CKb) resistor r=79.5379 c=0
Rl18 (n5 \3\:n5) resistor r=98.0769 c=0
Rl17 (n5 \2\:n5) resistor r=48.7687 c=0
Rl21 (\4\:CKbb \5\:CKbb) resistor r=113.027 c=0
Rl22 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl10 (CKbb \2\:CKbb) resistor r=76.1559 c=0
Rl11 (\2\:CKbb \3\:CKbb) resistor r=228.4 c=0
Rl19 (\5\:Eint \6\:Eint) resistor r=42.9995 c=0
Rl20 (\6\:Eint \7\:Eint) resistor r=29.5379 c=0
Rl12 (Eint \2\:Eint) resistor r=137.202 c=0
Rl13 (\2\:Eint \3\:Eint) resistor r=119.539 c=0
Rl14 (\2\:Eint \4\:Eint) resistor r=8.149 c=0
Rl26 (ECKb \5\:ECKb) resistor r=8.6997 c=0
Rz15 (\1\:VDD \3\:VDD) resistor r=12.5 c=0
Rz16 (\7\:VDD \3\:VDD) resistor r=75 c=0
Rz17 (\9\:VDD \3\:VDD) resistor r=6.25 c=0
Rz8 (\4\:ECK \3\:ECK) resistor r=75 c=0
Rz10 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz12 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz13 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz14 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz1 (Eb \2\:Eb) resistor r=75 c=0
Rz2 (\8\:Eb \9\:Eb) resistor r=75 c=0
Rz3 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz4 (\7\:n5 \8\:n5) resistor r=75 c=0
Rz6 (\8\:CKbb \9\:CKbb) resistor r=75 c=0
Rz5 (\12\:Eint \13\:Eint) resistor r=75 c=0
Rz7 (\14\:ECKb \13\:ECKb) resistor r=75 c=0
Ry16 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry17 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry18 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry8 (\2\:ECK \1\:ECK) resistor r=20.6667 c=0
Ry9 (\1\:VSS \3\:VSS) resistor r=15.5 c=0
Ry10 (\6\:VSS \3\:VSS) resistor r=62 c=0
Ry11 (\7\:VSS \3\:VSS) resistor r=62 c=0
Ry12 (\8\:VSS \3\:VSS) resistor r=15.5 c=0
Ry13 (\10\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry1 (\4\:Eb \5\:Eb) resistor r=62 c=0
Ry2 (\6\:Eb \7\:Eb) resistor r=62 c=0
Ry3 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry4 (\5\:n5 \6\:n5) resistor r=62 c=0
Ry6 (\11\:CKbb \12\:CKbb) resistor r=62 c=0
Ry5 (\10\:Eint \11\:Eint) resistor r=62 c=0
Ry7 (\12\:ECKb \11\:ECKb) resistor r=62 c=0
Rx3 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\2\:SE \4\:SE) resistor r=45 c=0
Rx1 (\3\:E \6\:E) resistor r=45 c=0
Rx4 (\7\:CKb \8\:CKb) resistor r=45 c=0
Rx5 (\2\:CKb \10\:CKb) resistor r=45 c=0
Rx6 (\4\:CKb \14\:CKb) resistor r=45 c=0
Rx7 (\2\:n5 \4\:n5) resistor r=45 c=0
Rx10 (\6\:CKbb \7\:CKbb) resistor r=45 c=0
Rx11 (\2\:CKbb \10\:CKbb) resistor r=45 c=0
Rx8 (\6\:Eint \8\:Eint) resistor r=45 c=0
Rx9 (\4\:Eint \14\:Eint) resistor r=45 c=0
Rx12 (\9\:ECKb \5\:ECKb) resistor r=45 c=0
mn1 (Eb \4\:E \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.537e-14 ps=5.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.75e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn0 (Eb \3\:SE \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.537e-14 ps=6.3e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=3.55e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (\12\:CKb \3\:CK \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.03e-14 ps=6.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn5 (\8\:Eb CKb \7\:n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.365e-14 ad=2.03e-14 ps=1.03e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.085e-06 sd=160n sca=20.6444 \
        scb=0.0212501 scc=0.00213091 m=(1)
mn16 (\7\:n5 CKbb net263 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=5.365e-14 ps=5.6e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=6.7e-07 sd=160n sca=20.6444 \
        scb=0.0212501 scc=0.00213091 m=(1)
mn15 (net263 Eint \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.972e-14 ad=1.957e-14 ps=7e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=4.9e-07 sd=160n sca=20.6444 \
        scb=0.0212501 scc=0.00213091 m=(1)
mn3 (\8\:CKbb \6\:CKb \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.972e-14 ad=3.48e-14 ps=7e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=2.4e-07 sd=160n sca=20.6444 \
        scb=0.0212501 scc=0.00213091 m=(1)
mn10 (\12\:Eint \3\:n5 \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.01e-14 ad=2.392e-14 ps=1.72e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=4.95e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (net271 \7\:Eint \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.01e-14 ad=1.087e-14 ps=1.72e-06 pd=4.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=2.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21 (\13\:ECKb \5\:CKbb net271 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.087e-14 ad=2.03e-14 ps=4.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn22 (\3\:ECK ECKb \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.16e-14 ps=1.15e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.45e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(2)
mp0 (net246 \1\:SE \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=1.29e-14 ps=7.7e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.6e-07 sd=160n sca=14.2912 \
        scb=0.0126949 scc=0.000241023 m=(1)
mp2 (\15\:CKb \1\:CK \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=5.268e-14 ps=7.7e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=2.45e-07 sd=160n sca=12.3184 \
        scb=0.0100356 scc=0.000221045 m=(1)
mp5 (\5\:n5 \3\:CKbb \6\:Eb VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.44e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.2e-07 sb=8.6e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp16 (\5\:n5 \3\:CKb net234 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=6.55e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp15 (net234 \3\:Eint \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.947e-14 ad=1.29e-14 ps=1.51e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=5.5e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp3 (\11\:CKbb \5\:CKb \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.947e-14 ad=3.01e-14 ps=1.51e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=1.4e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp10 (\10\:Eint n5 \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=3.01e-14 ps=8.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.025e-06 sd=160n sca=37.431 \
        scb=0.0268495 scc=0.00487383 m=(1)
mp20 (\11\:ECKb \5\:Eint \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.085e-14 ad=3.44e-14 ps=8.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=7.9e-07 sd=160n sca=37.431 \
        scb=0.0268495 scc=0.00487383 m=(1)
mp21 (\11\:ECKb \4\:CKbb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.943e-14 ad=3.44e-14 ps=1.17e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=5.85e-07 sd=160n sca=37.6758 \
        scb=0.0269122 scc=0.00487384 m=(1)
mp22 (\1\:ECK ECKb \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.701e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.96923e-07 sb=3.45e-07 sd=160n sca=31.7575 \
        scb=0.0209755 scc=0.00336197 m=(2)
ends TLATNTSCAX2
// End of subcircuit definition.

// Generated for: spectre (May  9 18:30:00 2012 )
// Library name: gsclib045
// Cell name: TLATNTSCAX20
// View name: extracted

simulator lang=spectre

subckt TLATNTSCAX20 CK E ECK SE VDD VSS
mp1 (\8\:Eb \1\:E net246 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.8e-07 sd=160n sca=48.9651 \
        scb=0.0318882 scc=0.00591085 m=(1)
C1 (CK VSS) capacitor c=6.27214e-17
C2 (SE VSS) capacitor c=5.80897e-17
C3 (VDD VSS) capacitor c=3.60011e-16
C4 (E VSS) capacitor c=4.95518e-17
C5 (ECK VSS) capacitor c=1.60969e-15
C6 (Eb VSS) capacitor c=1.00076e-16
C7 (CKb VSS) capacitor c=3.3091e-17
C8 (n5 VSS) capacitor c=3.53949e-16
C9 (net263 VSS) capacitor c=1.50435e-18
C10 (CKbb VSS) capacitor c=5.85651e-17
C11 (Eint VSS) capacitor c=5.86006e-17
C12 (ECKb VSS) capacitor c=7.70245e-16
C13 (17 VSS) capacitor c=1.72384e-18
C14 (18 VSS) capacitor c=1.72384e-18
C15 (19 VSS) capacitor c=1.72384e-18
C16 (20 VSS) capacitor c=2.10413e-18
C17 (net246 VSS) capacitor c=2.36136e-18
C18 (net234 VSS) capacitor c=1.23525e-18
C19 (\5\:CKb VSS) capacitor c=4.10689e-17
C20 (\3\:CKb VSS) capacitor c=6.48706e-17
C21 (\3\:CKbb VSS) capacitor c=4.32268e-17
C22 (\3\:CK VSS) capacitor c=2.25985e-17
C23 (\1\:SE VSS) capacitor c=5.38036e-17
C24 (\1\:E VSS) capacitor c=5.84468e-17
C25 (\19\:CKbb VSS) capacitor c=8.02297e-17
C26 (\18\:Eint VSS) capacitor c=4.90647e-17
C27 (\16\:Eint VSS) capacitor c=6.57019e-17
C28 (\15\:CKbb VSS) capacitor c=5.94374e-17
C29 (\14\:CKbb VSS) capacitor c=6.11352e-17
C30 (\11\:Eint VSS) capacitor c=4.81839e-17
C31 (\10\:Eint VSS) capacitor c=4.74364e-17
C32 (\5\:CKbb VSS) capacitor c=6.27606e-17
C33 (\9\:CKbb VSS) capacitor c=3.91111e-17
C34 (\4\:Eint VSS) capacitor c=4.27806e-17
C35 (\6\:CKb VSS) capacitor c=5.00332e-17
C36 (\3\:Eint VSS) capacitor c=6.73186e-17
C37 (\1\:CK VSS) capacitor c=2.72877e-17
C38 (\3\:SE VSS) capacitor c=3.04592e-17
C39 (\4\:E VSS) capacitor c=2.22842e-17
C40 (\19\:ECKb VSS) capacitor c=1.6911e-17
C41 (\5\:Eint VSS) capacitor c=7.28582e-16
C42 (\7\:CKb VSS) capacitor c=1.9208e-17
C43 (\2\:Eint VSS) capacitor c=7.05239e-17
C44 (\4\:CKbb VSS) capacitor c=3.39835e-17
C45 (\4\:CKb VSS) capacitor c=3.30405e-17
C46 (\2\:CKb VSS) capacitor c=2.73996e-17
C47 (\2\:CK VSS) capacitor c=2.68501e-17
C48 (\2\:SE VSS) capacitor c=3.58509e-17
C49 (\3\:E VSS) capacitor c=1.44707e-17
C50 (\53\:ECKb VSS) capacitor c=5.86701e-16
C51 (\27\:Eint VSS) capacitor c=4.19875e-17
C52 (\23\:CKbb VSS) capacitor c=1.87226e-16
C53 (\55\:VDD VSS) capacitor c=3.07408e-17
C54 (\13\:n5 VSS) capacitor c=1.0048e-16
C55 (\11\:CKb VSS) capacitor c=1.27571e-16
C56 (\59\:VDD VSS) capacitor c=5.06708e-17
C57 (\8\:Eb VSS) capacitor c=7.14149e-17
C58 (\1\:VDD VSS) capacitor c=1.38955e-15
C59 (\62\:ECKb VSS) capacitor c=8.74196e-17
C60 (\70\:ECKb VSS) capacitor c=1.16715e-16
C61 (\72\:ECKb VSS) capacitor c=7.47657e-17
C62 (\23\:Eint VSS) capacitor c=2.91524e-17
C63 (\26\:CKbb VSS) capacitor c=9.37503e-17
C64 (\11\:n5 VSS) capacitor c=1.95829e-16
C65 (\6\:Eb VSS) capacitor c=2.30097e-17
C66 (\15\:CKb VSS) capacitor c=1.21448e-16
C67 (\4\:Eb VSS) capacitor c=1.45738e-16
C68 (\2\:E VSS) capacitor c=2.39205e-17
C69 (\2\:CKbb VSS) capacitor c=3.97538e-17
C70 (\6\:CKbb VSS) capacitor c=8.62341e-16
C71 (\5\:E VSS) capacitor c=4.464e-17
C72 (\4\:SE VSS) capacitor c=5.96679e-17
C73 (\4\:CK VSS) capacitor c=6.35391e-17
C74 (\3\:Eb VSS) capacitor c=1.40095e-16
C75 (\8\:CKb VSS) capacitor c=4.03323e-17
C76 (\9\:CKb VSS) capacitor c=6.20395e-17
C77 (\10\:CKb VSS) capacitor c=1.06724e-16
C78 (\13\:CKb VSS) capacitor c=2.89255e-17
C79 (\14\:CKb VSS) capacitor c=9.23555e-17
C80 (\22\:Eint VSS) capacitor c=5.42098e-17
C81 (\25\:Eint VSS) capacitor c=9.32186e-17
C82 (\26\:Eint VSS) capacitor c=9.25998e-17
C83 (\25\:CKbb VSS) capacitor c=1.41954e-16
C84 (\61\:ECKb VSS) capacitor c=6.84107e-17
C85 (\54\:VDD VSS) capacitor c=2.83055e-17
C86 (\58\:VDD VSS) capacitor c=1.19522e-17
Rk3 (\4\:CK CK) resistor r=0.0284 c=0
Rk123 (\1\:VSS \17\:VSS) resistor r=0.3359 c=0
Rk124 (\17\:VSS \18\:VSS) resistor r=0.1579 c=0
Rk125 (\18\:VSS \19\:VSS) resistor r=0.1529 c=0
Rk126 (\19\:VSS \20\:VSS) resistor r=0.3284 c=0
Rk129 (\20\:VSS \23\:VSS) resistor r=0.3811 c=0
Rk130 (\23\:VSS \24\:VSS) resistor r=0.4365 c=0
Rk131 (\24\:VSS \25\:VSS) resistor r=0.2147 c=0
Rk133 (\26\:VSS VSS) resistor r=0.03469 c=0
Rk132 (\25\:VSS \26\:VSS) resistor r=0.2496 c=0
Rk142 (\17\:VSS \43\:VSS) resistor r=0.1839 c=0
Rk143 (\19\:VSS \45\:VSS) resistor r=0.1839 c=0
Rk146 (\23\:VSS \51\:VSS) resistor r=0.1637 c=0
Rk147 (\25\:VSS \53\:VSS) resistor r=0.04335 c=0
Rk148 (\26\:VSS \55\:VSS) resistor r=0.3574 c=0
Rk2 (\4\:SE SE) resistor r=0.07449 c=0
Rk105 (\53\:VDD \54\:VDD) resistor r=0.08011 c=0
Rk106 (\54\:VDD \56\:VDD) resistor r=0.1858 c=0
Rk107 (\54\:VDD \57\:VDD) resistor r=0.5218 c=0
Rk110 (\58\:VDD VDD) resistor r=0.2856 c=0
Rk108 (\57\:VDD \58\:VDD) resistor r=0.1654 c=0
Rk109 (\58\:VDD \60\:VDD) resistor r=0.4362 c=0
Rk1 (\5\:E E) resistor r=0.1753 c=0
Rk4 (\2\:Eb \3\:Eb) resistor r=0.4377 c=0
Rk5 (\3\:Eb \5\:Eb) resistor r=0.8153 c=0
Rk6 (\3\:Eb \7\:Eb) resistor r=0.05787 c=0
Rk7 (\5\:Eb \9\:Eb) resistor r=0.3455 c=0
Rk8 (\8\:CKb \9\:CKb) resistor r=0.404 c=0
Rk9 (\9\:CKb \10\:CKb) resistor r=0.2456 c=0
Rk10 (\10\:CKb \12\:CKb) resistor r=0.5473 c=0
Rk11 (\9\:CKb \13\:CKb) resistor r=0.04543 c=0
Rk12 (\10\:CKb \14\:CKb) resistor r=0.4838 c=0
Rk13 (\12\:CKb \16\:CKb) resistor r=0.7966 c=0
Rk15 (n5 \12\:n5) resistor r=1.0206 c=0
Rk16 (\12\:n5 \14\:n5) resistor r=0.536 c=0
Rk26 (\6\:CKbb \24\:CKbb) resistor r=1.1642 c=0
Rk27 (\24\:CKbb \25\:CKbb) resistor r=0.5452 c=0
Rk28 (\25\:CKbb \27\:CKbb) resistor r=0.5838 c=0
Rk19 (\5\:Eint \22\:Eint) resistor r=0.2208 c=0
Rk20 (\22\:Eint \24\:Eint) resistor r=0.144 c=0
Rk21 (\22\:Eint \25\:Eint) resistor r=0.3088 c=0
Rk22 (\25\:Eint \26\:Eint) resistor r=0.5477 c=0
Rk23 (\25\:Eint \28\:Eint) resistor r=0.08721 c=0
Rk34 (\53\:ECKb \61\:ECKb) resistor r=0.3335 c=0
Rk35 (\61\:ECKb \63\:ECKb) resistor r=0.4448 c=0
Rk39 (\63\:ECKb \71\:ECKb) resistor r=0.4512 c=0
Rk40 (\71\:ECKb \73\:ECKb) resistor r=0.4717 c=0
Rl7 (\2\:CK \3\:CK) resistor r=29.9451 c=0
Rl6 (\1\:CK \2\:CK) resistor r=51.9231 c=0
Rl4 (\1\:SE \2\:SE) resistor r=50.6918 c=0
Rl5 (\2\:SE \3\:SE) resistor r=29.5379 c=0
Rl1 (\1\:E \2\:E) resistor r=115.362 c=0
Rl3 (\2\:E \4\:E) resistor r=34.2969 c=0
Rl2 (\2\:E \3\:E) resistor r=24.9253 c=0
Rl15 (\5\:CKb \6\:CKb) resistor r=121.154 c=0
Rl16 (\5\:CKb \7\:CKb) resistor r=24.2328 c=0
Rl9 (\3\:CKb \4\:CKb) resistor r=71.8456 c=0
Rl8 (CKb \2\:CKb) resistor r=43.855 c=0
Rl10 (\2\:CKbb CKbb) resistor r=78.3081 c=0
Rl11 (\2\:CKbb \3\:CKbb) resistor r=137.971 c=0
Rl12 (\2\:CKbb \4\:CKbb) resistor r=4.5402 c=0
Rl46 (\6\:CKbb \19\:CKbb) resistor r=171.506 c=0
Rl38 (\6\:CKbb \15\:CKbb) resistor r=107.374 c=0
Rl37 (\6\:CKbb \14\:CKbb) resistor r=135.031 c=0
Rl25 (\6\:CKbb \5\:CKbb) resistor r=141.817 c=0
Rl28 (\6\:CKbb \9\:CKbb) resistor r=111.923 c=0
Rl44 (\5\:Eint \18\:Eint) resistor r=35.7713 c=0
Rl42 (\5\:Eint \16\:Eint) resistor r=77.4625 c=0
Rl33 (\5\:Eint \11\:Eint) resistor r=37.6951 c=0
Rl32 (\5\:Eint \10\:Eint) resistor r=35.7713 c=0
Rl23 (\5\:Eint \4\:Eint) resistor r=37.2302 c=0
Rl13 (\2\:Eint Eint) resistor r=61.7959 c=0
Rl14 (\2\:Eint \3\:Eint) resistor r=115.642 c=0
Rl64 (ECKb \19\:ECKb) resistor r=9.5287 c=0
Rz37 (\43\:VSS \42\:VSS) resistor r=75 c=0
Rz38 (\45\:VSS \44\:VSS) resistor r=75 c=0
Rz41 (\51\:VSS \50\:VSS) resistor r=75 c=0
Rz42 (\53\:VSS \52\:VSS) resistor r=75 c=0
Rz43 (\55\:VSS \54\:VSS) resistor r=75 c=0
Rz26 (\53\:VDD \1\:VDD) resistor r=0.1124 c=0
Rz27 (\57\:VDD \1\:VDD) resistor r=7.5 c=0
Rz1 (\4\:Eb \5\:Eb) resistor r=75 c=0
Rz2 (\6\:Eb \7\:Eb) resistor r=75 c=0
Rz3 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz4 (\12\:n5 \11\:n5) resistor r=75 c=0
Rz6 (\27\:CKbb \26\:CKbb) resistor r=75 c=0
Rz5 (\24\:Eint \23\:Eint) resistor r=75 c=0
Rz7 (\63\:ECKb \62\:ECKb) resistor r=75 c=0
Rz8 (\71\:ECKb \70\:ECKb) resistor r=75 c=0
Rz9 (\73\:ECKb \72\:ECKb) resistor r=75 c=0
Ry44 (VSS \1\:VSS) resistor r=62 c=0
Ry41 (\18\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry42 (\20\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry43 (\24\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry36 (\56\:VDD \55\:VDD) resistor r=62 c=0
Ry37 (\60\:VDD \59\:VDD) resistor r=62 c=0
Ry1 (Eb \2\:Eb) resistor r=62 c=0
Ry2 (\8\:Eb \9\:Eb) resistor r=62 c=0
Ry3 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry4 (\14\:n5 \13\:n5) resistor r=62 c=0
Ry6 (\24\:CKbb \23\:CKbb) resistor r=62 c=0
Ry5 (\28\:Eint \27\:Eint) resistor r=62 c=0
Rx3 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\2\:SE \4\:SE) resistor r=45 c=0
Rx1 (\3\:E \5\:E) resistor r=45 c=0
Rx4 (\7\:CKb \8\:CKb) resistor r=45 c=0
Rx5 (\4\:CKb \13\:CKb) resistor r=45 c=0
Rx6 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx16 (\25\:CKbb \4\:CKbb) resistor r=45 c=0
Rx12 (\26\:Eint \2\:Eint) resistor r=45 c=0
Rx17 (\61\:ECKb \19\:ECKb) resistor r=45 c=0
mn1 (\4\:Eb \4\:E \54\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.19e-14 ps=5.7e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.95e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn0 (\4\:Eb \3\:SE \52\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.353e-14 ad=3.19e-14 ps=1.58e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=4.3e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn2 (\15\:CKb \1\:CK \52\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.353e-14 ad=2.03e-14 ps=1.58e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=1.4e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn5 (\6\:Eb CKb \11\:n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.393e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.29138e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn16 (\11\:n5 CKbb net263 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.393e-14 ps=4.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=4.19138e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn15 (net263 \3\:Eint \50\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.53e-14 ad=8.7e-15 ps=1.29e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=3.14138e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn3 (\26\:CKbb \6\:CKb \50\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.53e-14 ad=3.263e-14 ps=1.29e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.57931e-07 sb=2.25e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn10_1__rcx (\23\:Eint n5 \20\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.96e-06 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(2)
mn20 (16 \4\:Eint \20\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.25e-14 ps=8.4e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.55e-06 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn21_1__rcx (\72\:ECKb \5\:CKbb 17 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.175e-06 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn21 (\72\:ECKb \9\:CKbb 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.25e-14 ad=4.16e-14 ps=7.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=1.38e-06 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn20_1__rcx (17 \10\:Eint \44\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.07e-06 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn20_2__rcx (18 \11\:Eint \44\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.235e-06 sb=8.65e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn21_2__rcx (\70\:ECKb \14\:CKbb 18 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34e-06 sb=7.6e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn21_3__rcx (\70\:ECKb \15\:CKbb 19 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.545e-06 sb=5.55e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn20_3__rcx (19 \16\:Eint \42\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-06 sb=4.5e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn20_4__rcx (20 \18\:Eint \42\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.855e-06 sb=2.45e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn21_4__rcx (\62\:ECKb \19\:CKbb 20 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96e-06 sb=1.4e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn22_1__rcx (ECK ECKb \1\:VSS VSS) g45n1svt w=(3.05e-07) l=4.5e-08 nf=1 \
        as=4.844e-14 ad=4.844e-14 ps=9.2765e-07 pd=9.2765e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.121 scb=0.0155296 \
        scc=0.00139557 m=(17)
mp0 (net246 \1\:SE \59\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=1.29e-14 ps=8.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.75e-07 sd=160n sca=47.6387 \
        scb=0.0298205 scc=0.00588813 m=(1)
mp2 (\11\:CKb \3\:CK \59\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=3.01e-14 ps=8.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.4e-07 sd=160n sca=46.2776 \
        scb=0.0284965 scc=0.00588421 m=(1)
mp5 (\13\:n5 \3\:CKbb Eb VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.128e-14 ad=3.44e-14 ps=1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=6.30233e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp16 (\13\:n5 \3\:CKb net234 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=3.44e-14 ps=5.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=4.25233e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp15 (net234 Eint \55\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.595e-14 ad=1.505e-14 ps=1.61e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=3.10233e-07 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp3 (\23\:CKbb \5\:CKb \55\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.595e-14 ad=2.71e-14 ps=1.61e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.77674e-07 sb=1.26047e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp10 (\27\:Eint n5 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.705e-14 ad=6.24e-14 ps=1.36e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.08974e-07 sb=1.69577e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp20_1__rcx (\53\:ECKb \5\:Eint \1\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=7.056e-14 ad=6.24e-14 ps=1.172e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=5.42821e-07 sb=2e-06 sd=160n \
        sca=16.7336 scb=0.0149207 scc=0.00128056 m=(5)
mp21 (\53\:ECKb \6\:CKbb \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.614e-14 ad=6.24e-14 ps=1.14e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.47821e-07 sb=2e-06 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(5)
mp22_1__rcx (ECK ECKb \1\:VDD VDD) g45p1svt w=(4.6e-07) l=4.5e-08 nf=1 \
        as=7.405e-14 ad=7.36e-14 ps=1.24375e-06 pd=1.24e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.71087e-06 sb=2e-06 sd=160n sca=27.3498 \
        scb=0.0181352 scc=0.00285625 m=(16)
mp22_16__rcx (ECK ECKb \1\:VDD VDD) g45p1svt w=(4.55e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=6.37e-14 ps=1.24e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=33.0977 scb=0.0260038 \
        scc=0.00304396 m=(1)
ends TLATNTSCAX20
// End of subcircuit definition.

// Generated for: spectre (May  9 18:30:39 2012 )
// Library name: gsclib045
// Cell name: TLATNTSCAX3
// View name: extracted

simulator lang=spectre

subckt TLATNTSCAX3 CK E ECK SE VDD VSS
mp1 (\4\:Eb \1\:E net246 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.65e-07 sd=160n sca=18.0262 \
        scb=0.0191386 scc=0.000518763 m=(1)
C1 (CK VSS) capacitor c=7.89624e-17
C2 (SE VSS) capacitor c=6.43288e-17
C3 (VDD VSS) capacitor c=2.64767e-16
C4 (E VSS) capacitor c=4.17753e-17
C5 (ECK VSS) capacitor c=1.58193e-17
C6 (Eb VSS) capacitor c=8.36234e-17
C7 (CKb VSS) capacitor c=2.12293e-17
C8 (n5 VSS) capacitor c=5.19282e-17
C9 (net263 VSS) capacitor c=1.44726e-18
C10 (CKbb VSS) capacitor c=3.32631e-17
C11 (Eint VSS) capacitor c=5.07992e-17
C12 (net271 VSS) capacitor c=2.34543e-18
C13 (ECKb VSS) capacitor c=1.7333e-16
C14 (net234 VSS) capacitor c=2.85236e-18
C15 (\4\:CKbb VSS) capacitor c=4.77665e-17
C16 (\5\:Eint VSS) capacitor c=5.2106e-17
C17 (\2\:n5 VSS) capacitor c=3.20513e-17
C18 (\5\:CKb VSS) capacitor c=6.0327e-17
C19 (\3\:Eint VSS) capacitor c=7.19671e-17
C20 (\3\:CKb VSS) capacitor c=7.00063e-17
C21 (\3\:CKbb VSS) capacitor c=6.45837e-17
C22 (\1\:CK VSS) capacitor c=3.82369e-17
C23 (\1\:SE VSS) capacitor c=8.05413e-17
C24 (\1\:E VSS) capacitor c=8.98757e-17
C25 (\6\:CKbb VSS) capacitor c=5.69929e-17
C26 (\8\:Eint VSS) capacitor c=6.31105e-17
C27 (\6\:CKb VSS) capacitor c=3.59052e-17
C28 (\3\:CK VSS) capacitor c=4.44792e-17
C29 (\3\:SE VSS) capacitor c=3.77714e-17
C30 (\4\:E VSS) capacitor c=2.84091e-17
C31 (\5\:CKbb VSS) capacitor c=3.55962e-17
C32 (\7\:Eint VSS) capacitor c=2.10002e-17
C33 (\3\:n5 VSS) capacitor c=1.84863e-17
C34 (\7\:CKb VSS) capacitor c=1.99743e-17
C35 (\4\:Eint VSS) capacitor c=2.77207e-17
C36 (\2\:CKbb VSS) capacitor c=7.51074e-17
C37 (\4\:CKb VSS) capacitor c=5.33374e-17
C38 (\2\:CKb VSS) capacitor c=1.91567e-17
C39 (\2\:CK VSS) capacitor c=4.53409e-17
C40 (\2\:SE VSS) capacitor c=7.78043e-17
C41 (\3\:E VSS) capacitor c=1.21869e-17
C42 (\1\:VDD VSS) capacitor c=1.177e-16
C43 (\16\:ECKb VSS) capacitor c=7.6098e-17
C44 (\10\:VDD VSS) capacitor c=7.38525e-17
C45 (\11\:Eint VSS) capacitor c=6.08742e-17
C46 (\8\:CKbb VSS) capacitor c=1.19463e-16
C47 (\14\:VDD VSS) capacitor c=3.71829e-17
C48 (\5\:n5 VSS) capacitor c=2.19865e-16
C49 (\6\:Eb VSS) capacitor c=1.49232e-16
C50 (\15\:CKb VSS) capacitor c=1.09618e-16
C51 (\18\:VDD VSS) capacitor c=4.93371e-17
C52 (\4\:Eb VSS) capacitor c=9.37931e-18
C53 (\3\:VDD VSS) capacitor c=1.32417e-16
C54 (\1\:ECK VSS) capacitor c=5.35788e-17
C55 (\14\:ECKb VSS) capacitor c=4.10604e-17
C56 (\14\:Eint VSS) capacitor c=3.73376e-17
C57 (\10\:CKbb VSS) capacitor c=1.7192e-16
C58 (\7\:n5 VSS) capacitor c=1.08156e-16
C59 (\8\:Eb VSS) capacitor c=9.72291e-17
C60 (\12\:CKb VSS) capacitor c=2.84951e-17
C61 (\2\:E VSS) capacitor c=5.77268e-17
C62 (\2\:Eint VSS) capacitor c=5.70111e-17
C63 (\6\:Eint VSS) capacitor c=2.28586e-17
C64 (\5\:E VSS) capacitor c=4.10751e-17
C65 (\4\:SE VSS) capacitor c=6.97755e-17
C66 (\4\:CK VSS) capacitor c=5.19013e-17
C67 (\3\:Eb VSS) capacitor c=1.65608e-16
C68 (\8\:CKb VSS) capacitor c=1.60162e-16
C69 (\9\:CKb VSS) capacitor c=1.21173e-16
C70 (\10\:CKb VSS) capacitor c=4.28159e-17
C71 (\11\:CKb VSS) capacitor c=7.50834e-17
C72 (\14\:CKb VSS) capacitor c=9.21989e-17
C73 (\4\:n5 VSS) capacitor c=1.33194e-16
C74 (\9\:Eint VSS) capacitor c=2.69554e-17
C75 (\10\:Eint VSS) capacitor c=3.08348e-17
C76 (\13\:Eint VSS) capacitor c=9.27799e-17
C77 (\7\:CKbb VSS) capacitor c=1.58292e-16
C78 (\12\:CKbb VSS) capacitor c=1.04474e-16
C79 (\12\:ECKb VSS) capacitor c=1.79978e-17
C80 (\13\:ECKb VSS) capacitor c=4.65871e-17
C81 (\5\:ECK VSS) capacitor c=1.23616e-16
C82 (\13\:VDD VSS) capacitor c=2.42839e-17
C83 (\17\:VDD VSS) capacitor c=1.40768e-17
Rk3 (CK \4\:CK) resistor r=0.1059 c=0
Rk2 (\4\:SE SE) resistor r=0.008993 c=0
Rk46 (\1\:VDD \8\:VDD) resistor r=0.08511 c=0
Rk47 (\8\:VDD \9\:VDD) resistor r=0.1202 c=0
Rk48 (\9\:VDD \11\:VDD) resistor r=0.4631 c=0
Rk49 (\9\:VDD \12\:VDD) resistor r=0.2306 c=0
Rk50 (\12\:VDD \13\:VDD) resistor r=0.2582 c=0
Rk51 (\13\:VDD \15\:VDD) resistor r=0.1031 c=0
Rk52 (\13\:VDD \16\:VDD) resistor r=0.4439 c=0
Rk55 (\17\:VDD VDD) resistor r=0.2153 c=0
Rk53 (\16\:VDD \17\:VDD) resistor r=0.1855 c=0
Rk54 (\17\:VDD \19\:VDD) resistor r=0.3017 c=0
Rk1 (E \5\:E) resistor r=0.1286 c=0
Rk27 (\1\:ECK ECK) resistor r=0.05515 c=0
Rk28 (ECK \5\:ECK) resistor r=0.1612 c=0
Rk33 (\1\:VSS \6\:VSS) resistor r=0.2281 c=0
Rk35 (\6\:VSS \9\:VSS) resistor r=0.4652 c=0
Rk36 (\9\:VSS \10\:VSS) resistor r=0.3385 c=0
Rk38 (\11\:VSS VSS) resistor r=0.2156 c=0
Rk37 (\10\:VSS \11\:VSS) resistor r=0.336 c=0
Rk39 (\6\:VSS \13\:VSS) resistor r=0.07151 c=0
Rk40 (\9\:VSS \15\:VSS) resistor r=0.4323 c=0
Rk41 (\11\:VSS \17\:VSS) resistor r=0.1795 c=0
Rk42 (VSS \19\:VSS) resistor r=0.186 c=0
Rk4 (\2\:Eb \3\:Eb) resistor r=0.5563 c=0
Rk5 (\3\:Eb \5\:Eb) resistor r=0.132 c=0
Rk6 (\3\:Eb \7\:Eb) resistor r=0.8219 c=0
Rk7 (\7\:Eb \9\:Eb) resistor r=0.5995 c=0
Rk8 (\8\:CKb \9\:CKb) resistor r=1.1346 c=0
Rk9 (\9\:CKb \10\:CKb) resistor r=0.1781 c=0
Rk10 (\10\:CKb \11\:CKb) resistor r=0.2803 c=0
Rk11 (\11\:CKb \13\:CKb) resistor r=0.07129 c=0
Rk12 (\9\:CKb \14\:CKb) resistor r=0.5928 c=0
Rk13 (\11\:CKb \16\:CKb) resistor r=0.6436 c=0
Rk14 (\4\:n5 \6\:n5) resistor r=1.0586 c=0
Rk15 (\6\:n5 \8\:n5) resistor r=0.6365 c=0
Rk20 (\7\:CKbb \9\:CKbb) resistor r=0.5984 c=0
Rk21 (\7\:CKbb \11\:CKbb) resistor r=0.707 c=0
Rk22 (\11\:CKbb \12\:CKbb) resistor r=0.7992 c=0
Rk16 (\9\:Eint \10\:Eint) resistor r=0.1523 c=0
Rk17 (\10\:Eint \12\:Eint) resistor r=0.2034 c=0
Rk18 (\12\:Eint \13\:Eint) resistor r=0.4695 c=0
Rk19 (\10\:Eint \15\:Eint) resistor r=0.1181 c=0
Rk23 (\12\:ECKb \13\:ECKb) resistor r=0.08178 c=0
Rk24 (\13\:ECKb \15\:ECKb) resistor r=0.159 c=0
Rk25 (\13\:ECKb \17\:ECKb) resistor r=0.3709 c=0
Rl6 (\1\:CK \2\:CK) resistor r=73.7687 c=0
Rl7 (\2\:CK \3\:CK) resistor r=175.692 c=0
Rl4 (\1\:SE \2\:SE) resistor r=151.156 c=0
Rl5 (\2\:SE \3\:SE) resistor r=95.3867 c=0
Rl1 (\1\:E \2\:E) resistor r=233.001 c=0
Rl3 (\2\:E \4\:E) resistor r=54.5094 c=0
Rl2 (\2\:E \3\:E) resistor r=9.7447 c=0
Rl15 (\5\:CKb \6\:CKb) resistor r=219.231 c=0
Rl16 (\6\:CKb \7\:CKb) resistor r=29.5379 c=0
Rl9 (\3\:CKb \4\:CKb) resistor r=53.079 c=0
Rl8 (CKb \2\:CKb) resistor r=79.5379 c=0
Rl17 (n5 \2\:n5) resistor r=95.0735 c=0
Rl18 (\2\:n5 \3\:n5) resistor r=31.461 c=0
Rl22 (\4\:CKbb \5\:CKbb) resistor r=39.9593 c=0
Rl23 (\5\:CKbb \6\:CKbb) resistor r=24.7951 c=0
Rl10 (CKbb \2\:CKbb) resistor r=76.1559 c=0
Rl11 (\2\:CKbb \3\:CKbb) resistor r=218.785 c=0
Rl12 (Eint \2\:Eint) resistor r=137.202 c=0
Rl13 (\2\:Eint \3\:Eint) resistor r=109.924 c=0
Rl14 (\2\:Eint \4\:Eint) resistor r=8.149 c=0
Rl19 (\5\:Eint \6\:Eint) resistor r=49.7141 c=0
Rl21 (\6\:Eint \8\:Eint) resistor r=34.3295 c=0
Rl20 (\6\:Eint \7\:Eint) resistor r=5.9102 c=0
Rz16 (\1\:VDD \3\:VDD) resistor r=18.75 c=0
Rz17 (\8\:VDD \3\:VDD) resistor r=37.5 c=0
Rz18 (\12\:VDD \3\:VDD) resistor r=15 c=0
Rz19 (\16\:VDD \3\:VDD) resistor r=8.3333 c=0
Rz12 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz13 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz14 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz15 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz1 (Eb \2\:Eb) resistor r=75 c=0
Rz2 (\8\:Eb \9\:Eb) resistor r=75 c=0
Rz3 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz4 (\7\:n5 \8\:n5) resistor r=75 c=0
Rz6 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz5 (\14\:Eint \15\:Eint) resistor r=75 c=0
Rz7 (\15\:ECKb \14\:ECKb) resistor r=75 c=0
Ry15 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry16 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry17 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry10 (\1\:VSS \3\:VSS) resistor r=15.5 c=0
Ry11 (\6\:VSS \3\:VSS) resistor r=15.5 c=0
Ry12 (\10\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\4\:Eb \5\:Eb) resistor r=62 c=0
Ry2 (\6\:Eb \7\:Eb) resistor r=62 c=0
Ry3 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry4 (\5\:n5 \6\:n5) resistor r=62 c=0
Ry6 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry5 (\11\:Eint \12\:Eint) resistor r=62 c=0
Ry7 (\17\:ECKb \16\:ECKb) resistor r=20.6667 c=0
Rx3 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\2\:SE \4\:SE) resistor r=45 c=0
Rx1 (\3\:E \5\:E) resistor r=45 c=0
Rx4 (\7\:CKb \8\:CKb) resistor r=45 c=0
Rx5 (\2\:CKb \10\:CKb) resistor r=45 c=0
Rx6 (\4\:CKb \14\:CKb) resistor r=45 c=0
Rx7 (\3\:n5 \4\:n5) resistor r=45 c=0
Rx10 (\2\:CKbb \7\:CKbb) resistor r=45 c=0
Rx11 (\5\:CKbb \12\:CKbb) resistor r=45 c=0
Rx8 (\7\:Eint \9\:Eint) resistor r=45 c=0
Rx9 (\4\:Eint \13\:Eint) resistor r=45 c=0
Rx12 (\12\:ECKb ECKb) resistor r=45 c=0
mn1 (Eb \4\:E \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.61e-14 ps=5.7e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6e-07 sd=160n sca=6.59604 scb=0.00318587 \
        scc=2.16275e-05 m=(1)
mn0 (Eb \3\:SE \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.61e-14 ps=6.7e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=3.75e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (\12\:CKb \3\:CK \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.755e-14 ad=2.03e-14 ps=6.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=1.4e-07 sd=160n sca=6.59604 scb=0.00318587 \
        scc=2.16275e-05 m=(1)
mn5 (\8\:Eb CKb \7\:n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.365e-14 ad=2.03e-14 ps=1.03e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.085e-06 sd=160n sca=20.6444 \
        scb=0.0212501 scc=0.00213091 m=(1)
mn16 (\7\:n5 CKbb net263 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=5.365e-14 ps=5.6e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=6.7e-07 sd=160n sca=20.6444 \
        scb=0.0212501 scc=0.00213091 m=(1)
mn15 (net263 Eint \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.972e-14 ad=1.957e-14 ps=7e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=4.9e-07 sd=160n sca=20.6444 \
        scb=0.0212501 scc=0.00213091 m=(1)
mn3 (\10\:CKbb \6\:CKb \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.972e-14 ad=3.48e-14 ps=7e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=2.4e-07 sd=160n sca=20.6444 \
        scb=0.0212501 scc=0.00213091 m=(1)
mn10 (\14\:Eint n5 \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.985e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.65e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (net271 \8\:Eint \12\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.985e-14 ad=1.56e-14 ps=1.6e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.01058e-07 sb=2.67115e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn21 (\14\:ECKb \6\:CKbb net271 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.215e-14 ps=6.4e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.06058e-07 sb=1.62115e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn22 (\1\:ECK ECKb \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=3.987e-14 ps=1.04667e-06 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=5.5e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(3)
mp0 (net246 \1\:SE \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=1.29e-14 ps=8.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.6e-07 sd=160n sca=15.3842 \
        scb=0.0145001 scc=0.000361295 m=(1)
mp2 (\15\:CKb \1\:CK \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=4.838e-14 ps=8.1e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=2.25e-07 sd=160n sca=13.085 \
        scb=0.0112888 scc=0.000332502 m=(1)
mp5 (\5\:n5 \3\:CKbb \6\:Eb VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.44e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.2e-07 sb=8.6e-07 sd=160n sca=10.1292 \
        scb=0.00731698 scc=7.20009e-05 m=(1)
mp16 (\5\:n5 \3\:CKb net234 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=6.55e-07 sd=160n sca=10.1292 \
        scb=0.00731698 scc=7.20009e-05 m=(1)
mp15 (net234 \3\:Eint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0248e-13 ad=1.29e-14 ps=1.56e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=5.5e-07 sd=160n sca=10.1292 \
        scb=0.00731698 scc=7.20009e-05 m=(1)
mp3 (\8\:CKbb \5\:CKb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0248e-13 ad=3.01e-14 ps=1.56e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=1.4e-07 sd=160n sca=10.1292 \
        scb=0.00731698 scc=7.20009e-05 m=(1)
mp10 (\11\:Eint \2\:n5 \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.835e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.265e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\16\:ECKb \5\:Eint \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.835e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.51603e-07 sb=1.03e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp21 (\16\:ECKb \4\:CKbb \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.56603e-07 sb=8.25e-07 sd=160n sca=30.5596 \
        scb=0.0202122 scc=0.00336097 m=(1)
mp22 (\5\:ECK ECKb \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.8e-14 ps=1.1e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.61603e-07 sb=6.2e-07 sd=160n sca=31.1577 \
        scb=0.0204645 scc=0.00336109 m=(3)
ends TLATNTSCAX3
// End of subcircuit definition.

// Generated for: spectre (May  9 18:31:20 2012 )
// Library name: gsclib045
// Cell name: TLATNTSCAX4
// View name: extracted

simulator lang=spectre

subckt TLATNTSCAX4 CK E ECK SE VDD VSS
mp1 (Eb \1\:E net246 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=14.9425 scb=0.013778 \
        scc=0.000180854 m=(1)
C1 (CK VSS) capacitor c=4.69178e-17
C2 (VDD VSS) capacitor c=3.18858e-16
C3 (E VSS) capacitor c=5.46931e-17
C4 (ECK VSS) capacitor c=2.80817e-16
C5 (Eb VSS) capacitor c=5.68582e-17
C6 (CKb VSS) capacitor c=6.27622e-17
C7 (n5 VSS) capacitor c=5.06456e-17
C8 (net263 VSS) capacitor c=1.34762e-18
C9 (CKbb VSS) capacitor c=3.09885e-17
C10 (Eint VSS) capacitor c=5.23915e-17
C11 (ECKb VSS) capacitor c=2.38668e-16
C12 (net234 VSS) capacitor c=1.7512e-18
C13 (\5\:CKbb VSS) capacitor c=5.30035e-17
C14 (\4\:Eint VSS) capacitor c=4.33421e-17
C15 (\2\:n5 VSS) capacitor c=3.83272e-17
C16 (\6\:CKb VSS) capacitor c=4.16205e-17
C17 (\1\:CK VSS) capacitor c=3.20545e-17
C18 (\1\:SE VSS) capacitor c=7.65736e-17
C19 (\1\:E VSS) capacitor c=7.86973e-17
C20 (\7\:CKbb VSS) capacitor c=5.86218e-17
C21 (\6\:Eint VSS) capacitor c=7.90515e-17
C22 (\9\:CKb VSS) capacitor c=3.08815e-17
C23 (\3\:Eint VSS) capacitor c=5.93306e-17
C24 (\3\:CKbb VSS) capacitor c=5.16021e-17
C25 (\5\:CKb VSS) capacitor c=3.60446e-17
C26 (\3\:CK VSS) capacitor c=3.88384e-17
C27 (\3\:SE VSS) capacitor c=3.64498e-17
C28 (\4\:E VSS) capacitor c=2.17817e-17
C29 (\6\:CKbb VSS) capacitor c=5.70817e-17
C30 (\5\:Eint VSS) capacitor c=4.1647e-17
C31 (\3\:n5 VSS) capacitor c=2.46334e-17
C32 (\8\:CKb VSS) capacitor c=4.0508e-17
C33 (\2\:Eint VSS) capacitor c=7.28908e-17
C34 (\2\:CKb VSS) capacitor c=4.99558e-17
C35 (\4\:CKbb VSS) capacitor c=2.36996e-17
C36 (\2\:CKbb VSS) capacitor c=4.17171e-17
C37 (\4\:CKb VSS) capacitor c=2.63925e-17
C38 (\2\:CK VSS) capacitor c=5.07798e-17
C39 (\2\:SE VSS) capacitor c=7.07487e-17
C40 (\3\:E VSS) capacitor c=1.31886e-17
C41 (\1\:VDD VSS) capacitor c=2.35402e-16
C42 (\18\:ECKb VSS) capacitor c=8.02388e-17
C43 (\16\:VDD VSS) capacitor c=6.29685e-17
C44 (\9\:Eint VSS) capacitor c=6.77165e-17
C45 (\14\:CKbb VSS) capacitor c=5.1155e-17
C46 (\18\:VDD VSS) capacitor c=2.43019e-17
C47 (\5\:n5 VSS) capacitor c=1.65687e-16
C48 (\8\:Eb VSS) capacitor c=1.10786e-16
C49 (\13\:CKb VSS) capacitor c=5.36715e-17
C50 (\20\:VDD VSS) capacitor c=4.01221e-17
C51 (\4\:VDD VSS) capacitor c=5.34093e-17
C52 (\16\:ECKb VSS) capacitor c=5.42954e-17
C53 (\12\:Eint VSS) capacitor c=7.12278e-17
C54 (\11\:CKbb VSS) capacitor c=1.24575e-16
C55 (\7\:n5 VSS) capacitor c=9.27577e-17
C56 (\6\:Eb VSS) capacitor c=2.04661e-16
C57 (\10\:CKb VSS) capacitor c=6.75964e-17
C58 (\4\:Eb VSS) capacitor c=2.87108e-17
C59 (\2\:E VSS) capacitor c=5.1121e-17
C60 (\3\:CKb VSS) capacitor c=4.98539e-17
C61 (\5\:E VSS) capacitor c=4.96436e-17
C62 (\4\:CK VSS) capacitor c=3.49622e-17
C63 (\4\:SE VSS) capacitor c=1.41196e-16
C64 (\12\:CKb VSS) capacitor c=1.0553e-16
C65 (\3\:Eb VSS) capacitor c=1.91165e-16
C66 (\15\:CKb VSS) capacitor c=4.39382e-17
C67 (\16\:CKb VSS) capacitor c=6.1141e-17
C68 (\4\:n5 VSS) capacitor c=1.0465e-16
C69 (\7\:Eint VSS) capacitor c=4.8083e-17
C70 (\8\:Eint VSS) capacitor c=6.00257e-17
C71 (\11\:Eint VSS) capacitor c=9.62918e-17
C72 (\8\:CKbb VSS) capacitor c=1.3778e-16
C73 (\9\:CKbb VSS) capacitor c=1.45027e-16
C74 (\10\:CKbb VSS) capacitor c=1.16395e-16
C75 (\13\:CKbb VSS) capacitor c=1.54682e-16
C76 (\14\:ECKb VSS) capacitor c=2.23501e-17
C77 (\15\:ECKb VSS) capacitor c=4.50983e-17
C78 (\7\:VDD VSS) capacitor c=2.78483e-17
C79 (\8\:VDD VSS) capacitor c=2.42493e-17
C80 (\10\:VDD VSS) capacitor c=2.80218e-17
Rk2 (\4\:CK CK) resistor r=0.02263 c=0
Rk3 (\4\:SE SE) resistor r=0.003108 c=0
Rk34 (\1\:VDD \7\:VDD) resistor r=0.2304 c=0
Rk35 (\7\:VDD \8\:VDD) resistor r=0.3825 c=0
Rk36 (\8\:VDD \9\:VDD) resistor r=0.172 c=0
Rk37 (\9\:VDD \10\:VDD) resistor r=0.5668 c=0
Rk39 (\11\:VDD VDD) resistor r=0.1001 c=0
Rk38 (\10\:VDD \11\:VDD) resistor r=0.1353 c=0
Rk42 (\7\:VDD \17\:VDD) resistor r=0.3601 c=0
Rk43 (\8\:VDD \19\:VDD) resistor r=0.04333 c=0
Rk44 (\10\:VDD \21\:VDD) resistor r=0.2361 c=0
Rk1 (\5\:E E) resistor r=0.1787 c=0
Rk47 (\1\:VSS \6\:VSS) resistor r=0.0851 c=0
Rk48 (\6\:VSS \7\:VSS) resistor r=0.1829 c=0
Rk49 (\7\:VSS \8\:VSS) resistor r=0.3483 c=0
Rk50 (\8\:VSS \9\:VSS) resistor r=0.5216 c=0
Rk51 (\9\:VSS \10\:VSS) resistor r=0.2306 c=0
Rk53 (\11\:VSS VSS) resistor r=0.02213 c=0
Rk52 (\10\:VSS \11\:VSS) resistor r=0.1978 c=0
Rk56 (\7\:VSS \17\:VSS) resistor r=0.3601 c=0
Rk57 (\8\:VSS \19\:VSS) resistor r=0.3783 c=0
Rk58 (\10\:VSS \21\:VSS) resistor r=0.3278 c=0
Rk59 (\11\:VSS \23\:VSS) resistor r=0.3348 c=0
Rk6 (\2\:Eb \3\:Eb) resistor r=0.4802 c=0
Rk7 (\3\:Eb \5\:Eb) resistor r=0.07801 c=0
Rk8 (\3\:Eb \7\:Eb) resistor r=1.0477 c=0
Rk9 (\7\:Eb \9\:Eb) resistor r=0.6528 c=0
Rk4 (\11\:CKb \12\:CKb) resistor r=0.3252 c=0
Rk5 (\12\:CKb \14\:CKb) resistor r=0.3979 c=0
Rk10 (\15\:CKb \16\:CKb) resistor r=0.204 c=0
Rk11 (\4\:n5 \6\:n5) resistor r=0.7287 c=0
Rk12 (\6\:n5 \8\:n5) resistor r=0.5084 c=0
Rk17 (\8\:CKbb \9\:CKbb) resistor r=0.791 c=0
Rk18 (\9\:CKbb \10\:CKbb) resistor r=0.6598 c=0
Rk19 (\10\:CKbb \12\:CKbb) resistor r=0.1029 c=0
Rk20 (\12\:CKbb \13\:CKbb) resistor r=1.0344 c=0
Rk21 (\10\:CKbb \15\:CKbb) resistor r=0.2342 c=0
Rk13 (\7\:Eint \8\:Eint) resistor r=0.2515 c=0
Rk14 (\8\:Eint \10\:Eint) resistor r=0.092 c=0
Rk15 (\10\:Eint \11\:Eint) resistor r=0.5808 c=0
Rk16 (\8\:Eint \13\:Eint) resistor r=0.3504 c=0
Rk22 (\14\:ECKb \15\:ECKb) resistor r=0.05483 c=0
Rk23 (\15\:ECKb \17\:ECKb) resistor r=0.3128 c=0
Rk24 (\15\:ECKb \19\:ECKb) resistor r=0.3612 c=0
Rl6 (\1\:CK \2\:CK) resistor r=41.5405 c=0
Rl7 (\2\:CK \3\:CK) resistor r=149.233 c=0
Rl4 (\1\:SE \2\:SE) resistor r=116.076 c=0
Rl5 (\2\:SE \3\:SE) resistor r=77.6149 c=0
Rl1 (\1\:E \2\:E) resistor r=192.616 c=0
Rl3 (\2\:E \4\:E) resistor r=37.2017 c=0
Rl2 (\2\:E \3\:E) resistor r=12.1383 c=0
Rl10 (CKb \2\:CKb) resistor r=85.7713 c=0
Rl13 (\3\:CKb \5\:CKb) resistor r=113.143 c=0
Rl11 (\2\:CKb \3\:CKb) resistor r=81.7209 c=0
Rl12 (\3\:CKb \4\:CKb) resistor r=142.233 c=0
Rl16 (\6\:CKb \7\:CKb) resistor r=35.4445 c=0
Rl18 (\7\:CKb \9\:CKb) resistor r=76.6255 c=0
Rl17 (\7\:CKb \8\:CKb) resistor r=3.6512 c=0
Rl19 (n5 \2\:n5) resistor r=145.787 c=0
Rl20 (\2\:n5 \3\:n5) resistor r=49.2328 c=0
Rl23 (\5\:CKbb \6\:CKbb) resistor r=93.0521 c=0
Rl24 (\6\:CKbb \7\:CKbb) resistor r=63.6565 c=0
Rl9 (\3\:CKbb \4\:CKbb) resistor r=51.1559 c=0
Rl8 (CKbb \2\:CKbb) resistor r=57.6695 c=0
Rl21 (\4\:Eint \5\:Eint) resistor r=26.9231 c=0
Rl22 (\5\:Eint \6\:Eint) resistor r=89.8352 c=0
Rl14 (Eint \2\:Eint) resistor r=24.2328 c=0
Rl15 (\2\:Eint \3\:Eint) resistor r=178.079 c=0
Rz10 (\1\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz11 (\9\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz12 (\11\:VDD \4\:VDD) resistor r=25 c=0
Rz16 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz17 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz18 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz19 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz2 (\4\:Eb \5\:Eb) resistor r=75 c=0
Rz3 (\6\:Eb \7\:Eb) resistor r=75 c=0
Rz1 (\10\:CKb \11\:CKb) resistor r=75 c=0
Rz4 (\7\:n5 \8\:n5) resistor r=75 c=0
Rz6 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz5 (\12\:Eint \13\:Eint) resistor r=75 c=0
Rz7 (\17\:ECKb \16\:ECKb) resistor r=75 c=0
Ry13 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry14 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry15 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry16 (\6\:VSS \5\:VSS) resistor r=5.6364 c=0
Ry17 (\9\:VSS \5\:VSS) resistor r=6.2 c=0
Ry2 (Eb \2\:Eb) resistor r=62 c=0
Ry3 (\8\:Eb \9\:Eb) resistor r=62 c=0
Ry1 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry4 (\5\:n5 \6\:n5) resistor r=62 c=0
Ry6 (\14\:CKbb \15\:CKbb) resistor r=62 c=0
Ry5 (\9\:Eint \10\:Eint) resistor r=62 c=0
Ry7 (\19\:ECKb \18\:ECKb) resistor r=20.6667 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx3 (\2\:SE \4\:SE) resistor r=45 c=0
Rx1 (\3\:E \5\:E) resistor r=45 c=0
Rx4 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx5 (\8\:CKb \15\:CKb) resistor r=45 c=0
Rx6 (\2\:CKb \16\:CKb) resistor r=45 c=0
Rx7 (\3\:n5 \4\:n5) resistor r=45 c=0
Rx10 (\2\:CKbb \8\:CKbb) resistor r=45 c=0
Rx11 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \13\:CKbb) resistor r=45 c=0
Rx8 (\5\:Eint \7\:Eint) resistor r=45 c=0
Rx9 (\2\:Eint \11\:Eint) resistor r=45 c=0
Rx13 (\14\:ECKb ECKb) resistor r=45 c=0
mn1 (\4\:Eb \4\:E \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.537e-14 ps=5.7e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.45e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn0 (\4\:Eb \3\:SE \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.537e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=6.25e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn2 (\10\:CKb \3\:CK \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=6.09e-14 ps=6.1e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=4.2e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn5 (\6\:Eb \5\:CKb \7\:n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.132e-14 ps=6.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=7.5e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn16 (\7\:n5 \3\:CKbb net263 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=2.32e-14 ps=6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=5.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn15 (net263 \3\:Eint \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.247e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn3 (\11\:CKbb \9\:CKb \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn10 (\12\:Eint n5 \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.698e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=4.5e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn20 (net271 \6\:Eint \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.00769e-07 sb=2.45e-07 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(1)
mn21 (\16\:ECKb \7\:CKbb net271 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05769e-07 sb=1.4e-07 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(1)
mn22 (ECK ECKb \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(4)
mp0 (net246 \1\:SE \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=12.9249 \
        scb=0.0102852 scc=0.000102334 m=(1)
mp2 (\13\:CKb \1\:CK \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=11.19 scb=0.0080569 \
        scc=8.84638e-05 m=(1)
mp5 (\5\:n5 CKbb \8\:Eb VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.16e-14 ps=7.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.65e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp16 (\5\:n5 CKb net234 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.16e-14 ps=5.5e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=2.8e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp15 (net234 Eint \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.022e-14 ad=1.29e-14 ps=1.72e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=1.75e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp3 (\14\:CKbb \6\:CKb \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.022e-14 ad=3.01e-14 ps=1.72e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=18.4975 scb=0.0182651 \
        scc=0.0015388 m=(1)
mp10 (\9\:Eint \2\:n5 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.265e-14 ad=3.01e-14 ps=1.2e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.47e-06 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp20 (\18\:ECKb \4\:Eint \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.265e-14 ad=8.19e-14 ps=1.2e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.62628e-07 sb=1.215e-06 sd=160n sca=14.7189 \
        scb=0.0133035 scc=0.000878755 m=(1)
mp21 (\18\:ECKb \5\:CKbb \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=8.19e-14 ps=1.1e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.17628e-07 sb=9.6e-07 sd=160n sca=14.7189 \
        scb=0.0133035 scc=0.000878755 m=(1)
mp22 (ECK ECKb \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.22628e-07 sb=7.55e-07 sd=160n sca=15.0324 \
        scb=0.0133911 scc=0.000878771 m=(4)
ends TLATNTSCAX4
// End of subcircuit definition.

// Generated for: spectre (May  9 18:31:58 2012 )
// Library name: gsclib045
// Cell name: TLATNTSCAX6
// View name: extracted

simulator lang=spectre

subckt TLATNTSCAX6 CK E ECK SE VDD VSS
mp1 (\6\:Eb \1\:E net246 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.95e-07 sd=160n sca=16.4413 \
        scb=0.0164604 scc=0.000341327 m=(1)
C1 (CK VSS) capacitor c=8.62451e-17
C2 (SE VSS) capacitor c=9.01758e-17
C3 (VDD VSS) capacitor c=2.56633e-16
C4 (E VSS) capacitor c=4.93202e-17
C5 (ECK VSS) capacitor c=5.05332e-16
C6 (Eb VSS) capacitor c=6.32326e-17
C7 (CKb VSS) capacitor c=2.88584e-17
C8 (n5 VSS) capacitor c=4.67097e-17
C9 (CKbb VSS) capacitor c=2.57279e-17
C10 (Eint VSS) capacitor c=5.41299e-17
C11 (16 VSS) capacitor c=1.96117e-18
C12 (ECKb VSS) capacitor c=2.83211e-16
C13 (17 VSS) capacitor c=3.55937e-18
C14 (net234 VSS) capacitor c=2.02974e-18
C15 (\3\:n5 VSS) capacitor c=4.28658e-17
C16 (\5\:CKb VSS) capacitor c=6.23708e-17
C17 (\3\:Eint VSS) capacitor c=4.5452e-17
C18 (\3\:CKb VSS) capacitor c=5.05233e-17
C19 (\3\:CKbb VSS) capacitor c=5.66538e-17
C20 (\1\:CK VSS) capacitor c=5.32789e-17
C21 (\1\:SE VSS) capacitor c=9.74241e-17
C22 (\1\:E VSS) capacitor c=9.59337e-17
C23 (\10\:Eint VSS) capacitor c=6.16109e-17
C24 (\4\:CKbb VSS) capacitor c=3.20848e-17
C25 (\9\:CKbb VSS) capacitor c=4.3117e-17
C26 (\5\:Eint VSS) capacitor c=6.82361e-17
C27 (\6\:CKb VSS) capacitor c=3.46804e-17
C28 (\3\:CK VSS) capacitor c=2.74866e-17
C29 (\3\:SE VSS) capacitor c=3.21638e-17
C30 (\4\:E VSS) capacitor c=2.49765e-17
C31 (\7\:ECKb VSS) capacitor c=2.10186e-17
C32 (\6\:Eint VSS) capacitor c=3.96236e-16
C33 (\2\:n5 VSS) capacitor c=3.03697e-17
C34 (\7\:CKb VSS) capacitor c=1.95946e-17
C35 (\4\:Eint VSS) capacitor c=5.38296e-17
C36 (\2\:CKbb VSS) capacitor c=5.32114e-17
C37 (\4\:CKb VSS) capacitor c=3.98906e-17
C38 (\2\:CKb VSS) capacitor c=1.84808e-17
C39 (\2\:CK VSS) capacitor c=4.8118e-17
C40 (\2\:SE VSS) capacitor c=8.37505e-17
C41 (\3\:E VSS) capacitor c=1.23819e-17
C42 (\17\:ECKb VSS) capacitor c=2.02705e-16
C43 (\18\:VDD VSS) capacitor c=4.12577e-17
C44 (\15\:Eint VSS) capacitor c=5.49574e-17
C45 (\10\:CKbb VSS) capacitor c=1.01502e-16
C46 (\22\:VDD VSS) capacitor c=1.68495e-17
C47 (\5\:n5 VSS) capacitor c=1.83464e-16
C48 (\3\:Eb VSS) capacitor c=1.40263e-16
C49 (\14\:CKb VSS) capacitor c=1.05195e-16
C50 (\24\:VDD VSS) capacitor c=4.56264e-17
C51 (\6\:Eb VSS) capacitor c=1.15608e-17
C52 (\1\:VDD VSS) capacitor c=5.29203e-17
C53 (\23\:ECKb VSS) capacitor c=5.63613e-17
C54 (\17\:Eint VSS) capacitor c=3.59181e-17
C55 (\13\:CKbb VSS) capacitor c=1.38273e-16
C56 (\7\:n5 VSS) capacitor c=8.83163e-17
C57 (\12\:CKb VSS) capacitor c=9.70275e-17
C58 (\8\:Eb VSS) capacitor c=9.4079e-17
C59 (\2\:E VSS) capacitor c=5.96457e-17
C60 (\5\:CKbb VSS) capacitor c=1.45761e-16
C61 (\5\:E VSS) capacitor c=4.06239e-17
C62 (\4\:SE VSS) capacitor c=4.7683e-17
C63 (\4\:CK VSS) capacitor c=4.05821e-17
C64 (\5\:Eb VSS) capacitor c=1.9132e-16
C65 (\8\:CKb VSS) capacitor c=6.13239e-17
C66 (\9\:CKb VSS) capacitor c=6.34167e-17
C67 (\10\:CKb VSS) capacitor c=5.89707e-17
C68 (\11\:CKb VSS) capacitor c=8.82431e-17
C69 (\4\:n5 VSS) capacitor c=1.58253e-16
C70 (\12\:CKbb VSS) capacitor c=1.06916e-16
C71 (\15\:CKbb VSS) capacitor c=1.23221e-16
C72 (\11\:Eint VSS) capacitor c=6.62124e-17
C73 (\12\:Eint VSS) capacitor c=5.77081e-17
C74 (\13\:Eint VSS) capacitor c=4.11405e-17
C75 (\20\:ECKb VSS) capacitor c=9.67773e-17
C76 (\3\:VDD VSS) capacitor c=3.76098e-16
C77 (\9\:VDD VSS) capacitor c=3.22125e-17
C78 (\11\:VDD VSS) capacitor c=1.46499e-17
Rk3 (CK \4\:CK) resistor r=0.09307 c=0
Rk2 (SE \4\:SE) resistor r=0.09307 c=0
Rk37 (\2\:VDD \3\:VDD) resistor r=0.09761 c=0
Rk43 (\3\:VDD \9\:VDD) resistor r=0.4184 c=0
Rk44 (\9\:VDD \10\:VDD) resistor r=0.5164 c=0
Rk46 (\11\:VDD VDD) resistor r=0.2278 c=0
Rk45 (\10\:VDD \11\:VDD) resistor r=0.223 c=0
Rk50 (\3\:VDD \19\:VDD) resistor r=0.2577 c=0
Rk52 (\9\:VDD \23\:VDD) resistor r=0.1026 c=0
Rk53 (\11\:VDD \25\:VDD) resistor r=0.2815 c=0
Rk1 (\5\:E E) resistor r=0.1669 c=0
Rk54 (\2\:VSS \3\:VSS) resistor r=0.1979 c=0
Rk57 (\3\:VSS \6\:VSS) resistor r=0.04244 c=0
Rk58 (\6\:VSS \7\:VSS) resistor r=0.3073 c=0
Rk59 (\7\:VSS \8\:VSS) resistor r=0.4617 c=0
Rk60 (\8\:VSS \9\:VSS) resistor r=0.4302 c=0
Rk62 (\10\:VSS VSS) resistor r=0.2283 c=0
Rk61 (\9\:VSS \10\:VSS) resistor r=0.3233 c=0
Rk63 (VSS \12\:VSS) resistor r=0.1795 c=0
Rk67 (\7\:VSS \20\:VSS) resistor r=0.04331 c=0
Rk68 (\8\:VSS \22\:VSS) resistor r=0.04331 c=0
Rk69 (\10\:VSS \24\:VSS) resistor r=0.1763 c=0
Rk4 (\2\:Eb \4\:Eb) resistor r=0.4314 c=0
Rk5 (\4\:Eb \5\:Eb) resistor r=0.9404 c=0
Rk6 (\5\:Eb \7\:Eb) resistor r=0.1045 c=0
Rk7 (\5\:Eb \9\:Eb) resistor r=0.5786 c=0
Rk8 (\8\:CKb \9\:CKb) resistor r=0.4073 c=0
Rk9 (\9\:CKb \10\:CKb) resistor r=0.2077 c=0
Rk10 (\9\:CKb \11\:CKb) resistor r=0.4009 c=0
Rk11 (\10\:CKb \13\:CKb) resistor r=0.3503 c=0
Rk12 (\13\:CKb \15\:CKb) resistor r=0.57 c=0
Rk13 (\4\:n5 \6\:n5) resistor r=1.1289 c=0
Rk14 (\6\:n5 \8\:n5) resistor r=0.5004 c=0
Rk15 (\11\:CKbb \12\:CKbb) resistor r=0.5813 c=0
Rk16 (\12\:CKbb \14\:CKbb) resistor r=0.4507 c=0
Rk17 (\14\:CKbb \15\:CKbb) resistor r=0.909 c=0
Rk18 (\11\:Eint \12\:Eint) resistor r=0.3233 c=0
Rk20 (\13\:Eint \6\:Eint) resistor r=0.2284 c=0
Rk19 (\12\:Eint \13\:Eint) resistor r=0.267 c=0
Rk21 (\12\:Eint \16\:Eint) resistor r=0.1427 c=0
Rk22 (\13\:Eint \18\:Eint) resistor r=0.08669 c=0
Rk25 (\17\:ECKb \20\:ECKb) resistor r=0.4206 c=0
Rk27 (\20\:ECKb \24\:ECKb) resistor r=0.393 c=0
Rl6 (\1\:CK \2\:CK) resistor r=219.923 c=0
Rl7 (\2\:CK \3\:CK) resistor r=39.1533 c=0
Rl4 (\1\:SE \2\:SE) resistor r=218.464 c=0
Rl5 (\2\:SE \3\:SE) resistor r=37.6944 c=0
Rl1 (\1\:E \2\:E) resistor r=259.924 c=0
Rl3 (\2\:E \4\:E) resistor r=37.2017 c=0
Rl2 (\2\:E \3\:E) resistor r=9.7447 c=0
Rl15 (\5\:CKb \6\:CKb) resistor r=150 c=0
Rl16 (\6\:CKb \7\:CKb) resistor r=29.5379 c=0
Rl9 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl8 (CKb \2\:CKb) resistor r=47.3097 c=0
Rl17 (n5 \2\:n5) resistor r=91.1062 c=0
Rl18 (\2\:n5 \3\:n5) resistor r=24.2328 c=0
Rl10 (\2\:CKbb CKbb) resistor r=24.2328 c=0
Rl11 (\2\:CKbb \3\:CKbb) resistor r=189.939 c=0
Rl21 (\5\:CKbb \4\:CKbb) resistor r=54.5712 c=0
Rl25 (\5\:CKbb \9\:CKbb) resistor r=24.7951 c=0
Rl27 (\6\:Eint \10\:Eint) resistor r=83.7903 c=0
Rl19 (\6\:Eint \5\:Eint) resistor r=63.4387 c=0
Rl12 (\2\:Eint Eint) resistor r=85.2786 c=0
Rl13 (\2\:Eint \3\:Eint) resistor r=58.0007 c=0
Rl14 (\2\:Eint \4\:Eint) resistor r=4.3511 c=0
Rl33 (ECKb \7\:ECKb) resistor r=4.8851 c=0
Rz11 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz12 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz13 (\10\:VDD \1\:VDD) resistor r=7.5 c=0
Rz14 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz18 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz19 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz20 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz1 (Eb \2\:Eb) resistor r=75 c=0
Rz2 (\8\:Eb \9\:Eb) resistor r=75 c=0
Rz3 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz4 (\7\:n5 \8\:n5) resistor r=75 c=0
Rz5 (\14\:CKbb \13\:CKbb) resistor r=75 c=0
Rz6 (\18\:Eint \17\:Eint) resistor r=75 c=0
Rz7 (\24\:ECKb \23\:ECKb) resistor r=75 c=0
Ry15 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry17 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry18 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry19 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry20 (\6\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry21 (\9\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry1 (\3\:Eb \4\:Eb) resistor r=62 c=0
Ry2 (\6\:Eb \7\:Eb) resistor r=62 c=0
Ry3 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry4 (\5\:n5 \6\:n5) resistor r=62 c=0
Ry5 (\11\:CKbb \10\:CKbb) resistor r=62 c=0
Ry6 (\16\:Eint \15\:Eint) resistor r=62 c=0
Rx3 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\2\:SE \4\:SE) resistor r=45 c=0
Rx1 (\3\:E \5\:E) resistor r=45 c=0
Rx4 (\7\:CKb \8\:CKb) resistor r=45 c=0
Rx5 (\2\:CKb \10\:CKb) resistor r=45 c=0
Rx6 (\4\:CKb \11\:CKb) resistor r=45 c=0
Rx7 (\2\:n5 \4\:n5) resistor r=45 c=0
Rx8 (\12\:CKbb \2\:CKbb) resistor r=45 c=0
Rx9 (\15\:CKbb \5\:CKbb) resistor r=45 c=0
Rx10 (\11\:Eint \4\:Eint) resistor r=45 c=0
Rx13 (\20\:ECKb \7\:ECKb) resistor r=45 c=0
mn1 (\8\:Eb \4\:E \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.61e-14 ps=5.7e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.85e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn0 (\8\:Eb \3\:SE \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.393e-14 ad=2.61e-14 ps=6.2e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=4.6e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (\12\:CKb \3\:CK \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=3.625e-14 ps=6.2e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=2.5e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn5 (Eb CKb \7\:n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=5.8e-14 \
        ad=2.03e-14 ps=1.09e-06 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.85e-07 sd=160n sca=14.3814 scb=0.0152134 \
        scc=0.00088947 m=(1)
mn16 (\7\:n5 CKbb net263 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.8e-14 ps=6.1e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=5.4e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn15 (net263 Eint \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.84e-14 ad=2.32e-14 ps=1.46e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=3.35e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn3 (\13\:CKbb \6\:CKb \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.84e-14 ad=2.03e-14 ps=1.46e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=1.4e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn10 (\17\:Eint n5 \19\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.885e-14 ad=2.87e-14 ps=1.58e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.54476e-06 sd=160n sca=18.43 \
        scb=0.0187068 scc=0.00173343 m=(1)
mn20_1__rcx (16 \5\:Eint \19\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.885e-14 ad=1.56e-14 ps=1.58e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.19135e-07 sb=1.63e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn21_1__rcx (\23\:ECKb \9\:CKbb 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.24135e-07 sb=1.525e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn21 (\23\:ECKb \4\:CKbb 17 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.86e-14 ad=4.16e-14 ps=7.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.29135e-07 sb=1.32e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn20 (17 \10\:Eint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.66e-14 ad=2.86e-14 ps=9.4e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.84135e-07 sb=1.165e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn22_1__rcx (ECK ECKb \3\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.9e-14 ad=4.836e-14 ps=9.4e-07 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45726e-07 sb=9.6e-07 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(5)
mp0 (net246 \1\:SE \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=1.29e-14 ps=7.6e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.9e-07 sd=160n sca=14.2155 \
        scb=0.0125694 scc=0.000239267 m=(1)
mp2 (\14\:CKb \1\:CK \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=6.02e-14 ps=7.6e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=2.8e-07 sd=160n sca=12.3184 \
        scb=0.0100356 scc=0.000221045 m=(1)
mp5 (\5\:n5 \3\:CKbb \3\:Eb VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.375e-14 ad=3.44e-14 ps=9.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.5e-07 sb=8e-07 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp16 (\5\:n5 \3\:CKb net234 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.44e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=5.95e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp15 (net234 \3\:Eint \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.95e-14 ad=3.118e-14 ps=1.74e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.45e-07 sb=4.05e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp3 (\10\:CKbb \5\:CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.95e-14 ad=3.01e-14 ps=1.74e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=1.4e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp10 (\15\:Eint \3\:n5 \3\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=8.835e-14 ps=1.1e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.985e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp20_1__rcx (\17\:ECKb \6\:Eint \3\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.4e-14 ad=6.24e-14 ps=1.18e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=4.1e-07 sb=1.78e-06 sd=160n sca=15.8351 \
        scb=0.0142471 scc=0.00110276 m=(2)
mp21_1__rcx (\17\:ECKb \5\:CKbb \18\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=6.15e-07 sb=1.575e-06 sd=160n \
        sca=15.8351 scb=0.0142471 scc=0.00110276 m=(2)
mp22_1__rcx (ECK ECKb \3\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.424e-14 ad=7.332e-14 ps=1.26e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.03766e-06 sb=9.6e-07 sd=160n sca=26.9787 \
        scb=0.0178954 scc=0.0027966 m=(5)
ends TLATNTSCAX6
// End of subcircuit definition.

// Generated for: spectre (May  9 18:32:38 2012 )
// Library name: gsclib045
// Cell name: TLATNTSCAX8
// View name: extracted

simulator lang=spectre

subckt TLATNTSCAX8 CK E ECK SE VDD VSS
mp1 (\5\:Eb \1\:E net246 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.25e-07 sd=160n sca=18.4859 \
        scb=0.0197569 scc=0.000618499 m=(1)
C1 (VDD VSS) capacitor c=3.02481e-16
C2 (E VSS) capacitor c=5.05166e-17
C3 (ECK VSS) capacitor c=4.74229e-16
C4 (Eb VSS) capacitor c=7.43444e-17
C5 (CKb VSS) capacitor c=2.94681e-17
C6 (n5 VSS) capacitor c=4.82333e-17
C7 (net263 VSS) capacitor c=1.22737e-18
C8 (CKbb VSS) capacitor c=2.36421e-17
C9 (Eint VSS) capacitor c=3.51748e-17
C10 (ECKb VSS) capacitor c=3.41511e-16
C11 (17 VSS) capacitor c=3.34753e-18
C12 (net246 VSS) capacitor c=1.44649e-18
C13 (net234 VSS) capacitor c=1.33092e-18
C14 (\3\:n5 VSS) capacitor c=3.96581e-17
C15 (\5\:CKb VSS) capacitor c=4.81812e-17
C16 (\3\:Eint VSS) capacitor c=7.00859e-17
C17 (\3\:CKb VSS) capacitor c=6.30284e-17
C18 (\3\:CKbb VSS) capacitor c=6.33719e-17
C19 (\1\:CK VSS) capacitor c=4.14703e-17
C20 (\1\:SE VSS) capacitor c=9.24427e-17
C21 (\1\:E VSS) capacitor c=9.27168e-17
C22 (\10\:Eint VSS) capacitor c=8.44518e-17
C23 (\4\:CKbb VSS) capacitor c=5.30415e-17
C24 (\9\:CKbb VSS) capacitor c=3.69764e-17
C25 (\4\:Eint VSS) capacitor c=6.19103e-17
C26 (\6\:CKb VSS) capacitor c=5.30073e-17
C27 (\3\:CK VSS) capacitor c=3.70793e-17
C28 (\3\:SE VSS) capacitor c=3.13396e-17
C29 (\4\:E VSS) capacitor c=2.52026e-17
C30 (\9\:ECKb VSS) capacitor c=3.50925e-17
C31 (\5\:Eint VSS) capacitor c=3.73801e-16
C32 (\2\:n5 VSS) capacitor c=4.22517e-17
C33 (\7\:CKb VSS) capacitor c=1.58994e-17
C34 (\2\:Eint VSS) capacitor c=8.25727e-17
C35 (\2\:CKbb VSS) capacitor c=8.08881e-17
C36 (\4\:CKb VSS) capacitor c=5.56036e-17
C37 (\2\:CKb VSS) capacitor c=1.8782e-17
C38 (\2\:CK VSS) capacitor c=4.40684e-17
C39 (\2\:SE VSS) capacitor c=7.74061e-17
C40 (\3\:E VSS) capacitor c=1.22628e-17
C41 (\1\:VDD VSS) capacitor c=3.96947e-16
C42 (\23\:ECKb VSS) capacitor c=2.1433e-16
C43 (\16\:VDD VSS) capacitor c=4.02543e-17
C44 (\18\:Eint VSS) capacitor c=6.48411e-17
C45 (\14\:CKbb VSS) capacitor c=1.13701e-16
C46 (\21\:VDD VSS) capacitor c=5.55368e-17
C47 (\8\:n5 VSS) capacitor c=1.34099e-17
C48 (\7\:Eb VSS) capacitor c=2.12438e-17
C49 (\14\:CKb VSS) capacitor c=1.04512e-16
C50 (\25\:VDD VSS) capacitor c=4.98853e-17
C51 (\5\:Eb VSS) capacitor c=1.16139e-17
C52 (\3\:VDD VSS) capacitor c=1.04831e-16
C53 (\29\:ECKb VSS) capacitor c=4.95806e-17
C54 (\14\:Eint VSS) capacitor c=5.32114e-17
C55 (\11\:CKbb VSS) capacitor c=1.97778e-16
C56 (\6\:n5 VSS) capacitor c=8.09313e-17
C57 (\11\:CKb VSS) capacitor c=9.50604e-17
C58 (\9\:Eb VSS) capacitor c=9.28679e-17
C59 (\2\:E VSS) capacitor c=5.7908e-17
C60 (\5\:CKbb VSS) capacitor c=1.529e-16
C61 (\5\:E VSS) capacitor c=4.27151e-17
C62 (\4\:SE VSS) capacitor c=1.29021e-16
C63 (\4\:CK VSS) capacitor c=1.19179e-16
C64 (\3\:Eb VSS) capacitor c=1.16021e-16
C65 (\4\:Eb VSS) capacitor c=1.52991e-16
C66 (\8\:CKb VSS) capacitor c=7.78971e-17
C67 (\9\:CKb VSS) capacitor c=9.3556e-17
C68 (\10\:CKb VSS) capacitor c=4.78252e-17
C69 (\13\:CKb VSS) capacitor c=9.74718e-17
C70 (\4\:n5 VSS) capacitor c=1.57111e-16
C71 (\5\:n5 VSS) capacitor c=1.97228e-16
C72 (\10\:CKbb VSS) capacitor c=1.25102e-16
C73 (\13\:CKbb VSS) capacitor c=1.66025e-16
C74 (\13\:Eint VSS) capacitor c=3.34798e-17
C75 (\16\:Eint VSS) capacitor c=6.04305e-17
C76 (\17\:Eint VSS) capacitor c=7.92323e-17
C77 (\26\:ECKb VSS) capacitor c=9.60701e-17
C78 (\20\:VDD VSS) capacitor c=1.99535e-17
C79 (\24\:VDD VSS) capacitor c=3.73678e-19
Rk3 (CK \4\:CK) resistor r=0.0026 c=0
Rk2 (SE \4\:SE) resistor r=0.003157 c=0
Rk51 (\1\:VDD \17\:VDD) resistor r=0.2343 c=0
Rk53 (\1\:VDD \20\:VDD) resistor r=0.4442 c=0
Rk54 (\20\:VDD \22\:VDD) resistor r=0.2679 c=0
Rk55 (\20\:VDD \23\:VDD) resistor r=0.3083 c=0
Rk56 (\23\:VDD \24\:VDD) resistor r=0.3158 c=0
Rk57 (\24\:VDD \26\:VDD) resistor r=0.3046 c=0
Rk59 (\27\:VDD VDD) resistor r=0.1001 c=0
Rk58 (\24\:VDD \27\:VDD) resistor r=0.1352 c=0
Rk1 (\5\:E E) resistor r=0.176 c=0
Rk60 (\2\:VSS \3\:VSS) resistor r=0.03241 c=0
Rk64 (\3\:VSS \7\:VSS) resistor r=0.1453 c=0
Rk65 (\7\:VSS \8\:VSS) resistor r=0.1754 c=0
Rk66 (\8\:VSS \9\:VSS) resistor r=0.431 c=0
Rk67 (\9\:VSS \10\:VSS) resistor r=0.4964 c=0
Rk69 (\11\:VSS VSS) resistor r=0.2206 c=0
Rk68 (\10\:VSS \11\:VSS) resistor r=0.2305 c=0
Rk70 (VSS \13\:VSS) resistor r=0.1826 c=0
Rk75 (\8\:VSS \23\:VSS) resistor r=0.2945 c=0
Rk76 (\9\:VSS \25\:VSS) resistor r=0.1895 c=0
Rk77 (\11\:VSS \27\:VSS) resistor r=0.1763 c=0
Rk4 (\2\:Eb \3\:Eb) resistor r=0.4479 c=0
Rk5 (\3\:Eb \4\:Eb) resistor r=0.7504 c=0
Rk6 (\4\:Eb \6\:Eb) resistor r=0.1114 c=0
Rk7 (\3\:Eb \8\:Eb) resistor r=0.04435 c=0
Rk8 (\4\:Eb \10\:Eb) resistor r=0.5669 c=0
Rk9 (\8\:CKb \9\:CKb) resistor r=0.3353 c=0
Rk10 (\9\:CKb \10\:CKb) resistor r=0.3119 c=0
Rk11 (\10\:CKb \12\:CKb) resistor r=0.2729 c=0
Rk12 (\9\:CKb \13\:CKb) resistor r=0.4926 c=0
Rk13 (\12\:CKb \15\:CKb) resistor r=0.5503 c=0
Rk14 (\4\:n5 \5\:n5) resistor r=1.1857 c=0
Rk15 (\5\:n5 \7\:n5) resistor r=0.4734 c=0
Rk16 (\5\:n5 \9\:n5) resistor r=0.0279 c=0
Rk17 (\10\:CKbb \12\:CKbb) resistor r=0.9808 c=0
Rk18 (\12\:CKbb \13\:CKbb) resistor r=0.5898 c=0
Rk19 (\13\:CKbb \15\:CKbb) resistor r=0.6545 c=0
Rk21 (\5\:Eint \13\:Eint) resistor r=0.2174 c=0
Rk22 (\13\:Eint \15\:Eint) resistor r=0.1815 c=0
Rk23 (\13\:Eint \16\:Eint) resistor r=0.1259 c=0
Rk24 (\16\:Eint \17\:Eint) resistor r=0.3976 c=0
Rk25 (\16\:Eint \19\:Eint) resistor r=0.2359 c=0
Rk27 (\23\:ECKb \26\:ECKb) resistor r=0.4253 c=0
Rk29 (\26\:ECKb \30\:ECKb) resistor r=0.3739 c=0
Rl6 (\1\:CK \2\:CK) resistor r=144.923 c=0
Rl7 (\2\:CK \3\:CK) resistor r=96.8456 c=0
Rl4 (\1\:SE \2\:SE) resistor r=201.156 c=0
Rl5 (\2\:SE \3\:SE) resistor r=37.6944 c=0
Rl1 (\1\:E \2\:E) resistor r=248.385 c=0
Rl3 (\2\:E \4\:E) resistor r=31.4325 c=0
Rl2 (\2\:E \3\:E) resistor r=9.7447 c=0
Rl14 (\5\:CKb \6\:CKb) resistor r=195.72 c=0
Rl15 (\6\:CKb \7\:CKb) resistor r=29.5379 c=0
Rl9 (\3\:CKb \4\:CKb) resistor r=74.4182 c=0
Rl8 (CKb \2\:CKb) resistor r=74.2328 c=0
Rl16 (n5 \2\:n5) resistor r=149.566 c=0
Rl17 (\2\:n5 \3\:n5) resistor r=26.3736 c=0
Rl10 (\2\:CKbb CKbb) resistor r=24.2328 c=0
Rl11 (\2\:CKbb \3\:CKbb) resistor r=224.554 c=0
Rl20 (\5\:CKbb \4\:CKbb) resistor r=78.824 c=0
Rl24 (\5\:CKbb \9\:CKbb) resistor r=24.7951 c=0
Rl27 (\5\:Eint \10\:Eint) resistor r=106.708 c=0
Rl18 (\5\:Eint \4\:Eint) resistor r=105.746 c=0
Rl12 (\2\:Eint Eint) resistor r=37.6365 c=0
Rl13 (\2\:Eint \3\:Eint) resistor r=146.817 c=0
Rl35 (ECKb \9\:ECKb) resistor r=6.6042 c=0
Rz12 (\1\:VDD \3\:VDD) resistor r=4.4118 c=0
Rz14 (\23\:VDD \3\:VDD) resistor r=12.5 c=0
Rz15 (\27\:VDD \3\:VDD) resistor r=25 c=0
Rz16 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz21 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz22 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz23 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz1 (Eb \2\:Eb) resistor r=75 c=0
Rz2 (\9\:Eb \10\:Eb) resistor r=75 c=0
Rz3 (\11\:CKb \12\:CKb) resistor r=75 c=0
Rz4 (\6\:n5 \7\:n5) resistor r=75 c=0
Rz5 (\12\:CKbb \11\:CKbb) resistor r=75 c=0
Rz6 (\15\:Eint \14\:Eint) resistor r=75 c=0
Rz7 (\30\:ECKb \29\:ECKb) resistor r=75 c=0
Ry17 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry19 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry20 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry21 (\2\:VSS \1\:VSS) resistor r=15.5 c=0
Ry22 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry23 (\10\:VSS \1\:VSS) resistor r=6.2 c=0
Ry1 (\5\:Eb \6\:Eb) resistor r=62 c=0
Ry2 (\7\:Eb \8\:Eb) resistor r=62 c=0
Ry3 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry4 (\8\:n5 \9\:n5) resistor r=62 c=0
Ry5 (\15\:CKbb \14\:CKbb) resistor r=62 c=0
Ry6 (\19\:Eint \18\:Eint) resistor r=62 c=0
Rx3 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\2\:SE \4\:SE) resistor r=45 c=0
Rx1 (\3\:E \5\:E) resistor r=45 c=0
Rx4 (\4\:CKb \8\:CKb) resistor r=45 c=0
Rx5 (\2\:CKb \10\:CKb) resistor r=45 c=0
Rx6 (\7\:CKb \13\:CKb) resistor r=45 c=0
Rx7 (\2\:n5 \4\:n5) resistor r=45 c=0
Rx8 (\10\:CKbb \5\:CKbb) resistor r=45 c=0
Rx9 (\13\:CKbb \2\:CKbb) resistor r=45 c=0
Rx12 (\17\:Eint \2\:Eint) resistor r=45 c=0
Rx13 (\26\:ECKb \9\:ECKb) resistor r=45 c=0
mn1 (\9\:Eb \4\:E \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.61e-14 ps=5.7e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.7e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn0 (\9\:Eb \3\:SE \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=2.61e-14 ps=6.5e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=4.45e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (\11\:CKb \3\:CK \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=3.19e-14 ps=6.5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=2.2e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn5 (Eb CKb \6\:n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=5.365e-14 \
        ad=2.03e-14 ps=1.03e-06 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.115e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn16 (\6\:n5 CKbb net263 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=5.365e-14 ps=5.6e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=7e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn15 (net263 Eint \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=1.957e-14 ps=1.36e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=5.2e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn3 (\11\:CKbb \6\:CKb \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.12e-14 ad=2.827e-14 ps=1.36e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=1.95e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn10 (\14\:Eint n5 \22\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.187e-14 ad=2.87e-14 ps=1.07e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.4389 scb=0.0137383 \
        scc=0.000784938 m=(1)
mn20_1__rcx (16 \4\:Eint \22\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.187e-14 ad=2.08e-14 ps=1.07e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.83846e-07 sb=2e-06 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mn21_1__rcx (\29\:ECKb \9\:CKbb 16 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=2.08e-14 ad=4.16e-14 ps=6.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.08846e-07 sb=1.9e-06 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mn21 (\29\:ECKb \4\:CKbb 17 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.13846e-07 sb=1.695e-06 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mn20 (17 \10\:Eint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=1.56e-14 ps=9.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.18846e-07 sb=1.59e-06 sd=160n sca=12.1772 \
        scb=0.0118935 scc=0.000630577 m=(1)
mn22_1__rcx (ECK ECKb \3\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.762e-14 ps=9.1e-07 pd=9.1286e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.14237e-07 sb=1.385e-06 sd=160n sca=13.9473 \
        scb=0.0136631 scc=0.00097867 m=(7)
mp0 (net246 \1\:SE \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=1.29e-14 ps=7.9e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.2e-07 sd=160n sca=16.022 \
        scb=0.0154303 scc=0.000486038 m=(1)
mp2 (\14\:CKb \1\:CK \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=6.342e-14 ps=7.9e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.7e-07 sb=2.95e-07 sd=160n sca=13.8909 \
        scb=0.0125053 scc=0.000462042 m=(1)
mp5 (\8\:n5 \3\:CKbb \7\:Eb VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=3.44e-14 ps=8.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=8.3e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp16 (\8\:n5 \3\:CKb net234 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=6.25e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp15 (net234 \3\:Eint \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.203e-14 ad=1.29e-14 ps=1.1e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.15e-07 sb=5.2e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp3 (\14\:CKbb \5\:CKb \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.203e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=1.4e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp10 (\18\:Eint \3\:n5 \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.705e-14 ad=4.96e-14 ps=1.29e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2e-06 sd=160n sca=11.3312 scb=0.00941412 \
        scc=0.000228915 m=(1)
mp20_1__rcx (\23\:ECKb \5\:Eint \1\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=7.747e-14 ad=6.24e-14 ps=1.25e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.86154e-07 sb=2e-06 sd=160n \
        sca=13.5671 scb=0.012183 scc=0.000647513 m=(2)
mp21_1__rcx (\23\:ECKb \5\:CKbb \16\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=5.91154e-07 sb=1.985e-06 sd=160n \
        sca=13.5671 scb=0.012183 scc=0.000647513 m=(2)
mp22_1__rcx (ECK ECKb \1\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=6.993e-14 ps=1.21e-06 pd=1.20429e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.06944e-06 sb=1.37e-06 sd=160n sca=16.8284 \
        scb=0.0145775 scc=0.00130846 m=(7)
ends TLATNTSCAX8
// End of subcircuit definition.

// Generated for: spectre (May  9 18:33:16 2012 )
// Library name: gsclib045
// Cell name: TLATNX1
// View name: extracted

simulator lang=spectre

subckt TLATNX1 D GN Q QN VDD VSS
mp1 (\6\:GNbb GNb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.93e-14 ad=3.01e-14 ps=1.07e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.235e-06 sd=160n sca=19.0466 \
        scb=0.0202158 scc=0.000796115 m=(1)
C1 (GN VSS) capacitor c=7.44346e-17
C2 (D VSS) capacitor c=5.4498e-17
C3 (VDD VSS) capacitor c=1.96843e-16
C4 (QN VSS) capacitor c=4.45725e-17
C5 (GNb VSS) capacitor c=5.24526e-17
C6 (GNbb VSS) capacitor c=4.5834e-17
C7 (n0 VSS) capacitor c=4.47901e-17
C8 (net245 VSS) capacitor c=5.30936e-18
C9 (Qint VSS) capacitor c=5.83044e-17
C10 (Qbint VSS) capacitor c=3.99148e-17
C11 (net220 VSS) capacitor c=1.66212e-18
C12 (\4\:Qint VSS) capacitor c=3.5e-17
C13 (\10\:Qint VSS) capacitor c=3.55705e-17
C14 (\1\:GN VSS) capacitor c=3.13979e-17
C15 (\6\:GNb VSS) capacitor c=7.00952e-17
C16 (\3\:GNbb VSS) capacitor c=4.98618e-17
C17 (\1\:D VSS) capacitor c=5.11351e-17
C18 (\4\:Qbint VSS) capacitor c=3.25268e-17
C19 (\8\:Qint VSS) capacitor c=2.81574e-17
C20 (\9\:Qint VSS) capacitor c=2.44009e-17
C21 (\3\:GN VSS) capacitor c=3.0595e-17
C22 (\3\:n0 VSS) capacitor c=2.56325e-17
C23 (\3\:Qint VSS) capacitor c=5.11662e-17
C24 (\4\:GNb VSS) capacitor c=6.7929e-17
C25 (\4\:D VSS) capacitor c=8.28465e-17
C26 (\3\:GNb VSS) capacitor c=2.82292e-17
C27 (\3\:Qbint VSS) capacitor c=2.21777e-17
C28 (\7\:Qint VSS) capacitor c=3.2285e-17
C29 (\2\:GN VSS) capacitor c=2.5074e-17
C30 (\2\:n0 VSS) capacitor c=3.86557e-17
C31 (\2\:Qint VSS) capacitor c=4.95016e-17
C32 (\7\:GNb VSS) capacitor c=3.37128e-17
C33 (\2\:GNbb VSS) capacitor c=7.65417e-17
C34 (\5\:GNb VSS) capacitor c=5.11588e-17
C35 (\3\:D VSS) capacitor c=2.66669e-17
C36 (\2\:GNb VSS) capacitor c=4.61411e-17
C37 (\1\:Q VSS) capacitor c=6.7585e-17
C38 (\1\:VDD VSS) capacitor c=9.74009e-17
C39 (\9\:Qbint VSS) capacitor c=8.65122e-17
C40 (\3\:QN VSS) capacitor c=9.7768e-17
C41 (\9\:VDD VSS) capacitor c=4.92313e-17
C42 (\8\:GNb VSS) capacitor c=1.61185e-16
C43 (\17\:Qint VSS) capacitor c=2.42766e-17
C44 (\11\:VDD VSS) capacitor c=1.42162e-17
C45 (\8\:n0 VSS) capacitor c=7.60581e-17
C46 (\13\:VDD VSS) capacitor c=3.50257e-17
C47 (\6\:GNbb VSS) capacitor c=1.11897e-16
C48 (\3\:VDD VSS) capacitor c=4.54472e-17
C49 (\3\:Q VSS) capacitor c=5.13212e-17
C50 (\7\:Qbint VSS) capacitor c=2.78599e-17
C51 (\1\:QN VSS) capacitor c=2.93625e-17
C52 (\11\:GNb VSS) capacitor c=5.33403e-17
C53 (\15\:Qint VSS) capacitor c=2.36829e-17
C54 (\6\:n0 VSS) capacitor c=5.69356e-17
C55 (\4\:GNbb VSS) capacitor c=6.54587e-17
C56 (\2\:D VSS) capacitor c=4.48098e-17
C57 (\5\:Qint VSS) capacitor c=3.6988e-17
C58 (\2\:Qbint VSS) capacitor c=1.28988e-17
C59 (\5\:D VSS) capacitor c=6.63632e-17
C60 (\8\:GNbb VSS) capacitor c=1.0239e-16
C61 (\4\:n0 VSS) capacitor c=5.30425e-17
C62 (\5\:n0 VSS) capacitor c=8.81209e-17
C63 (\10\:GNb VSS) capacitor c=1.97957e-16
C64 (\13\:GNb VSS) capacitor c=7.58381e-17
C65 (\14\:GNb VSS) capacitor c=4.85507e-17
C66 (\4\:GN VSS) capacitor c=3.99573e-17
C67 (\11\:Qint VSS) capacitor c=1.30724e-16
C68 (\12\:Qint VSS) capacitor c=7.81695e-17
C69 (\13\:Qint VSS) capacitor c=4.44753e-17
C70 (\14\:Qint VSS) capacitor c=5.23317e-17
C71 (\5\:Qbint VSS) capacitor c=3.64228e-17
C72 (\6\:Qbint VSS) capacitor c=2.9445e-17
C73 (\5\:VDD VSS) capacitor c=1.72199e-17
C74 (\6\:VDD VSS) capacitor c=3.67188e-17
C75 (\8\:VDD VSS) capacitor c=5.9822e-18
Rk11 (\4\:GN GN) resistor r=0.1254 c=0
Rk33 (\2\:VSS \4\:VSS) resistor r=0.3329 c=0
Rk34 (\4\:VSS \5\:VSS) resistor r=0.3184 c=0
Rk35 (\5\:VSS \6\:VSS) resistor r=0.5008 c=0
Rk36 (\6\:VSS \7\:VSS) resistor r=0.03238 c=0
Rk38 (\8\:VSS VSS) resistor r=0.18 c=0
Rk37 (\7\:VSS \8\:VSS) resistor r=0.3707 c=0
Rk39 (\5\:VSS \10\:VSS) resistor r=0.2916 c=0
Rk40 (\6\:VSS \12\:VSS) resistor r=0.2953 c=0
Rk41 (\8\:VSS \14\:VSS) resistor r=0.2934 c=0
Rk1 (\5\:D D) resistor r=0.1521 c=0
Rk24 (\2\:VDD \4\:VDD) resistor r=0.6646 c=0
Rk25 (\4\:VDD \5\:VDD) resistor r=0.05744 c=0
Rk26 (\5\:VDD \6\:VDD) resistor r=0.4832 c=0
Rk27 (\6\:VDD \7\:VDD) resistor r=0.3105 c=0
Rk29 (\8\:VDD VDD) resistor r=0.195 c=0
Rk28 (\7\:VDD \8\:VDD) resistor r=0.105 c=0
Rk30 (\5\:VDD \10\:VDD) resistor r=0.2849 c=0
Rk31 (\6\:VDD \12\:VDD) resistor r=0.07334 c=0
Rk32 (\8\:VDD \14\:VDD) resistor r=0.2525 c=0
Rk22 (\2\:Q Q) resistor r=0.3732 c=0
Rk23 (Q \4\:Q) resistor r=0.01117 c=0
Rk17 (QN \2\:QN) resistor r=0.03891 c=0
Rk18 (QN \4\:QN) resistor r=0.2873 c=0
Rk7 (\9\:GNb \10\:GNb) resistor r=1.3057 c=0
Rk8 (\9\:GNb \12\:GNb) resistor r=0.2949 c=0
Rk9 (\10\:GNb \13\:GNb) resistor r=0.3651 c=0
Rk10 (\13\:GNb \14\:GNb) resistor r=0.2223 c=0
Rk2 (\5\:GNbb \7\:GNbb) resistor r=0.5809 c=0
Rk3 (\7\:GNbb \8\:GNbb) resistor r=0.4962 c=0
Rk4 (\4\:n0 \5\:n0) resistor r=0.2114 c=0
Rk5 (\5\:n0 \7\:n0) resistor r=0.391 c=0
Rk6 (\5\:n0 \9\:n0) resistor r=0.3421 c=0
Rk12 (\11\:Qint \12\:Qint) resistor r=0.7883 c=0
Rk13 (\12\:Qint \13\:Qint) resistor r=0.298 c=0
Rk14 (\13\:Qint \14\:Qint) resistor r=0.2114 c=0
Rk15 (\12\:Qint \16\:Qint) resistor r=0.03766 c=0
Rk16 (\13\:Qint \18\:Qint) resistor r=0.1368 c=0
Rk19 (\5\:Qbint \6\:Qbint) resistor r=0.1514 c=0
Rk20 (\6\:Qbint \8\:Qbint) resistor r=0.1265 c=0
Rk21 (\6\:Qbint \10\:Qbint) resistor r=0.2772 c=0
Rl14 (\1\:GN \2\:GN) resistor r=30.7692 c=0
Rl15 (\2\:GN \3\:GN) resistor r=56.8681 c=0
Rl3 (\1\:D \2\:D) resistor r=52.2314 c=0
Rl5 (\2\:D \4\:D) resistor r=127.586 c=0
Rl4 (\2\:D \3\:D) resistor r=5.8511 c=0
Rl9 (\6\:GNb \7\:GNb) resistor r=56.7875 c=0
Rl6 (\4\:GNb \5\:GNb) resistor r=26.1559 c=0
Rl1 (GNb \2\:GNb) resistor r=135.771 c=0
Rl2 (\2\:GNb \3\:GNb) resistor r=26.1559 c=0
Rl7 (GNbb \2\:GNbb) resistor r=126.477 c=0
Rl8 (\2\:GNbb \3\:GNbb) resistor r=74.2328 c=0
Rl12 (n0 \2\:n0) resistor r=115.643 c=0
Rl13 (\2\:n0 \3\:n0) resistor r=49.7951 c=0
Rl10 (Qint \2\:Qint) resistor r=24.2328 c=0
Rl11 (\2\:Qint \3\:Qint) resistor r=141.213 c=0
Rl16 (\4\:Qint \5\:Qint) resistor r=60.772 c=0
Rl19 (\5\:Qint \8\:Qint) resistor r=30.0028 c=0
Rl21 (\6\:Qint \10\:Qint) resistor r=74.7185 c=0
Rl20 (\6\:Qint \9\:Qint) resistor r=40.1031 c=0
Rl18 (\6\:Qint \7\:Qint) resistor r=2.9824 c=0
Rl17 (\5\:Qint \6\:Qint) resistor r=146.3 c=0
Rl22 (Qbint \2\:Qbint) resistor r=51.6372 c=0
Rl24 (\2\:Qbint \4\:Qbint) resistor r=34.3295 c=0
Rl23 (\2\:Qbint \3\:Qbint) resistor r=2.0166 c=0
Rz10 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz11 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz12 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz13 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz8 (\3\:VDD \4\:VDD) resistor r=7.5 c=0
Rz9 (\3\:VDD \7\:VDD) resistor r=10.7143 c=0
Rz7 (\3\:Q \4\:Q) resistor r=75 c=0
Rz5 (\1\:QN \2\:QN) resistor r=75 c=0
Rz3 (\11\:GNb \12\:GNb) resistor r=75 c=0
Rz1 (\4\:GNbb \5\:GNbb) resistor r=75 c=0
Rz2 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz4 (\15\:Qint \16\:Qint) resistor r=75 c=0
Rz6 (\7\:Qbint \8\:Qbint) resistor r=75 c=0
Ry12 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry13 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry8 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry9 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry10 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry11 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry7 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry5 (\3\:QN \4\:QN) resistor r=20.6667 c=0
Ry3 (\8\:GNb \9\:GNb) resistor r=62 c=0
Ry1 (\6\:GNbb \7\:GNbb) resistor r=62 c=0
Ry2 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry4 (\17\:Qint \18\:Qint) resistor r=62 c=0
Ry6 (\9\:Qbint \10\:Qbint) resistor r=20.6667 c=0
Rx7 (\2\:GN \4\:GN) resistor r=45 c=0
Rx1 (\3\:D \5\:D) resistor r=45 c=0
Rx4 (\7\:GNb \10\:GNb) resistor r=45 c=0
Rx5 (\5\:GNb \13\:GNb) resistor r=45 c=0
Rx6 (\2\:GNb \14\:GNb) resistor r=45 c=0
Rx2 (\2\:GNbb \8\:GNbb) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx8 (\7\:Qint \11\:Qint) resistor r=45 c=0
Rx9 (\2\:Qint \14\:Qint) resistor r=45 c=0
Rx10 (\3\:Qbint \5\:Qbint) resistor r=45 c=0
mn1 (\4\:GNbb \3\:GNb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.15e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn5 (net257 \4\:D \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn6 (\6\:n0 \4\:GNb net257 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=8.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn16 (\6\:n0 GNbb net245 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.553e-14 ad=2.32e-14 ps=7.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=6.35e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn15 (net245 \3\:Qint \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.553e-14 ps=6.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn10 (\15\:Qint \3\:n0 \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn0 (\11\:GNb \3\:GN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.742e-14 ad=2.465e-14 ps=1.09e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn22 (\1\:QN \9\:Qint \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.742e-14 ad=4.16e-14 ps=1.09e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.40769e-07 sb=1.6e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (\7\:Qbint \8\:Qint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(1)
mn21 (\3\:Q \4\:Qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(1)
mp5 (net220 \1\:D \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.93e-14 ad=1.828e-14 ps=1.07e-06 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=9.7e-07 sd=160n sca=15.442 \
        scb=0.0145142 scc=0.000695697 m=(1)
mp6 (\8\:n0 \3\:GNbb net220 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.828e-14 ad=6.128e-14 ps=6e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=8.4e-07 sd=160n sca=14.8088 \
        scb=0.0140105 scc=0.000694942 m=(1)
mp16 (\8\:n0 \6\:GNb net212 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.128e-14 ps=5.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=5.1e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp15 (net212 Qint \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.17e-14 ad=1.29e-14 ps=1.61e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=4.05e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp10 (\17\:Qint n0 \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.17e-14 ad=3.01e-14 ps=1.61e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.235e-06 sb=1.4e-07 sd=160n sca=14.2498 \
        scb=0.0138057 scc=0.00069487 m=(1)
mp0 (\8\:GNb \1\:GN \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.825e-14 ad=4.837e-14 ps=1.28e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=4.35e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp22 (\3\:QN \10\:Qint \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.825e-14 ad=5.46e-14 ps=1.28e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.49487e-07 sb=1.4e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp20 (\9\:Qbint \4\:Qint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.7e-07 sd=160n sca=31.7909 \
        scb=0.0210107 scc=0.00336206 m=(1)
mp21 (\1\:Q Qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.435e-14 ps=1.1e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.65e-07 sd=160n sca=34.23 \
        scb=0.0247192 scc=0.00340661 m=(1)
ends TLATNX1
// End of subcircuit definition.

// Generated for: spectre (May  9 18:33:57 2012 )
// Library name: gsclib045
// Cell name: TLATNX2
// View name: extracted

simulator lang=spectre

subckt TLATNX2 D GN Q QN VDD VSS
mp1 (\8\:GNbb GNb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.25791e-06 sd=160n sca=18.8037 \
        scb=0.0201527 scc=0.000687752 m=(1)
C1 (GN VSS) capacitor c=9.15527e-17
C2 (QN VSS) capacitor c=3.43986e-17
C3 (D VSS) capacitor c=5.98959e-17
C4 (VDD VSS) capacitor c=1.89855e-16
C5 (Q VSS) capacitor c=2.95621e-17
C6 (GNb VSS) capacitor c=4.75384e-17
C7 (GNbb VSS) capacitor c=4.75354e-17
C8 (n0 VSS) capacitor c=6.83065e-17
C9 (net245 VSS) capacitor c=6.91488e-18
C10 (Qint VSS) capacitor c=2.10541e-17
C11 (Qbint VSS) capacitor c=1.3198e-16
C12 (net212 VSS) capacitor c=6.52001e-19
C13 (\5\:Qint VSS) capacitor c=1.36418e-16
C14 (\1\:GN VSS) capacitor c=3.55652e-17
C15 (\4\:Qint VSS) capacitor c=5.99178e-17
C16 (\6\:GNb VSS) capacitor c=6.86674e-17
C17 (\3\:GNbb VSS) capacitor c=3.22985e-17
C18 (\1\:D VSS) capacitor c=5.19987e-17
C19 (\3\:GN VSS) capacitor c=3.21618e-17
C20 (\4\:n0 VSS) capacitor c=3.41047e-17
C21 (\3\:Qint VSS) capacitor c=5.84858e-17
C22 (\4\:GNb VSS) capacitor c=6.17457e-17
C23 (\3\:D VSS) capacitor c=6.3872e-17
C24 (\3\:GNb VSS) capacitor c=2.91871e-17
C25 (\4\:Qbint VSS) capacitor c=2.19524e-17
C26 (\10\:Qint VSS) capacitor c=1.45999e-17
C27 (\2\:GN VSS) capacitor c=3.24942e-17
C28 (\3\:n0 VSS) capacitor c=2.69855e-17
C29 (\7\:GNb VSS) capacitor c=2.74648e-17
C30 (\2\:GNbb VSS) capacitor c=7.28936e-17
C31 (\5\:GNb VSS) capacitor c=6.09041e-17
C32 (\2\:D VSS) capacitor c=6.73337e-17
C33 (\2\:GNb VSS) capacitor c=4.53614e-17
C34 (\1\:VDD VSS) capacitor c=3.3977e-16
C35 (\4\:Q VSS) capacitor c=8.93388e-17
C36 (\12\:Qbint VSS) capacitor c=8.54494e-17
C37 (\3\:QN VSS) capacitor c=8.87555e-17
C38 (\10\:GNb VSS) capacitor c=2.05328e-16
C39 (\23\:Qint VSS) capacitor c=3.96837e-17
C40 (\18\:VDD VSS) capacitor c=1.9112e-17
C41 (\9\:n0 VSS) capacitor c=9.7384e-17
C42 (\20\:VDD VSS) capacitor c=4.24225e-17
C43 (\8\:GNbb VSS) capacitor c=1.27173e-17
C44 (\4\:VDD VSS) capacitor c=3.67591e-17
C45 (\2\:Q VSS) capacitor c=1.25623e-17
C46 (\10\:Qbint VSS) capacitor c=1.62775e-17
C47 (\1\:QN VSS) capacitor c=3.36146e-17
C48 (\8\:GNb VSS) capacitor c=9.97515e-17
C49 (\19\:Qint VSS) capacitor c=1.17624e-16
C50 (\7\:n0 VSS) capacitor c=6.73873e-17
C51 (\6\:GNbb VSS) capacitor c=7.02049e-17
C52 (\2\:Qint VSS) capacitor c=4.61966e-17
C53 (\2\:n0 VSS) capacitor c=2.36538e-17
C54 (\8\:Qint VSS) capacitor c=1.17106e-16
C55 (\4\:D VSS) capacitor c=5.67487e-17
C56 (\4\:GNbb VSS) capacitor c=7.13098e-17
C57 (\5\:GNbb VSS) capacitor c=1.00992e-16
C58 (\5\:n0 VSS) capacitor c=2.46733e-17
C59 (\6\:n0 VSS) capacitor c=1.02489e-16
C60 (\12\:GNb VSS) capacitor c=1.97537e-16
C61 (\13\:GNb VSS) capacitor c=9.70421e-17
C62 (\14\:GNb VSS) capacitor c=5.16469e-17
C63 (\18\:Qint VSS) capacitor c=1.05649e-16
C64 (\21\:Qint VSS) capacitor c=6.49061e-17
C65 (\22\:Qint VSS) capacitor c=3.72495e-17
C66 (\8\:Qbint VSS) capacitor c=3.06263e-17
C67 (\9\:Qbint VSS) capacitor c=2.1901e-17
C68 (\1\:Q VSS) capacitor c=2.3866e-17
C69 (\8\:VDD VSS) capacitor c=1.63371e-17
C70 (\10\:VDD VSS) capacitor c=1.62502e-17
Rk12 (\4\:GN GN) resistor r=0.003656 c=0
Rk17 (QN \2\:QN) resistor r=0.08701 c=0
Rk18 (QN \4\:QN) resistor r=0.258 c=0
Rk43 (\1\:VSS \8\:VSS) resistor r=0.227 c=0
Rk44 (\8\:VSS \9\:VSS) resistor r=0.1477 c=0
Rk45 (\9\:VSS \10\:VSS) resistor r=0.4359 c=0
Rk47 (\11\:VSS VSS) resistor r=0.0499 c=0
Rk46 (\10\:VSS \11\:VSS) resistor r=0.1177 c=0
Rk51 (\9\:VSS \19\:VSS) resistor r=0.2267 c=0
Rk52 (\10\:VSS \21\:VSS) resistor r=0.2284 c=0
Rk1 (D \4\:D) resistor r=0.1747 c=0
Rk29 (\1\:VDD \8\:VDD) resistor r=0.3447 c=0
Rk30 (\8\:VDD \9\:VDD) resistor r=0.06655 c=0
Rk31 (\9\:VDD \10\:VDD) resistor r=0.3809 c=0
Rk33 (\11\:VDD VDD) resistor r=0.0499 c=0
Rk32 (\10\:VDD \11\:VDD) resistor r=0.1202 c=0
Rk37 (\8\:VDD \19\:VDD) resistor r=0.0433 c=0
Rk38 (\10\:VDD \21\:VDD) resistor r=0.3107 c=0
Rk22 (Q \1\:Q) resistor r=0.07163 c=0
Rk23 (\1\:Q \3\:Q) resistor r=0.09072 c=0
Rk24 (\1\:Q \5\:Q) resistor r=0.2617 c=0
Rk8 (\9\:GNb \11\:GNb) resistor r=0.5899 c=0
Rk9 (\11\:GNb \12\:GNb) resistor r=1.342 c=0
Rk10 (\12\:GNb \13\:GNb) resistor r=0.3888 c=0
Rk11 (\13\:GNb \14\:GNb) resistor r=0.2653 c=0
Rk2 (\4\:GNbb \5\:GNbb) resistor r=0.4794 c=0
Rk3 (\5\:GNbb \7\:GNbb) resistor r=0.6581 c=0
Rk4 (\5\:GNbb \9\:GNbb) resistor r=0.04786 c=0
Rk5 (\5\:n0 \6\:n0) resistor r=0.1391 c=0
Rk6 (\6\:n0 \8\:n0) resistor r=0.4154 c=0
Rk7 (\6\:n0 \10\:n0) resistor r=0.5473 c=0
Rk13 (\18\:Qint \20\:Qint) resistor r=0.6757 c=0
Rk14 (\20\:Qint \21\:Qint) resistor r=0.4154 c=0
Rk15 (\21\:Qint \22\:Qint) resistor r=0.15 c=0
Rk16 (\21\:Qint \24\:Qint) resistor r=0.1903 c=0
Rk19 (\8\:Qbint \9\:Qbint) resistor r=0.148 c=0
Rk20 (\9\:Qbint \11\:Qbint) resistor r=0.1176 c=0
Rk21 (\9\:Qbint \13\:Qbint) resistor r=0.3022 c=0
Rl15 (\1\:GN \2\:GN) resistor r=70.3867 c=0
Rl16 (\2\:GN \3\:GN) resistor r=24.2328 c=0
Rl3 (\1\:D \2\:D) resistor r=118.464 c=0
Rl4 (\2\:D \3\:D) resistor r=87.6944 c=0
Rl8 (\6\:GNb \7\:GNb) resistor r=41.3803 c=0
Rl5 (\4\:GNb \5\:GNb) resistor r=40.2307 c=0
Rl1 (GNb \2\:GNb) resistor r=168.37 c=0
Rl2 (\2\:GNb \3\:GNb) resistor r=39.1533 c=0
Rl6 (GNbb \2\:GNbb) resistor r=166.052 c=0
Rl7 (\2\:GNbb \3\:GNbb) resistor r=51.3736 c=0
Rl12 (n0 \2\:n0) resistor r=172.684 c=0
Rl14 (\2\:n0 \4\:n0) resistor r=26.0667 c=0
Rl13 (\2\:n0 \3\:n0) resistor r=8.3524 c=0
Rl9 (\2\:Qint Qint) resistor r=3.7334 c=0
Rl11 (\2\:Qint \4\:Qint) resistor r=37.3411 c=0
Rl10 (\2\:Qint \3\:Qint) resistor r=187.341 c=0
Rl19 (\8\:Qint \5\:Qint) resistor r=72.348 c=0
Rl21 (\8\:Qint \10\:Qint) resistor r=4.8851 c=0
Rl31 (Qbint \4\:Qbint) resistor r=5.6351 c=0
Rz5 (\2\:QN \1\:QN) resistor r=75 c=0
Rz15 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz16 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz8 (\1\:VDD \4\:VDD) resistor r=9.375 c=0
Rz9 (\9\:VDD \4\:VDD) resistor r=9.375 c=0
Rz10 (\11\:VDD \4\:VDD) resistor r=37.5 c=0
Rz7 (\3\:Q \2\:Q) resistor r=75 c=0
Rz3 (\8\:GNb \9\:GNb) resistor r=75 c=0
Rz1 (\6\:GNbb \7\:GNbb) resistor r=75 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz4 (\20\:Qint \19\:Qint) resistor r=75 c=0
Rz6 (\11\:Qbint \10\:Qbint) resistor r=75 c=0
Ry5 (\4\:QN \3\:QN) resistor r=20.6667 c=0
Ry14 (\1\:VSS \3\:VSS) resistor r=15.5 c=0
Ry15 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry16 (\11\:VSS \3\:VSS) resistor r=31 c=0
Ry12 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry13 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry7 (\5\:Q \4\:Q) resistor r=20.6667 c=0
Ry3 (\10\:GNb \11\:GNb) resistor r=62 c=0
Ry1 (\8\:GNbb \9\:GNbb) resistor r=62 c=0
Ry2 (\9\:n0 \10\:n0) resistor r=62 c=0
Ry4 (\24\:Qint \23\:Qint) resistor r=62 c=0
Ry6 (\13\:Qbint \12\:Qbint) resistor r=20.6667 c=0
Rx7 (\2\:GN \4\:GN) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\7\:GNb \12\:GNb) resistor r=45 c=0
Rx5 (\5\:GNb \13\:GNb) resistor r=45 c=0
Rx6 (\2\:GNb \14\:GNb) resistor r=45 c=0
Rx2 (\2\:GNbb \4\:GNbb) resistor r=45 c=0
Rx3 (\3\:n0 \5\:n0) resistor r=45 c=0
Rx8 (\18\:Qint \10\:Qint) resistor r=45 c=0
Rx9 (\22\:Qint Qint) resistor r=45 c=0
Rx10 (\8\:Qbint \4\:Qbint) resistor r=45 c=0
mn1 (\6\:GNbb \3\:GNb \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.393e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.24e-06 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn5 (net257 \3\:D \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.393e-14 ad=8.7e-15 ps=6.2e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.03e-06 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn6 (\7\:n0 \4\:GNb net257 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=9.25e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn16 (\7\:n0 GNbb net245 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.423e-14 ad=2.32e-14 ps=9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=7.2e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn15 (net245 \3\:Qint \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.283e-14 ad=4.423e-14 ps=7.8e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=3.7e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn10 (\19\:Qint \4\:n0 \18\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.283e-14 ad=2.87e-14 ps=7.8e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.06341e-07 sb=1.4e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn0 (\8\:GNb \3\:GN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.025e-14 ad=2.03e-14 ps=1.44e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.455e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn22 (\1\:QN \8\:Qint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.093e-14 ad=4.16e-14 ps=1.14e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.01058e-07 sb=1.19e-06 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(2)
mn20 (\10\:Qbint \5\:Qint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.11058e-07 sb=7.8e-07 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(2)
mn21 (\2\:Q Qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.81e-14 ps=8.2e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12106e-06 sb=3.7e-07 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(2)
mp5 (net220 \1\:D \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.118e-14 ps=7.5e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.05291e-06 sd=160n sca=15.2131 \
        scb=0.0141215 scc=0.000547625 m=(1)
mp6 (\9\:n0 \3\:GNbb net220 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=6.88e-14 ps=7.2e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=8.62907e-07 sd=160n sca=14.0479 \
        scb=0.0129451 scc=0.00054411 m=(1)
mp16 (\9\:n0 \6\:GNb net212 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.88e-14 ps=5.5e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=4.97907e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp15 (net212 \4\:Qint \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.465e-14 ad=1.29e-14 ps=1.58e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=3.92907e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp10 (\23\:Qint n0 \18\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.465e-14 ad=4.08e-14 ps=1.58e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.32903e-07 sb=1.31613e-07 sd=160n sca=12.3129 \
        scb=0.0108562 scc=0.00039161 m=(1)
mp0 (\10\:GNb \1\:GN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.48e-14 ad=3.01e-14 ps=1.22e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.455e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp22 (\3\:QN \8\:Qint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.36e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.68141e-07 sb=1.19e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp20 (\12\:Qbint \5\:Qint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.78141e-07 sb=7.8e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp21 (\4\:Q Qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=7.215e-14 ps=1.08e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.08814e-06 sb=3.7e-07 sd=160n sca=31.8955 \
        scb=0.0211257 scc=0.00336241 m=(2)
ends TLATNX2
// End of subcircuit definition.

// Generated for: spectre (May  9 18:34:36 2012 )
// Library name: gsclib045
// Cell name: TLATNX4
// View name: extracted

simulator lang=spectre

subckt TLATNX4 D GN Q QN VDD VSS
mp0 (\15\:GNb \1\:GN \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=27.6315 scb=0.0243605 \
        scc=0.00301984 m=(1)
C1 (D VSS) capacitor c=4.68926e-17
C2 (QN VSS) capacitor c=1.42042e-16
C3 (Q VSS) capacitor c=2.31279e-17
C4 (GN VSS) capacitor c=6.2034e-17
C5 (VDD VSS) capacitor c=2.27414e-16
C6 (GNb VSS) capacitor c=3.72834e-17
C7 (Qbint VSS) capacitor c=2.67029e-16
C8 (Qint VSS) capacitor c=2.34523e-16
C9 (n0 VSS) capacitor c=1.89899e-16
C10 (net245 VSS) capacitor c=9.60816e-19
C11 (GNbb VSS) capacitor c=5.48914e-17
C12 (net257 VSS) capacitor c=5.51213e-19
C13 (\5\:GNb VSS) capacitor c=6.85078e-17
C14 (\1\:D VSS) capacitor c=7.03761e-17
C15 (\31\:Qint VSS) capacitor c=5.37142e-17
C16 (\1\:GN VSS) capacitor c=3.30355e-17
C17 (\6\:GNb VSS) capacitor c=4.91106e-17
C18 (\3\:D VSS) capacitor c=6.03386e-17
C19 (\3\:GNb VSS) capacitor c=5.15799e-17
C20 (\3\:GNbb VSS) capacitor c=8.68199e-17
C21 (\29\:Qint VSS) capacitor c=5.55315e-17
C22 (\3\:GN VSS) capacitor c=3.22685e-17
C23 (\7\:GNb VSS) capacitor c=1.73739e-17
C24 (\2\:D VSS) capacitor c=6.81264e-17
C25 (\2\:GNbb VSS) capacitor c=6.3535e-17
C26 (\4\:GNb VSS) capacitor c=2.62633e-17
C27 (\2\:GNb VSS) capacitor c=4.57215e-17
C28 (\30\:Qint VSS) capacitor c=6.1604e-17
C29 (\2\:GN VSS) capacitor c=3.54325e-17
C30 (\4\:GNbb VSS) capacitor c=5.8705e-17
C31 (\1\:VDD VSS) capacitor c=2.78735e-17
C32 (\8\:n0 VSS) capacitor c=1.51114e-17
C33 (\38\:Qint VSS) capacitor c=7.92851e-17
C34 (\1\:Q VSS) capacitor c=1.73469e-16
C35 (\15\:GNb VSS) capacitor c=6.45124e-17
C36 (\3\:VDD VSS) capacitor c=8.5641e-17
C37 (\6\:GNbb VSS) capacitor c=1.04729e-16
C38 (\12\:n0 VSS) capacitor c=8.25213e-17
C39 (\32\:Qint VSS) capacitor c=2.66198e-17
C40 (\1\:QN VSS) capacitor c=1.27332e-16
C41 (\15\:Qbint VSS) capacitor c=8.90957e-17
C42 (\11\:GNb VSS) capacitor c=3.54159e-16
C43 (\14\:Qint VSS) capacitor c=2.35422e-16
C44 (\4\:GN VSS) capacitor c=4.1846e-17
C45 (\4\:Q VSS) capacitor c=1.13241e-16
C46 (\19\:Qbint VSS) capacitor c=2.49181e-17
C47 (\20\:Qbint VSS) capacitor c=4.82081e-17
C48 (\21\:Qbint VSS) capacitor c=1.50416e-16
C49 (\34\:Qint VSS) capacitor c=2.6705e-17
C50 (\35\:Qint VSS) capacitor c=3.82135e-17
C51 (\36\:Qint VSS) capacitor c=4.68827e-17
C52 (\37\:Qint VSS) capacitor c=4.84697e-17
C53 (\10\:n0 VSS) capacitor c=7.73502e-17
C54 (\11\:n0 VSS) capacitor c=8.17746e-17
C55 (\4\:D VSS) capacitor c=7.27894e-17
C56 (\8\:GNb VSS) capacitor c=2.90024e-17
C57 (\9\:GNb VSS) capacitor c=5.47462e-17
C58 (\10\:GNb VSS) capacitor c=3.59385e-16
C59 (\13\:GNb VSS) capacitor c=7.63697e-17
C60 (\14\:GNb VSS) capacitor c=7.81604e-17
C61 (\8\:GNbb VSS) capacitor c=1.07793e-16
C62 (\5\:VDD VSS) capacitor c=5.66399e-16
Rk30 (D \4\:D) resistor r=0.2006 c=0
Rk15 (\1\:QN QN) resistor r=0.2989 c=0
Rk3 (\1\:Q Q) resistor r=0.07979 c=0
Rk4 (Q \4\:Q) resistor r=0.1901 c=0
Rk1 (GN \4\:GN) resistor r=0.05181 c=0
Rk39 (\2\:VDD \4\:VDD) resistor r=0.4128 c=0
Rk52 (\5\:VDD VDD) resistor r=0.2928 c=0
Rk40 (\4\:VDD \5\:VDD) resistor r=0.3832 c=0
Rk61 (\2\:VSS \3\:VSS) resistor r=0.1201 c=0
Rk62 (\3\:VSS \4\:VSS) resistor r=0.1802 c=0
Rk63 (\4\:VSS \5\:VSS) resistor r=0.1802 c=0
Rk73 (\14\:VSS VSS) resistor r=0.04987 c=0
Rk72 (\5\:VSS \14\:VSS) resistor r=0.1401 c=0
Rk74 (\3\:VSS \16\:VSS) resistor r=0.07346 c=0
Rk31 (\8\:GNb \9\:GNb) resistor r=0.0554 c=0
Rk32 (\9\:GNb \10\:GNb) resistor r=0.1943 c=0
Rk33 (\10\:GNb \12\:GNb) resistor r=2.8604 c=0
Rk34 (\9\:GNb \13\:GNb) resistor r=0.4135 c=0
Rk35 (\10\:GNb \14\:GNb) resistor r=0.3981 c=0
Rk36 (\12\:GNb \16\:GNb) resistor r=0.4808 c=0
Rk9 (\15\:Qbint \19\:Qbint) resistor r=0.2234 c=0
Rk10 (\19\:Qbint \20\:Qbint) resistor r=0.258 c=0
Rk11 (\19\:Qbint \21\:Qbint) resistor r=0.1278 c=0
Rk22 (\33\:Qint \34\:Qint) resistor r=0.08745 c=0
Rk23 (\34\:Qint \35\:Qint) resistor r=0.1556 c=0
Rk24 (\35\:Qint \36\:Qint) resistor r=0.259 c=0
Rk25 (\34\:Qint \37\:Qint) resistor r=0.2121 c=0
Rk26 (\35\:Qint \39\:Qint) resistor r=0.3346 c=0
Rk27 (\9\:n0 \10\:n0) resistor r=0.08384 c=0
Rk28 (\10\:n0 \11\:n0) resistor r=0.5287 c=0
Rk29 (\10\:n0 \13\:n0) resistor r=0.435 c=0
Rk37 (\5\:GNbb \7\:GNbb) resistor r=0.4941 c=0
Rk38 (\7\:GNbb \8\:GNbb) resistor r=0.4569 c=0
Rl55 (\1\:D \2\:D) resistor r=153.207 c=0
Rl56 (\2\:D \3\:D) resistor r=76.9003 c=0
Rl1 (\1\:GN \2\:GN) resistor r=40.1797 c=0
Rl2 (\2\:GN \3\:GN) resistor r=117.285 c=0
Rl57 (\5\:GNb \6\:GNb) resistor r=214.304 c=0
Rl58 (\6\:GNb \7\:GNb) resistor r=29.5379 c=0
Rl52 (\3\:GNb \4\:GNb) resistor r=81.0213 c=0
Rl51 (GNb \2\:GNb) resistor r=66.5405 c=0
Rl50 (\30\:Qint \31\:Qint) resistor r=149.233 c=0
Rl49 (\30\:Qint \29\:Qint) resistor r=66.8618 c=0
Rl28 (\14\:Qint Qint) resistor r=50.0953 c=0
Rl53 (GNbb \2\:GNbb) resistor r=106.925 c=0
Rl54 (\2\:GNbb \3\:GNbb) resistor r=178.4 c=0
Rz11 (\4\:VDD \3\:VDD) resistor r=9.375 c=0
Rz12 (\5\:VDD \3\:VDD) resistor r=4.1667 c=0
Rz16 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz9 (\11\:GNb \12\:GNb) resistor r=75 c=0
Rz7 (\33\:Qint \32\:Qint) resistor r=75 c=0
Rz8 (\13\:n0 \12\:n0) resistor r=75 c=0
Rz10 (\6\:GNbb \7\:GNbb) resistor r=75 c=0
Ry13 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry22 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry23 (\4\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry25 (\5\:VSS \1\:VSS) resistor r=3.4444 c=0
Ry26 (\14\:VSS \1\:VSS) resistor r=31 c=0
Ry11 (\15\:GNb \16\:GNb) resistor r=62 c=0
Ry9 (\39\:Qint \38\:Qint) resistor r=31 c=0
Ry10 (\9\:n0 \8\:n0) resistor r=62 c=0
Ry12 (\4\:GNbb \5\:GNbb) resistor r=62 c=0
Rx6 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:GN \4\:GN) resistor r=45 c=0
Rx7 (\4\:GNb \8\:GNb) resistor r=45 c=0
Rx8 (\7\:GNb \13\:GNb) resistor r=45 c=0
Rx9 (\2\:GNb \14\:GNb) resistor r=45 c=0
Rx2 (\20\:Qbint Qbint) resistor r=45 c=0
Rx3 (\36\:Qint Qint) resistor r=45 c=0
Rx4 (\37\:Qint \30\:Qint) resistor r=45 c=0
Rx5 (\11\:n0 n0) resistor r=45 c=0
Rx10 (\2\:GNbb \8\:GNbb) resistor r=45 c=0
mn0 (\11\:GNb \3\:GN \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.0175e-13 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn21_1__rcx (\4\:Q Qbint \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.949e-14 ad=4.16e-14 ps=1.4725e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.86058e-07 sb=2e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(4)
mn20_1__rcx (\15\:Qbint \14\:Qint \5\:VSS VSS) g45n1svt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=8.54e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.32606e-06 sb=1.95452e-06 sd=160n \
        sca=10.79 scb=0.0100512 scc=0.000418069 m=(4)
mn22_1__rcx (\1\:QN Qint \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.471e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.61721e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(4)
mn10_1__rcx (\32\:Qint n0 \5\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=8.849e-14 ad=3.28e-14 ps=1.515e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.15671e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(2)
mn15 (net245 \29\:Qint \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.432e-14 ad=8.7e-15 ps=1.6e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.9e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn1 (\6\:GNbb \6\:GNb \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.825e-14 ad=2.03e-14 ps=1.49e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn16 (\12\:n0 \3\:GNbb net245 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.85e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn6 (\12\:n0 \3\:GNb net257 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.45e-14 ad=2.32e-14 ps=4.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.8e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn5 (net257 \3\:D \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.825e-14 ad=1.45e-14 ps=1.49e-06 pd=4.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.35e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mp21_1__rcx (\1\:Q Qbint \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.606e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=2e-06 sd=160n sca=19.4622 \
        scb=0.0164993 scc=0.00171566 m=(4)
mp20_1__rcx (\21\:Qbint \14\:Qint \5\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.532e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.11955e-06 sb=1.92308e-06 sd=160n \
        sca=19.0259 scb=0.0163587 scc=0.00171562 m=(4)
mp22_1__rcx (QN Qint \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.432e-14 ad=7.215e-14 ps=1.115e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.91474e-06 sb=1.57096e-06 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(4)
mp10_1__rcx (\38\:Qint n0 \5\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.04e-14 ad=4.96e-14 ps=1.25e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.19806e-06 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(2)
mp15 (net212 \31\:Qint \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.07e-14 ad=3.117e-14 ps=1.34e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.65e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp16 (\8\:n0 GNb net212 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=5.59e-14 ps=7.2e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.75e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp6 (\8\:n0 GNbb net220 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=5.59e-14 ps=5.9e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.7e-07 sd=160n sca=11.7304 scb=0.00936234 \
        scc=0.000188063 m=(1)
mp5 (net220 \1\:D \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.72e-14 ps=7.5e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=12.3705 \
        scb=0.00989845 scc=0.000188963 m=(1)
mp1 (\4\:GNbb \5\:GNb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=14.743 scb=0.013467 \
        scc=0.000229709 m=(1)
ends TLATNX4
// End of subcircuit definition.

// Generated for: spectre (May  9 18:35:16 2012 )
// Library name: gsclib045
// Cell name: TLATNXL
// View name: extracted

simulator lang=spectre

subckt TLATNXL D GN Q QN VDD VSS
mp1 (\7\:GNbb GNb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.73e-14 ad=3.01e-14 ps=1.47e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.34233e-06 sd=160n sca=21.1459 \
        scb=0.0238169 scc=0.000917416 m=(1)
C1 (GN VSS) capacitor c=1.10135e-16
C2 (D VSS) capacitor c=3.86232e-17
C3 (VDD VSS) capacitor c=2.06674e-16
C4 (Q VSS) capacitor c=3.1039e-17
C5 (GNb VSS) capacitor c=5.86639e-17
C6 (GNbb VSS) capacitor c=2.74523e-17
C7 (n0 VSS) capacitor c=6.04234e-17
C8 (net245 VSS) capacitor c=7.14613e-18
C9 (Qint VSS) capacitor c=2.86977e-17
C10 (Qbint VSS) capacitor c=3.46829e-17
C11 (net220 VSS) capacitor c=6.3127e-18
C12 (net212 VSS) capacitor c=7.7467e-19
C13 (\5\:Qint VSS) capacitor c=2.36996e-17
C14 (\11\:Qint VSS) capacitor c=5.54949e-17
C15 (\4\:GN VSS) capacitor c=3.55742e-17
C16 (\4\:Qint VSS) capacitor c=6.90984e-17
C17 (\6\:GNb VSS) capacitor c=5.03007e-17
C18 (\1\:D VSS) capacitor c=3.66339e-17
C19 (\4\:Qbint VSS) capacitor c=2.64356e-17
C20 (\10\:Qint VSS) capacitor c=3.5686e-17
C21 (\8\:Qint VSS) capacitor c=1.01149e-17
C22 (\3\:GN VSS) capacitor c=4.13741e-17
C23 (\3\:n0 VSS) capacitor c=2.18431e-17
C24 (\3\:Qint VSS) capacitor c=5.14599e-17
C25 (\4\:GNbb VSS) capacitor c=5.59558e-17
C26 (\4\:GNb VSS) capacitor c=6.35529e-17
C27 (\3\:D VSS) capacitor c=8.80968e-17
C28 (\3\:GNb VSS) capacitor c=2.86524e-17
C29 (\3\:Qbint VSS) capacitor c=2.04785e-17
C30 (\9\:Qint VSS) capacitor c=2.07074e-17
C31 (\1\:GN VSS) capacitor c=2.8987e-17
C32 (\2\:n0 VSS) capacitor c=6.4513e-17
C33 (\7\:GNb VSS) capacitor c=3.944e-17
C34 (\3\:GNbb VSS) capacitor c=2.57774e-17
C35 (\5\:GNb VSS) capacitor c=4.57298e-17
C36 (\2\:D VSS) capacitor c=5.0971e-17
C37 (\2\:GNb VSS) capacitor c=4.28483e-17
C38 (\3\:Q VSS) capacitor c=2.46018e-17
C39 (\1\:VDD VSS) capacitor c=4.4817e-17
C40 (\9\:Qbint VSS) capacitor c=3.49469e-17
C41 (\3\:QN VSS) capacitor c=9.10768e-17
C42 (\10\:VDD VSS) capacitor c=3.70669e-17
C43 (\14\:GNb VSS) capacitor c=2.75374e-17
C44 (\18\:Qint VSS) capacitor c=5.87652e-17
C45 (\12\:VDD VSS) capacitor c=1.83572e-17
C46 (\8\:n0 VSS) capacitor c=7.9875e-17
C47 (\14\:VDD VSS) capacitor c=9.93421e-18
C48 (\7\:GNbb VSS) capacitor c=8.49709e-17
C49 (\3\:VDD VSS) capacitor c=5.53484e-17
C50 (\1\:Q VSS) capacitor c=2.28726e-17
C51 (\7\:Qbint VSS) capacitor c=2.76262e-17
C52 (\1\:QN VSS) capacitor c=9.08871e-17
C53 (\8\:GNb VSS) capacitor c=1.1815e-16
C54 (\16\:Qint VSS) capacitor c=3.08319e-17
C55 (\6\:n0 VSS) capacitor c=6.38578e-17
C56 (\5\:GNbb VSS) capacitor c=6.38235e-17
C57 (\2\:GNbb VSS) capacitor c=3.38229e-17
C58 (\2\:Qint VSS) capacitor c=4.30015e-17
C59 (\2\:GN VSS) capacitor c=3.66585e-17
C60 (\6\:Qint VSS) capacitor c=3.90652e-17
C61 (\7\:Qint VSS) capacitor c=4.50766e-17
C62 (\2\:Qbint VSS) capacitor c=1.86952e-17
C63 (\4\:D VSS) capacitor c=7.24757e-17
C64 (\9\:GNbb VSS) capacitor c=7.83745e-17
C65 (\4\:n0 VSS) capacitor c=3.49076e-17
C66 (\5\:n0 VSS) capacitor c=1.00946e-16
C67 (\10\:GNb VSS) capacitor c=1.62346e-16
C68 (\11\:GNb VSS) capacitor c=1.32216e-16
C69 (\12\:GNb VSS) capacitor c=7.43637e-17
C70 (\13\:GNb VSS) capacitor c=5.15188e-17
C71 (\16\:GNb VSS) capacitor c=2.99773e-17
C72 (\12\:Qint VSS) capacitor c=1.27908e-16
C73 (\13\:Qint VSS) capacitor c=1.66832e-16
C74 (\14\:Qint VSS) capacitor c=5.97288e-17
C75 (\15\:Qint VSS) capacitor c=3.82588e-17
C76 (\5\:Qbint VSS) capacitor c=3.65023e-17
C77 (\6\:Qbint VSS) capacitor c=2.88085e-17
C78 (\5\:VDD VSS) capacitor c=2.40911e-17
C79 (\6\:VDD VSS) capacitor c=3.00222e-17
C80 (\8\:VDD VSS) capacitor c=8.32544e-18
Rk13 (\5\:GN GN) resistor r=0.003 c=0
Rk36 (\2\:VSS \4\:VSS) resistor r=0.4109 c=0
Rk37 (\4\:VSS \5\:VSS) resistor r=0.3157 c=0
Rk38 (\5\:VSS \6\:VSS) resistor r=0.1854 c=0
Rk39 (\6\:VSS \7\:VSS) resistor r=0.2004 c=0
Rk40 (\7\:VSS \8\:VSS) resistor r=0.3007 c=0
Rk42 (\9\:VSS VSS) resistor r=0.1224 c=0
Rk41 (\8\:VSS \9\:VSS) resistor r=0.1277 c=0
Rk43 (\5\:VSS \11\:VSS) resistor r=0.3069 c=0
Rk44 (\7\:VSS \13\:VSS) resistor r=0.2848 c=0
Rk45 (\9\:VSS \15\:VSS) resistor r=0.2719 c=0
Rk1 (\4\:D D) resistor r=0.04318 c=0
Rk26 (\2\:VDD \4\:VDD) resistor r=0.6991 c=0
Rk27 (\4\:VDD \5\:VDD) resistor r=0.09007 c=0
Rk28 (\5\:VDD \6\:VDD) resistor r=0.3958 c=0
Rk29 (\6\:VDD \7\:VDD) resistor r=0.2154 c=0
Rk30 (\7\:VDD \8\:VDD) resistor r=0.2631 c=0
Rk32 (\9\:VDD VDD) resistor r=0.0499 c=0
Rk31 (\8\:VDD \9\:VDD) resistor r=0.08756 c=0
Rk33 (\5\:VDD \11\:VDD) resistor r=0.1784 c=0
Rk34 (\6\:VDD \13\:VDD) resistor r=0.07381 c=0
Rk35 (\8\:VDD \15\:VDD) resistor r=0.07381 c=0
Rk24 (Q \2\:Q) resistor r=0.12 c=0
Rk25 (Q \4\:Q) resistor r=0.177 c=0
Rk19 (\2\:QN QN) resistor r=0.006001 c=0
Rk20 (QN \4\:QN) resistor r=0.5101 c=0
Rk7 (\9\:GNb \10\:GNb) resistor r=0.7178 c=0
Rk8 (\10\:GNb \11\:GNb) resistor r=0.9246 c=0
Rk9 (\11\:GNb \12\:GNb) resistor r=0.4434 c=0
Rk10 (\12\:GNb \13\:GNb) resistor r=0.2123 c=0
Rk11 (\10\:GNb \15\:GNb) resistor r=0.1281 c=0
Rk12 (\11\:GNb \16\:GNb) resistor r=0.08656 c=0
Rk2 (\6\:GNbb \8\:GNbb) resistor r=0.5709 c=0
Rk3 (\8\:GNbb \9\:GNbb) resistor r=0.487 c=0
Rk4 (\4\:n0 \5\:n0) resistor r=0.1314 c=0
Rk5 (\5\:n0 \7\:n0) resistor r=0.478 c=0
Rk6 (\5\:n0 \9\:n0) resistor r=0.4275 c=0
Rk14 (\12\:Qint \13\:Qint) resistor r=1.0034 c=0
Rk15 (\13\:Qint \14\:Qint) resistor r=0.3093 c=0
Rk16 (\14\:Qint \15\:Qint) resistor r=0.1014 c=0
Rk17 (\13\:Qint \17\:Qint) resistor r=0.02381 c=0
Rk18 (\14\:Qint \19\:Qint) resistor r=0.2778 c=0
Rk21 (\5\:Qbint \6\:Qbint) resistor r=0.1193 c=0
Rk22 (\6\:Qbint \8\:Qbint) resistor r=0.1087 c=0
Rk23 (\6\:Qbint \10\:Qbint) resistor r=0.1957 c=0
Rl17 (\2\:GN \4\:GN) resistor r=69.7859 c=0
Rl16 (\2\:GN \3\:GN) resistor r=203.093 c=0
Rl15 (\1\:GN \2\:GN) resistor r=5.7469 c=0
Rl3 (\1\:D \2\:D) resistor r=29.5379 c=0
Rl4 (\2\:D \3\:D) resistor r=177.615 c=0
Rl9 (\6\:GNb \7\:GNb) resistor r=61.5157 c=0
Rl5 (\4\:GNb \5\:GNb) resistor r=29.5379 c=0
Rl1 (GNb \2\:GNb) resistor r=168 c=0
Rl2 (\2\:GNb \3\:GNb) resistor r=39.1533 c=0
Rl6 (GNbb \2\:GNbb) resistor r=35.772 c=0
Rl8 (\2\:GNbb \4\:GNbb) resistor r=193.464 c=0
Rl7 (\2\:GNbb \3\:GNbb) resistor r=32.3537 c=0
Rl13 (n0 \2\:n0) resistor r=194.208 c=0
Rl14 (\2\:n0 \3\:n0) resistor r=34.4104 c=0
Rl21 (\8\:Qint \9\:Qint) resistor r=29.5379 c=0
Rl10 (Qint \2\:Qint) resistor r=9.9043 c=0
Rl12 (\2\:Qint \4\:Qint) resistor r=92.0218 c=0
Rl11 (\2\:Qint \3\:Qint) resistor r=153.126 c=0
Rl18 (\5\:Qint \6\:Qint) resistor r=51.1566 c=0
Rl22 (\6\:Qint \10\:Qint) resistor r=89.6181 c=0
Rl23 (\7\:Qint \11\:Qint) resistor r=187.982 c=0
Rl20 (\7\:Qint \8\:Qint) resistor r=96.5658 c=0
Rl19 (\6\:Qint \7\:Qint) resistor r=195.503 c=0
Rl24 (Qbint \2\:Qbint) resistor r=99.7141 c=0
Rl26 (\2\:Qbint \4\:Qbint) resistor r=36.2526 c=0
Rl25 (\2\:Qbint \3\:Qbint) resistor r=2.0166 c=0
Rz11 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz12 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz13 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz14 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz8 (\3\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz9 (\3\:VDD \7\:VDD) resistor r=15 c=0
Rz10 (\3\:VDD \9\:VDD) resistor r=37.5 c=0
Rz7 (\1\:Q \2\:Q) resistor r=75 c=0
Rz5 (\1\:QN \2\:QN) resistor r=75 c=0
Rz3 (\8\:GNb \9\:GNb) resistor r=75 c=0
Rz1 (\5\:GNbb \6\:GNbb) resistor r=75 c=0
Rz2 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz4 (\16\:Qint \17\:Qint) resistor r=75 c=0
Rz6 (\7\:Qbint \8\:Qbint) resistor r=75 c=0
Ry12 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry13 (\3\:VSS \6\:VSS) resistor r=15.5 c=0
Ry14 (\3\:VSS \8\:VSS) resistor r=10.3333 c=0
Ry8 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry9 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry10 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry11 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry7 (\3\:Q \4\:Q) resistor r=62 c=0
Ry5 (\3\:QN \4\:QN) resistor r=62 c=0
Ry3 (\14\:GNb \15\:GNb) resistor r=62 c=0
Ry1 (\7\:GNbb \8\:GNbb) resistor r=62 c=0
Ry2 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry4 (\18\:Qint \19\:Qint) resistor r=62 c=0
Ry6 (\9\:Qbint \10\:Qbint) resistor r=62 c=0
Rx7 (\1\:GN \5\:GN) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\5\:GNb \12\:GNb) resistor r=45 c=0
Rx5 (\2\:GNb \13\:GNb) resistor r=45 c=0
Rx6 (\7\:GNb \16\:GNb) resistor r=45 c=0
Rx2 (\3\:GNbb \9\:GNbb) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx8 (\9\:Qint \12\:Qint) resistor r=45 c=0
Rx9 (Qint \15\:Qint) resistor r=45 c=0
Rx10 (\3\:Qbint \5\:Qbint) resistor r=45 c=0
mn1 (\5\:GNbb \3\:GNb \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.465e-14 ps=6.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.2e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn5 (net257 \3\:D \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=9.95e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn6 (\6\:n0 \4\:GNb net257 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.682e-14 ps=4.1e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=8.9e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn10 (\16\:Qint \3\:n0 \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23e-06 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn16 (\6\:n0 \4\:GNbb net245 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=2.682e-14 ps=8.3e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.1e-07 sb=6.6e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn15 (net245 \3\:Qint \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.915e-14 ps=6.1e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=3.45e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn0 (\8\:GNb \3\:GN \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=3.698e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=4.6e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn22 (\1\:QN \8\:Qint \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn20 (\7\:Qbint \10\:Qint \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.7e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn21 (\1\:Q \4\:Qbint \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.393e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.65e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp5 (net220 \1\:D \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.73e-14 ad=6.235e-14 ps=1.47e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.13733e-06 sd=160n sca=14.0472 \
        scb=0.012275 scc=0.000208339 m=(1)
mp6 (\8\:n0 GNbb net220 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.235e-14 ad=5.697e-14 ps=1.01e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=8.02326e-07 sd=160n sca=11.5667 \
        scb=0.00927227 scc=0.000188008 m=(1)
mp16 (\8\:n0 \6\:GNb net212 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.697e-14 ps=5.5e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=4.92326e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp15 (net212 \4\:Qint \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=1.29e-14 ps=1.45e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.095e-06 sb=3.87326e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp10 (\18\:Qint n0 \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=2.63e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.36e-06 sb=1.22326e-07 sd=160n sca=11.1138 \
        scb=0.00912362 scc=0.000187967 m=(1)
mp0 (\14\:GNb \4\:GN \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.69e-14 ps=7.5e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25116e-07 sb=3.45e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp22 (\3\:QN \11\:Qint \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.30116e-07 sb=1.4e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp20 (\9\:Qbint \5\:Qint \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.7e-07 sd=160n sca=48.8019 \
        scb=0.0316124 scc=0.00590646 m=(1)
mp21 (\3\:Q Qbint \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.65e-07 sd=160n sca=56.1973 \
        scb=0.0435219 scc=0.00667686 m=(1)
ends TLATNXL
// End of subcircuit definition.

// Generated for: spectre (May  9 18:35:56 2012 )
// Library name: gsclib045
// Cell name: TLATSRX1
// View name: extracted

simulator lang=spectre

subckt TLATSRX1 D G Q QN RN SN VDD VSS
mp21 (\1\:Q \4\:Qbint \20\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.435e-14 ps=1.1e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.17308e-07 sd=160n sca=34.23 \
        scb=0.0247192 scc=0.00340661 m=(1)
C1 (D VSS) capacitor c=4.78965e-17
C2 (VDD VSS) capacitor c=2.36489e-16
C3 (RN VSS) capacitor c=5.68441e-17
C4 (Q VSS) capacitor c=2.3553e-17
C5 (QN VSS) capacitor c=6.57303e-17
C6 (Qbint VSS) capacitor c=2.22955e-17
C7 (Qint VSS) capacitor c=1.41524e-17
C8 (net183 VSS) capacitor c=1.35824e-18
C9 (n5 VSS) capacitor c=7.22561e-17
C10 (net159 VSS) capacitor c=1.48418e-18
C11 (Gb VSS) capacitor c=4.75591e-17
C12 (net167 VSS) capacitor c=3.60468e-18
C13 (net171 VSS) capacitor c=5.50835e-18
C14 (Gbb VSS) capacitor c=3.37561e-17
C15 (net103 VSS) capacitor c=7.7535e-17
C16 (net142 VSS) capacitor c=6.87895e-19
C17 (\5\:Gb VSS) capacitor c=3.53638e-17
C18 (\3\:D VSS) capacitor c=5.05589e-17
C19 (\3\:Gb VSS) capacitor c=5.96223e-17
C20 (\3\:Gbb VSS) capacitor c=5.50637e-17
C21 (\11\:Qint VSS) capacitor c=3.12271e-17
C22 (\7\:RN VSS) capacitor c=2.71443e-17
C23 (\6\:RN VSS) capacitor c=3.01259e-17
C24 (\3\:G VSS) capacitor c=3.82443e-17
C25 (\3\:SN VSS) capacitor c=4.43372e-17
C26 (\7\:Qint VSS) capacitor c=4.46806e-17
C27 (\8\:Qint VSS) capacitor c=3.31712e-17
C28 (\4\:Qbint VSS) capacitor c=4.06182e-17
C29 (\6\:Gb VSS) capacitor c=4.78469e-17
C30 (\1\:D VSS) capacitor c=5.62893e-17
C31 (\9\:Qint VSS) capacitor c=6.15564e-17
C32 (\1\:RN VSS) capacitor c=4.52747e-17
C33 (\4\:RN VSS) capacitor c=1.97228e-17
C34 (\1\:G VSS) capacitor c=5.78326e-17
C35 (\2\:n5 VSS) capacitor c=7.03005e-17
C36 (\1\:SN VSS) capacitor c=7.25925e-17
C37 (\6\:Qint VSS) capacitor c=3.47477e-17
C38 (\5\:Qint VSS) capacitor c=3.61564e-17
C39 (\3\:Qbint VSS) capacitor c=3.05207e-17
C40 (\7\:Gb VSS) capacitor c=2.02154e-17
C41 (\2\:D VSS) capacitor c=5.09465e-17
C42 (\2\:Gbb VSS) capacitor c=5.94489e-17
C43 (\4\:Gb VSS) capacitor c=2.54856e-17
C44 (\2\:Gb VSS) capacitor c=2.323e-17
C45 (\10\:Qint VSS) capacitor c=5.42928e-17
C46 (\3\:RN VSS) capacitor c=2.4249e-17
C47 (\2\:G VSS) capacitor c=4.94317e-17
C48 (\3\:n5 VSS) capacitor c=2.68963e-17
C49 (\2\:SN VSS) capacitor c=5.45087e-17
C50 (\4\:Gbb VSS) capacitor c=4.11604e-17
C51 (\1\:VDD VSS) capacitor c=4.11688e-17
C52 (\4\:n5 VSS) capacitor c=8.19738e-17
C53 (\3\:net103 VSS) capacitor c=9.23753e-17
C54 (\12\:VDD VSS) capacitor c=2.78821e-17
C55 (\14\:VDD VSS) capacitor c=1.60649e-17
C56 (\15\:Gb VSS) capacitor c=5.75228e-17
C57 (\16\:VDD VSS) capacitor c=1.97393e-17
C58 (\13\:Qint VSS) capacitor c=1.87596e-16
C59 (\18\:VDD VSS) capacitor c=2.94746e-17
C60 (\1\:QN VSS) capacitor c=3.72645e-17
C61 (\5\:Qbint VSS) capacitor c=3.70933e-17
C62 (\20\:VDD VSS) capacitor c=7.56394e-17
C63 (\1\:Q VSS) capacitor c=6.27685e-17
C64 (\3\:VDD VSS) capacitor c=6.06489e-17
C65 (\8\:Gbb VSS) capacitor c=1.94454e-17
C66 (\6\:n5 VSS) capacitor c=2.19452e-16
C67 (\13\:Gb VSS) capacitor c=2.67634e-17
C68 (\15\:Qint VSS) capacitor c=1.15413e-16
C69 (\3\:QN VSS) capacitor c=2.96491e-17
C70 (\9\:Qbint VSS) capacitor c=2.89633e-17
C71 (\3\:Q VSS) capacitor c=3.87056e-17
C72 (\2\:Qbint VSS) capacitor c=1.24882e-17
C73 (\2\:Qint VSS) capacitor c=9.68253e-18
C74 (\3\:Qint VSS) capacitor c=1.8597e-17
C75 (\4\:Qint VSS) capacitor c=3.12093e-17
C76 (\2\:RN VSS) capacitor c=2.22016e-17
C77 (\5\:RN VSS) capacitor c=1.57305e-17
C78 (\7\:Qbint VSS) capacitor c=2.87372e-17
C79 (\8\:Qbint VSS) capacitor c=3.95243e-17
C80 (\4\:SN VSS) capacitor c=1.1358e-16
C81 (\4\:G VSS) capacitor c=1.14967e-16
C82 (\8\:RN VSS) capacitor c=7.07191e-17
C83 (\12\:Qint VSS) capacitor c=1.89054e-16
C84 (\17\:Qint VSS) capacitor c=7.29236e-17
C85 (\8\:n5 VSS) capacitor c=1.53197e-16
C86 (\4\:D VSS) capacitor c=6.35576e-17
C87 (\6\:Gbb VSS) capacitor c=3.90585e-17
C88 (\7\:Gbb VSS) capacitor c=6.07662e-17
C89 (\8\:Gb VSS) capacitor c=4.67529e-17
C90 (\9\:Gb VSS) capacitor c=1.12744e-16
C91 (\10\:Gb VSS) capacitor c=1.69556e-16
C92 (\11\:Gb VSS) capacitor c=1.74261e-17
C93 (\12\:Gb VSS) capacitor c=1.33739e-16
C94 (\5\:VDD VSS) capacitor c=1.48901e-17
C95 (\6\:VDD VSS) capacitor c=9.78779e-18
C96 (\8\:VDD VSS) capacitor c=1.75265e-17
C97 (\9\:VDD VSS) capacitor c=1.30572e-17
C98 (\11\:VDD VSS) capacitor c=7.8401e-18
Rk8 (\4\:SN SN) resistor r=0.03189 c=0
Rk17 (\4\:D D) resistor r=0.01227 c=0
Rk27 (\2\:VDD \4\:VDD) resistor r=0.2792 c=0
Rk28 (\4\:VDD \5\:VDD) resistor r=0.2255 c=0
Rk29 (\5\:VDD \6\:VDD) resistor r=0.2002 c=0
Rk30 (\6\:VDD \7\:VDD) resistor r=0.1252 c=0
Rk31 (\7\:VDD \8\:VDD) resistor r=0.1653 c=0
Rk32 (\8\:VDD \9\:VDD) resistor r=0.2278 c=0
Rk33 (\9\:VDD \10\:VDD) resistor r=0.1578 c=0
Rk35 (\11\:VDD VDD) resistor r=0.2027 c=0
Rk34 (\10\:VDD \11\:VDD) resistor r=0.1478 c=0
Rk36 (\5\:VDD \13\:VDD) resistor r=0.1474 c=0
Rk37 (\6\:VDD \15\:VDD) resistor r=0.07393 c=0
Rk38 (\8\:VDD \17\:VDD) resistor r=0.07393 c=0
Rk39 (\9\:VDD \19\:VDD) resistor r=0.2997 c=0
Rk40 (\11\:VDD \21\:VDD) resistor r=0.4004 c=0
Rk10 (\8\:RN RN) resistor r=0.05736 c=0
Rk2 (\4\:Q Q) resistor r=0.08444 c=0
Rk1 (\2\:Q \4\:Q) resistor r=0.38 c=0
Rk9 (G \4\:G) resistor r=0.002841 c=0
Rk41 (\2\:VSS \4\:VSS) resistor r=0.493 c=0
Rk42 (\4\:VSS \5\:VSS) resistor r=0.3359 c=0
Rk43 (\5\:VSS \6\:VSS) resistor r=0.6167 c=0
Rk44 (\6\:VSS \7\:VSS) resistor r=0.04244 c=0
Rk46 (\8\:VSS VSS) resistor r=0.2027 c=0
Rk45 (\7\:VSS \8\:VSS) resistor r=0.3056 c=0
Rk47 (\5\:VSS \10\:VSS) resistor r=0.2036 c=0
Rk48 (\7\:VSS \12\:VSS) resistor r=0.2009 c=0
Rk49 (\8\:VSS \14\:VSS) resistor r=0.2901 c=0
Rk6 (\2\:QN QN) resistor r=0.2469 c=0
Rk7 (QN \4\:QN) resistor r=0.1396 c=0
Rk3 (\6\:Qbint \7\:Qbint) resistor r=0.1238 c=0
Rk4 (\7\:Qbint \8\:Qbint) resistor r=0.1194 c=0
Rk5 (\7\:Qbint \10\:Qbint) resistor r=0.09978 c=0
Rk11 (\12\:Qint \14\:Qint) resistor r=1.2613 c=0
Rk12 (\14\:Qint \16\:Qint) resistor r=0.6756 c=0
Rk13 (\16\:Qint \17\:Qint) resistor r=0.3784 c=0
Rk15 (\5\:n5 \7\:n5) resistor r=0.4836 c=0
Rk16 (\7\:n5 \8\:n5) resistor r=1.3354 c=0
Rk21 (\8\:Gb \9\:Gb) resistor r=0.3878 c=0
Rk22 (\9\:Gb \10\:Gb) resistor r=0.6655 c=0
Rk23 (\9\:Gb \11\:Gb) resistor r=0.02785 c=0
Rk24 (\10\:Gb \12\:Gb) resistor r=0.7561 c=0
Rk25 (\12\:Gb \14\:Gb) resistor r=0.1164 c=0
Rk26 (\12\:Gb \16\:Gb) resistor r=0.3623 c=0
Rk18 (\5\:Gbb \6\:Gbb) resistor r=0.2915 c=0
Rk19 (\6\:Gbb \7\:Gbb) resistor r=0.2917 c=0
Rk20 (\6\:Gbb \9\:Gbb) resistor r=0.1237 c=0
Rk14 (\2\:net103 \4\:net103) resistor r=0.3419 c=0
Rl12 (\2\:SN \3\:SN) resistor r=74.1758 c=0
Rl11 (\1\:SN \2\:SN) resistor r=119.231 c=0
Rl30 (\2\:D \3\:D) resistor r=29.9451 c=0
Rl29 (\1\:D \2\:D) resistor r=125 c=0
Rl17 (\1\:RN \2\:RN) resistor r=123.503 c=0
Rl19 (\2\:RN \4\:RN) resistor r=35.772 c=0
Rl18 (\2\:RN \3\:RN) resistor r=62.6951 c=0
Rl22 (\5\:RN \7\:RN) resistor r=35.772 c=0
Rl21 (\5\:RN \6\:RN) resistor r=96.5797 c=0
Rl20 (\3\:RN \5\:RN) resistor r=44.5632 c=0
Rl16 (\2\:G \3\:G) resistor r=81.9251 c=0
Rl15 (\1\:G \2\:G) resistor r=219.952 c=0
Rl1 (Qbint \2\:Qbint) resistor r=2.0213 c=0
Rl3 (\2\:Qbint \4\:Qbint) resistor r=49.7141 c=0
Rl2 (\2\:Qbint \3\:Qbint) resistor r=34.3295 c=0
Rl24 (\10\:Qint \11\:Qint) resistor r=54.1337 c=0
Rl23 (\9\:Qint \10\:Qint) resistor r=184.128 c=0
Rl4 (Qint \2\:Qint) resistor r=1.2334 c=0
Rl8 (\2\:Qint \6\:Qint) resistor r=37.3411 c=0
Rl9 (\3\:Qint \7\:Qint) resistor r=35.772 c=0
Rl5 (\2\:Qint \3\:Qint) resistor r=63.4977 c=0
Rl10 (\4\:Qint \8\:Qint) resistor r=28.0797 c=0
Rl7 (\4\:Qint \5\:Qint) resistor r=60.772 c=0
Rl6 (\3\:Qint \4\:Qint) resistor r=141.671 c=0
Rl13 (n5 \2\:n5) resistor r=216.873 c=0
Rl14 (\2\:n5 \3\:n5) resistor r=26.1559 c=0
Rl31 (\5\:Gb \6\:Gb) resistor r=178.846 c=0
Rl32 (\5\:Gb \7\:Gb) resistor r=35.6938 c=0
Rl26 (\3\:Gb \4\:Gb) resistor r=56.9251 c=0
Rl25 (Gb \2\:Gb) resistor r=26.1559 c=0
Rl27 (Gbb \2\:Gbb) resistor r=35.7134 c=0
Rl28 (\2\:Gbb \3\:Gbb) resistor r=181.433 c=0
Rz8 (\3\:VDD \4\:VDD) resistor r=9.375 c=0
Rz9 (\3\:VDD \7\:VDD) resistor r=25 c=0
Rz10 (\3\:VDD \10\:VDD) resistor r=9.375 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz11 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz12 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz13 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz14 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz3 (\3\:QN \4\:QN) resistor r=75 c=0
Rz2 (\9\:Qbint \10\:Qbint) resistor r=75 c=0
Rz4 (\15\:Qint \16\:Qint) resistor r=75 c=0
Rz5 (\6\:n5 \7\:n5) resistor r=75 c=0
Rz7 (\13\:Gb \14\:Gb) resistor r=75 c=0
Rz6 (\8\:Gbb \9\:Gbb) resistor r=75 c=0
Ry10 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry11 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry12 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry13 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry14 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry15 (\20\:VDD \21\:VDD) resistor r=20.6667 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry16 (\3\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry17 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry3 (\1\:QN \2\:QN) resistor r=62 c=0
Ry2 (\5\:Qbint \6\:Qbint) resistor r=62 c=0
Ry4 (\13\:Qint \14\:Qint) resistor r=62 c=0
Ry7 (\4\:n5 \5\:n5) resistor r=62 c=0
Ry9 (\15\:Gb \16\:Gb) resistor r=62 c=0
Ry8 (\4\:Gbb \5\:Gbb) resistor r=62 c=0
Ry5 (net103 \2\:net103) resistor r=62 c=0
Ry6 (\3\:net103 \4\:net103) resistor r=62 c=0
Rx2 (\2\:SN \4\:SN) resistor r=45 c=0
Rx8 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\3\:RN \8\:RN) resistor r=45 c=0
Rx3 (\2\:G \4\:G) resistor r=45 c=0
Rx1 (Qbint \8\:Qbint) resistor r=45 c=0
Rx5 (\10\:Qint \12\:Qint) resistor r=45 c=0
Rx6 (Qint \17\:Qint) resistor r=45 c=0
Rx7 (\3\:n5 \8\:n5) resistor r=45 c=0
Rx10 (\7\:Gb \8\:Gb) resistor r=45 c=0
Rx11 (\2\:Gb \10\:Gb) resistor r=45 c=0
Rx12 (\4\:Gb \11\:Gb) resistor r=45 c=0
Rx9 (\2\:Gbb \7\:Gbb) resistor r=45 c=0
mn21 (\3\:Q \3\:Qbint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.29e-14 ps=8.4e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (\9\:Qbint \5\:Qint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn22 (\3\:QN \6\:Qint \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=3.64e-14 ps=9.8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.51923e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn10 (net183 \1\:SN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=8.7e-15 ps=9.8e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=2.45e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn11 (\15\:Qint \2\:n5 net183 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.4e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn1 (\13\:Gb \1\:G net159 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.827e-14 ad=2.03e-14 ps=6.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.71e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn0 (net159 \4\:RN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=2.827e-14 ps=9.9e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=1.47e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn5 (net191 \1\:D \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.74e-14 ps=6.1e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.505e-06 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn15 (net167 \1\:RN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=1.812e-14 ps=9.9e-07 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.45e-07 sb=1.205e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn16 (net171 \9\:Qint net167 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.812e-14 ad=2.9e-14 ps=5.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.035e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn17 (\6\:n5 Gb net171 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=3.407e-14 ps=6.9e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=7.9e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn6 (\6\:n5 Gbb net191 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.74e-14 ad=3.407e-14 ps=5.3e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34e-06 sb=5.1e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn2 (\8\:Gbb \6\:Gb \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp20 (\5\:Qbint \8\:Qint \20\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=4.38e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.12308e-07 sd=160n sca=31.7909 \
        scb=0.0210107 scc=0.00336206 m=(1)
mp22 (\1\:QN \7\:Qint \18\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.512e-14 ad=5.34e-14 ps=1.13e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.36923e-07 sb=8.74551e-07 sd=160n sca=24.4353 \
        scb=0.0186618 scc=0.00260099 m=(1)
mp10 (\13\:Qint \3\:SN \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.512e-14 ad=3.44e-14 ps=1.13e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.285e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp11 (\13\:Qint n5 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.417e-14 ad=3.44e-14 ps=1.58e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.08e-06 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp1 (\15\:Gb \3\:G \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.417e-14 ad=6.558e-14 ps=1.58e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.95e-07 sb=8.5e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp16 (net103 \11\:Qint \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.04e-14 ad=3.44e-14 ps=1.19e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.545e-06 sb=1e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp0 (\15\:Gb \6\:RN \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.665e-14 ad=6.558e-14 ps=1.51e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=5e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp15 (net103 \7\:RN \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.665e-14 ad=3.44e-14 ps=1.51e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34e-06 sb=3.05e-07 sd=160n sca=11.9515 \
        scb=0.0105226 scc=0.000305882 m=(1)
mp17 (\4\:n5 \3\:Gbb \3\:net103 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.37e-14 ad=3.44e-14 ps=1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.03256e-07 sb=7.4e-07 sd=160n sca=16.8549 \
        scb=0.0164675 scc=0.00112488 m=(1)
mp6 (\4\:n5 \3\:Gb net142 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.827e-14 ad=3.44e-14 ps=6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.08256e-07 sb=5.35e-07 sd=160n sca=17.8256 \
        scb=0.0172341 scc=0.00112617 m=(1)
mp5 (net142 \3\:D \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.53e-14 ad=1.827e-14 ps=1.67e-06 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.38256e-07 sb=4.05e-07 sd=160n sca=19.1101 \
        scb=0.0190255 scc=0.00113905 m=(1)
mp2 (\4\:Gbb \5\:Gb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.53e-14 ad=3.01e-14 ps=1.67e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.03256e-07 sb=1.4e-07 sd=160n sca=30.1296 \
        scb=0.035365 scc=0.00253121 m=(1)
ends TLATSRX1
// End of subcircuit definition.

// Generated for: spectre (May  9 18:36:37 2012 )
// Library name: gsclib045
// Cell name: TLATSRX2
// View name: extracted

simulator lang=spectre

subckt TLATSRX2 D G Q QN RN SN VDD VSS
mp2 (\6\:Gbb Gb \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.65e-14 ad=3.01e-14 ps=1.19e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.9e-07 sd=160n sca=22.2113 \
        scb=0.0236966 scc=0.00141807 m=(1)
C1 (D VSS) capacitor c=5.7879e-17
C2 (SN VSS) capacitor c=7.18527e-17
C3 (QN VSS) capacitor c=4.18898e-17
C4 (G VSS) capacitor c=1.15388e-16
C5 (VDD VSS) capacitor c=2.64787e-16
C6 (Q VSS) capacitor c=5.80353e-17
C7 (RN VSS) capacitor c=2.42273e-17
C8 (Gb VSS) capacitor c=4.79275e-17
C9 (Gbb VSS) capacitor c=7.73722e-17
C10 (n5 VSS) capacitor c=6.96155e-17
C11 (net171 VSS) capacitor c=4.64568e-19
C12 (net167 VSS) capacitor c=1.12865e-18
C13 (Qint VSS) capacitor c=6.87439e-17
C14 (net159 VSS) capacitor c=1.73155e-18
C15 (Qbint VSS) capacitor c=1.38715e-16
C16 (net142 VSS) capacitor c=8.16647e-18
C17 (net103 VSS) capacitor c=6.11838e-17
C18 (\4\:Qint VSS) capacitor c=1.34363e-16
C19 (\1\:SN VSS) capacitor c=3.91655e-17
C20 (\3\:n5 VSS) capacitor c=2.71194e-17
C21 (\1\:G VSS) capacitor c=2.59445e-17
C22 (\1\:RN VSS) capacitor c=2.90294e-17
C23 (\5\:RN VSS) capacitor c=2.59214e-17
C24 (\4\:Gb VSS) capacitor c=3.21252e-17
C25 (\1\:D VSS) capacitor c=4.07569e-17
C26 (\3\:SN VSS) capacitor c=6.60307e-17
C27 (\3\:G VSS) capacitor c=3.74373e-17
C28 (\6\:RN VSS) capacitor c=2.93136e-17
C29 (\4\:RN VSS) capacitor c=4.46963e-17
C30 (\2\:Qint VSS) capacitor c=6.27291e-17
C31 (\6\:Gb VSS) capacitor c=3.63922e-17
C32 (\3\:Gbb VSS) capacitor c=2.77661e-17
C33 (\3\:D VSS) capacitor c=3.26335e-17
C34 (\3\:Gb VSS) capacitor c=2.10109e-17
C35 (\2\:SN VSS) capacitor c=5.10748e-17
C36 (\2\:n5 VSS) capacitor c=4.14085e-17
C37 (\2\:G VSS) capacitor c=3.34243e-17
C38 (\2\:RN VSS) capacitor c=3.15792e-17
C39 (\3\:Qint VSS) capacitor c=3.20077e-17
C40 (\7\:Gb VSS) capacitor c=3.17127e-17
C41 (\5\:Gb VSS) capacitor c=4.79538e-17
C42 (\2\:Gbb VSS) capacitor c=6.88338e-17
C43 (\2\:D VSS) capacitor c=4.45016e-17
C44 (\2\:Gb VSS) capacitor c=3.80658e-17
C45 (\1\:VDD VSS) capacitor c=2.99576e-16
C46 (\1\:Q VSS) capacitor c=6.64619e-17
C47 (\11\:Qbint VSS) capacitor c=8.60187e-17
C48 (\1\:QN VSS) capacitor c=7.78221e-17
C49 (\17\:Qint VSS) capacitor c=9.96901e-17
C50 (\21\:VDD VSS) capacitor c=2.81223e-17
C51 (\10\:Gb VSS) capacitor c=1.9894e-16
C52 (\23\:VDD VSS) capacitor c=1.87209e-17
C53 (\25\:VDD VSS) capacitor c=2.19817e-17
C54 (\3\:net103 VSS) capacitor c=4.87472e-17
C55 (\5\:n5 VSS) capacitor c=2.45523e-16
C56 (\27\:VDD VSS) capacitor c=2.99685e-17
C57 (\6\:Gbb VSS) capacitor c=1.02886e-16
C58 (\4\:VDD VSS) capacitor c=8.15839e-17
C59 (\3\:Q VSS) capacitor c=2.82636e-17
C60 (\9\:Qbint VSS) capacitor c=2.34889e-17
C61 (\4\:QN VSS) capacitor c=3.03236e-17
C62 (\20\:Qint VSS) capacitor c=1.58661e-16
C63 (\8\:Gb VSS) capacitor c=1.29984e-16
C64 (\7\:n5 VSS) capacitor c=1.01671e-16
C65 (\4\:Gbb VSS) capacitor c=6.31276e-17
C66 (\3\:RN VSS) capacitor c=3.77907e-17
C67 (\7\:Qint VSS) capacitor c=1.34176e-16
C68 (\4\:D VSS) capacitor c=6.36667e-17
C69 (\8\:Gbb VSS) capacitor c=1.06546e-16
C70 (\7\:RN VSS) capacitor c=8.10894e-17
C71 (\12\:Gb VSS) capacitor c=1.62721e-16
C72 (\13\:Gb VSS) capacitor c=1.4232e-16
C73 (\14\:Gb VSS) capacitor c=8.98143e-17
C74 (\15\:Gb VSS) capacitor c=4.99169e-17
C75 (\4\:n5 VSS) capacitor c=2.10255e-16
C76 (\4\:SN VSS) capacitor c=4.62652e-17
C77 (\19\:Qint VSS) capacitor c=6.31629e-17
C78 (\22\:Qint VSS) capacitor c=1.76348e-16
C79 (\23\:Qint VSS) capacitor c=6.28411e-17
C80 (\3\:QN VSS) capacitor c=4.6767e-17
C81 (\7\:Qbint VSS) capacitor c=3.33191e-17
C82 (\8\:Qbint VSS) capacitor c=2.72388e-17
C83 (\9\:VDD VSS) capacitor c=3.4017e-18
C84 (\11\:VDD VSS) capacitor c=8.78234e-18
C85 (\12\:VDD VSS) capacitor c=1.74829e-17
C86 (\14\:VDD VSS) capacitor c=1.17765e-17
Rk1 (\4\:D D) resistor r=0.03569 c=0
Rk14 (SN \4\:SN) resistor r=0.09089 c=0
Rk21 (\3\:QN QN) resistor r=0.1142 c=0
Rk19 (\2\:QN \3\:QN) resistor r=0.3636 c=0
Rk20 (\3\:QN \5\:QN) resistor r=0.1296 c=0
Rk50 (\1\:VSS \8\:VSS) resistor r=0.09507 c=0
Rk51 (\8\:VSS \9\:VSS) resistor r=0.5689 c=0
Rk52 (\9\:VSS \10\:VSS) resistor r=0.1327 c=0
Rk53 (\10\:VSS \11\:VSS) resistor r=0.614 c=0
Rk55 (\12\:VSS VSS) resistor r=0.04989 c=0
Rk54 (\11\:VSS \12\:VSS) resistor r=0.08755 c=0
Rk59 (\9\:VSS \20\:VSS) resistor r=0.1255 c=0
Rk60 (\11\:VSS \22\:VSS) resistor r=0.2227 c=0
Rk6 (\4\:G G) resistor r=0.002999 c=0
Rk31 (\1\:VDD \8\:VDD) resistor r=0.1452 c=0
Rk32 (\8\:VDD \9\:VDD) resistor r=0.1252 c=0
Rk33 (\9\:VDD \10\:VDD) resistor r=0.1753 c=0
Rk34 (\10\:VDD \11\:VDD) resistor r=0.1828 c=0
Rk35 (\11\:VDD \12\:VDD) resistor r=0.1992 c=0
Rk36 (\12\:VDD \13\:VDD) resistor r=0.2671 c=0
Rk38 (\14\:VDD VDD) resistor r=0.1951 c=0
Rk37 (\13\:VDD \14\:VDD) resistor r=0.2555 c=0
Rk42 (\9\:VDD \22\:VDD) resistor r=0.07369 c=0
Rk43 (\11\:VDD \24\:VDD) resistor r=0.07369 c=0
Rk44 (\12\:VDD \26\:VDD) resistor r=0.04329 c=0
Rk45 (\14\:VDD \28\:VDD) resistor r=0.2403 c=0
Rk25 (\2\:Q Q) resistor r=0.2486 c=0
Rk26 (Q \4\:Q) resistor r=0.1848 c=0
Rk5 (RN \7\:RN) resistor r=0.0693 c=0
Rk7 (\9\:Gb \11\:Gb) resistor r=0.8825 c=0
Rk8 (\11\:Gb \12\:Gb) resistor r=0.8648 c=0
Rk9 (\12\:Gb \13\:Gb) resistor r=0.8064 c=0
Rk10 (\13\:Gb \14\:Gb) resistor r=0.4937 c=0
Rk11 (\13\:Gb \15\:Gb) resistor r=0.2247 c=0
Rk2 (\5\:Gbb \7\:Gbb) resistor r=0.5506 c=0
Rk3 (\7\:Gbb \8\:Gbb) resistor r=0.7063 c=0
Rk12 (\4\:n5 \6\:n5) resistor r=1.7248 c=0
Rk13 (\6\:n5 \8\:n5) resistor r=0.5673 c=0
Rk15 (\18\:Qint \19\:Qint) resistor r=0.424 c=0
Rk16 (\19\:Qint \21\:Qint) resistor r=0.1339 c=0
Rk17 (\21\:Qint \22\:Qint) resistor r=1.3928 c=0
Rk18 (\19\:Qint \23\:Qint) resistor r=0.2844 c=0
Rk22 (\7\:Qbint \8\:Qbint) resistor r=0.1625 c=0
Rk23 (\8\:Qbint \10\:Qbint) resistor r=0.1341 c=0
Rk24 (\8\:Qbint \12\:Qbint) resistor r=0.2951 c=0
Rk4 (\2\:net103 \4\:net103) resistor r=0.2339 c=0
Rl3 (\1\:D \2\:D) resistor r=96.8456 c=0
Rl4 (\2\:D \3\:D) resistor r=89.1533 c=0
Rl20 (\1\:SN \2\:SN) resistor r=55.0021 c=0
Rl21 (\2\:SN \3\:SN) resistor r=76.1559 c=0
Rl16 (\1\:G \2\:G) resistor r=59.6154 c=0
Rl17 (\2\:G \3\:G) resistor r=139.56 c=0
Rl11 (\1\:RN \2\:RN) resistor r=71.4298 c=0
Rl14 (\2\:RN \5\:RN) resistor r=24.2328 c=0
Rl15 (\3\:RN \6\:RN) resistor r=90.3625 c=0
Rl13 (\3\:RN \4\:RN) resistor r=65.3625 c=0
Rl12 (\2\:RN \3\:RN) resistor r=125.837 c=0
Rl8 (\6\:Gb \7\:Gb) resistor r=67.9995 c=0
Rl5 (\4\:Gb \5\:Gb) resistor r=63.7124 c=0
Rl1 (Gb \2\:Gb) resistor r=157.692 c=0
Rl2 (\2\:Gb \3\:Gb) resistor r=29.9451 c=0
Rl6 (Gbb \2\:Gbb) resistor r=236.093 c=0
Rl7 (\2\:Gbb \3\:Gbb) resistor r=80.0021 c=0
Rl18 (n5 \2\:n5) resistor r=176.477 c=0
Rl19 (\2\:n5 \3\:n5) resistor r=24.2328 c=0
Rl9 (\2\:Qint Qint) resistor r=223.077 c=0
Rl10 (\3\:Qint \2\:Qint) resistor r=24.2328 c=0
Rl24 (\7\:Qint \4\:Qint) resistor r=72.348 c=0
Rz5 (\5\:QN \4\:QN) resistor r=75 c=0
Rz16 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz17 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz8 (\1\:VDD \4\:VDD) resistor r=9.375 c=0
Rz9 (\8\:VDD \4\:VDD) resistor r=25 c=0
Rz10 (\10\:VDD \4\:VDD) resistor r=25 c=0
Rz11 (\13\:VDD \4\:VDD) resistor r=7.5 c=0
Rz7 (\4\:Q \3\:Q) resistor r=75 c=0
Rz2 (\8\:Gb \9\:Gb) resistor r=75 c=0
Rz1 (\4\:Gbb \5\:Gbb) resistor r=75 c=0
Rz3 (\7\:n5 \8\:n5) resistor r=75 c=0
Rz4 (\21\:Qint \20\:Qint) resistor r=75 c=0
Rz6 (\10\:Qbint \9\:Qbint) resistor r=75 c=0
Ry7 (\2\:QN \1\:QN) resistor r=20.6667 c=0
Ry18 (\1\:VSS \4\:VSS) resistor r=7.75 c=0
Ry19 (\8\:VSS \4\:VSS) resistor r=31 c=0
Ry20 (\10\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry21 (\12\:VSS \4\:VSS) resistor r=31 c=0
Ry14 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry15 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry16 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry17 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry9 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry4 (\10\:Gb \11\:Gb) resistor r=62 c=0
Ry1 (\6\:Gbb \7\:Gbb) resistor r=62 c=0
Ry5 (\5\:n5 \6\:n5) resistor r=62 c=0
Ry6 (\18\:Qint \17\:Qint) resistor r=31 c=0
Ry8 (\12\:Qbint \11\:Qbint) resistor r=20.6667 c=0
Ry2 (net103 \2\:net103) resistor r=62 c=0
Ry3 (\3\:net103 \4\:net103) resistor r=62 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx9 (\2\:SN \4\:SN) resistor r=45 c=0
Rx4 (\2\:G \4\:G) resistor r=45 c=0
Rx3 (\2\:RN \7\:RN) resistor r=45 c=0
Rx5 (\7\:Gb \12\:Gb) resistor r=45 c=0
Rx6 (\2\:Gb \14\:Gb) resistor r=45 c=0
Rx7 (\5\:Gb \15\:Gb) resistor r=45 c=0
Rx2 (\2\:Gbb \8\:Gbb) resistor r=45 c=0
Rx8 (\2\:n5 \4\:n5) resistor r=45 c=0
Rx10 (\22\:Qint \3\:Qint) resistor r=45 c=0
Rx11 (\23\:Qint \7\:Qint) resistor r=45 c=0
Rx12 (\7\:Qbint Qbint) resistor r=45 c=0
mn2 (\4\:Gbb \3\:Gb \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.465e-14 ps=8.4e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=8.15925 scb=0.00587019 \
        scc=8.94977e-05 m=(1)
mn5 (net191 \3\:D \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.987e-14 ad=3.335e-14 ps=8.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.78e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn6 (\7\:n5 \3\:Gbb net191 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=5.8e-14 ps=7.5e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=1.505e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn17 (\7\:n5 \6\:Gb net171 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=5.8e-14 ps=7.1e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.21e-06 sb=1.06e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn0 (net159 \6\:RN \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.99e-14 ad=3.625e-14 ps=1.03e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.835e-06 sb=4.35e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn16 (net171 \2\:Qint net167 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.045e-14 ps=4.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.465e-06 sb=8.05e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn15 (net167 \4\:RN \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.99e-14 ad=8.7e-15 ps=1.03e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57e-06 sb=7e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn1 (\8\:Gb \3\:G net159 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=2.03e-14 ps=7.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=8.15925 scb=0.00587019 \
        scc=8.94977e-05 m=(1)
mn11 (\20\:Qint n5 net183 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.87e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.565e-06 sd=160n sca=15.0894 \
        scb=0.0156086 scc=0.00108313 m=(1)
mn10 (net183 \3\:SN \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.06e-14 ad=1.23e-14 ps=9.6e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.46e-06 sd=160n sca=15.0894 \
        scb=0.0156086 scc=0.00108313 m=(1)
mn22 (\4\:QN \7\:Qint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.61e-14 ad=4.94e-14 ps=9e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.23269e-07 sb=1.195e-06 sd=160n sca=13.5771 scb=0.0135427 \
        scc=0.000870653 m=(2)
mn20 (\9\:Qbint \4\:Qint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.63269e-07 sb=7.55e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(2)
mn21_1__rcx (\3\:Q Qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27327e-06 sb=3.45e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(2)
mp5 (net142 \1\:D \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.65e-14 ad=7.203e-14 ps=1.19e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=7.25e-07 sd=160n sca=18.6067 \
        scb=0.017995 scc=0.00131765 m=(1)
mp6 (\5\:n5 \4\:Gb net142 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.203e-14 ad=3.44e-14 ps=1.1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=3.45e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp17 (\5\:n5 Gbb \3\:net103 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.4e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp16 (net103 Qint \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.89e-14 ad=3.44e-14 ps=1.53e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2e-06 sd=160n sca=14.8993 scb=0.0146069 \
        scc=0.000816972 m=(1)
mp15 (net103 \5\:RN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.965e-14 ad=3.44e-14 ps=1.63e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=2e-06 sd=160n sca=14.8993 scb=0.0146069 \
        scc=0.000816972 m=(1)
mp0 (\10\:Gb \1\:RN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.965e-14 ad=5.913e-14 ps=1.63e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=2e-06 sd=160n sca=14.8993 scb=0.0146069 \
        scc=0.000816972 m=(1)
mp1 (\10\:Gb \1\:G \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.2245e-13 ad=5.913e-14 ps=2.17e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=2e-06 sd=160n sca=14.8993 scb=0.0146069 \
        scc=0.000816972 m=(1)
mp11 (\17\:Qint \3\:n5 \21\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.2245e-13 ad=8.06e-14 ps=2.17e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.21855e-07 sb=1.765e-06 sd=160n sca=13.3668 \
        scb=0.0122284 scc=0.000582667 m=(1)
mp10 (\17\:Qint \1\:SN \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.55e-14 ad=8.06e-14 ps=1.28e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.22685e-06 sb=1.46e-06 sd=160n sca=13.3668 \
        scb=0.0122284 scc=0.000582667 m=(1)
mp22 (\1\:QN \7\:Qint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.395e-14 ad=6.24e-14 ps=1.19e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.23019e-06 sb=1.165e-06 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(2)
mp20 (\11\:Qbint \4\:Qint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.47756e-06 sb=7.55e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(2)
mp21_1__rcx (\1\:Q Qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.66154e-06 sb=3.45e-07 sd=160n sca=19.7386 \
        scb=0.0168744 scc=0.00159746 m=(2)
ends TLATSRX2
// End of subcircuit definition.

// Generated for: spectre (May  9 18:37:16 2012 )
// Library name: gsclib045
// Cell name: TLATSRX4
// View name: extracted

simulator lang=spectre

subckt TLATSRX4 D G Q QN RN SN VDD VSS
mp1 (\11\:Gb \4\:G \41\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.408e-14 ps=7.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=26.1093 scb=0.0251079 \
        scc=0.0024536 m=(1)
C1 (D VSS) capacitor c=4.92065e-17
C2 (G VSS) capacitor c=5.64066e-17
C3 (QN VSS) capacitor c=2.99783e-16
C4 (Q VSS) capacitor c=2.99097e-16
C5 (RN VSS) capacitor c=6.59094e-16
C6 (VDD VSS) capacitor c=3.7087e-16
C7 (SN VSS) capacitor c=3.8849e-16
C8 (Gb VSS) capacitor c=3.92582e-17
C9 (Qbint VSS) capacitor c=2.83686e-16
C10 (Qint VSS) capacitor c=2.58514e-16
C11 (17 VSS) capacitor c=1.99305e-18
C12 (n5 VSS) capacitor c=2.47729e-17
C13 (18 VSS) capacitor c=1.00421e-18
C14 (net171 VSS) capacitor c=5.28892e-19
C15 (net191 VSS) capacitor c=1.10871e-17
C16 (Gbb VSS) capacitor c=5.1201e-17
C17 (net103 VSS) capacitor c=7.05362e-17
C18 (\5\:Gb VSS) capacitor c=1.75609e-17
C19 (\1\:D VSS) capacitor c=4.67152e-17
C20 (\3\:Gb VSS) capacitor c=5.5991e-17
C21 (\32\:Qint VSS) capacitor c=3.13546e-17
C22 (\6\:RN VSS) capacitor c=7.5636e-17
C23 (\1\:RN VSS) capacitor c=4.20223e-17
C24 (\4\:G VSS) capacitor c=3.17798e-17
C25 (\7\:Gb VSS) capacitor c=3.69092e-17
C26 (\3\:D VSS) capacitor c=3.60806e-17
C27 (\2\:Gbb VSS) capacitor c=4.01386e-17
C28 (\30\:Qint VSS) capacitor c=5.04916e-17
C29 (\5\:RN VSS) capacitor c=4.85712e-17
C30 (\6\:SN VSS) capacitor c=5.08138e-17
C31 (\5\:n5 VSS) capacitor c=3.74003e-17
C32 (\1\:SN VSS) capacitor c=5.64266e-17
C33 (\3\:RN VSS) capacitor c=3.92349e-17
C34 (\1\:G VSS) capacitor c=6.18365e-17
C35 (\6\:Gb VSS) capacitor c=3.03878e-17
C36 (\2\:D VSS) capacitor c=4.66424e-17
C37 (\4\:Gb VSS) capacitor c=5.16358e-17
C38 (\3\:Gbb VSS) capacitor c=2.25624e-17
C39 (\2\:Gb VSS) capacitor c=4.09298e-17
C40 (\31\:Qint VSS) capacitor c=4.3205e-17
C41 (\4\:RN VSS) capacitor c=3.11406e-17
C42 (\2\:RN VSS) capacitor c=3.59259e-17
C43 (\3\:G VSS) capacitor c=1.2982e-17
C44 (\4\:Gbb VSS) capacitor c=5.29244e-17
C45 (\1\:VDD VSS) capacitor c=3.94311e-17
C46 (\8\:n5 VSS) capacitor c=7.49662e-17
C47 (\9\:VDD VSS) capacitor c=1.9287e-17
C48 (\3\:net103 VSS) capacitor c=6.82699e-17
C49 (\34\:Qint VSS) capacitor c=1.85096e-16
C50 (\13\:VDD VSS) capacitor c=1.78741e-17
C51 (\11\:Gb VSS) capacitor c=4.76664e-16
C52 (\41\:VDD VSS) capacitor c=3.2471e-17
C53 (\3\:VDD VSS) capacitor c=1.33979e-16
C54 (\6\:Gbb VSS) capacitor c=1.07852e-16
C55 (\12\:n5 VSS) capacitor c=2.39725e-17
C56 (\40\:Qint VSS) capacitor c=9.2958e-17
C57 (\14\:Qbint VSS) capacitor c=2.94706e-16
C58 (\13\:Gb VSS) capacitor c=7.04063e-17
C59 (\2\:G VSS) capacitor c=1.94601e-17
C60 (\8\:Qint VSS) capacitor c=2.70425e-16
C61 (\3\:n5 VSS) capacitor c=1.55243e-16
C62 (\5\:G VSS) capacitor c=1.95857e-17
C63 (\18\:Qbint VSS) capacitor c=5.28429e-17
C64 (\7\:RN VSS) capacitor c=6.48822e-16
C65 (\8\:RN VSS) capacitor c=2.67516e-17
C66 (\33\:Qint VSS) capacitor c=6.62928e-17
C67 (\38\:Qint VSS) capacitor c=9.49517e-17
C68 (\39\:Qint VSS) capacitor c=2.32078e-17
C69 (\10\:n5 VSS) capacitor c=1.23175e-16
C70 (\11\:n5 VSS) capacitor c=1.0212e-16
C71 (\4\:D VSS) capacitor c=6.77328e-17
C72 (\8\:Gb VSS) capacitor c=7.05691e-17
C73 (\9\:Gb VSS) capacitor c=1.10821e-16
C74 (\10\:Gb VSS) capacitor c=5.7726e-16
C75 (\15\:Gb VSS) capacitor c=5.6988e-17
C76 (\16\:Gb VSS) capacitor c=7.02201e-17
C77 (\8\:Gbb VSS) capacitor c=9.25481e-17
C78 (\5\:VDD VSS) capacitor c=2.01345e-17
C79 (\6\:VDD VSS) capacitor c=3.44799e-16
C80 (\40\:VDD VSS) capacitor c=2.33262e-18
Rk29 (D \4\:D) resistor r=0.1125 c=0
Rk1 (\5\:G G) resistor r=0.05653 c=0
Rk18 (\7\:RN RN) resistor r=5.6724 c=0
Rk19 (RN \8\:RN) resistor r=0.03296 c=0
Rk38 (\2\:VDD \4\:VDD) resistor r=0.4634 c=0
Rk39 (\4\:VDD \5\:VDD) resistor r=0.3097 c=0
Rk40 (\5\:VDD \6\:VDD) resistor r=0.2117 c=0
Rk43 (\5\:VDD \10\:VDD) resistor r=0.04328 c=0
Rk45 (\6\:VDD \14\:VDD) resistor r=0.1198 c=0
Rk63 (\6\:VDD \39\:VDD) resistor r=0.248 c=0
Rk66 (\40\:VDD VDD) resistor r=0.1123 c=0
Rk64 (\39\:VDD \40\:VDD) resistor r=0.0374 c=0
Rk65 (\40\:VDD \42\:VDD) resistor r=0.38 c=0
Rk67 (\2\:VSS \3\:VSS) resistor r=0.1222 c=0
Rk68 (\3\:VSS \5\:VSS) resistor r=0.1928 c=0
Rk69 (\5\:VSS \6\:VSS) resistor r=0.2154 c=0
Rk71 (\3\:VSS \8\:VSS) resistor r=0.5086 c=0
Rk72 (\8\:VSS \10\:VSS) resistor r=0.4138 c=0
Rk82 (\20\:VSS VSS) resistor r=0.1501 c=0
Rk81 (\6\:VSS \20\:VSS) resistor r=0.2053 c=0
Rk30 (\8\:Gb \9\:Gb) resistor r=0.4521 c=0
Rk31 (\9\:Gb \10\:Gb) resistor r=0.4621 c=0
Rk32 (\10\:Gb \12\:Gb) resistor r=4.327 c=0
Rk33 (\12\:Gb \14\:Gb) resistor r=0.4282 c=0
Rk34 (\9\:Gb \15\:Gb) resistor r=0.2637 c=0
Rk35 (\10\:Gb \16\:Gb) resistor r=0.4096 c=0
Rk8 (\14\:Qbint \18\:Qbint) resistor r=0.3455 c=0
Rk20 (\33\:Qint \34\:Qint) resistor r=0.415 c=0
Rk22 (\34\:Qint \38\:Qint) resistor r=0.3009 c=0
Rk23 (\38\:Qint \39\:Qint) resistor r=0.1109 c=0
Rk24 (\38\:Qint \41\:Qint) resistor r=0.5798 c=0
Rk26 (\9\:n5 \10\:n5) resistor r=0.4864 c=0
Rk27 (\10\:n5 \11\:n5) resistor r=0.7341 c=0
Rk28 (\10\:n5 \13\:n5) resistor r=0.09314 c=0
Rk36 (\5\:Gbb \7\:Gbb) resistor r=0.4726 c=0
Rk37 (\7\:Gbb \8\:Gbb) resistor r=0.7035 c=0
Rk25 (\2\:net103 \4\:net103) resistor r=0.2607 c=0
Rl64 (\1\:D \2\:D) resistor r=77.6148 c=0
Rl65 (\2\:D \3\:D) resistor r=89.1533 c=0
Rl3 (\2\:G \4\:G) resistor r=76.385 c=0
Rl1 (\1\:G \2\:G) resistor r=86.048 c=0
Rl2 (\2\:G \3\:G) resistor r=8.3231 c=0
Rl57 (\5\:RN \6\:RN) resistor r=170.72 c=0
Rl56 (\4\:RN \5\:RN) resistor r=35.7417 c=0
Rl4 (\1\:RN \2\:RN) resistor r=81.461 c=0
Rl5 (\2\:RN \3\:RN) resistor r=39.1533 c=0
Rl55 (SN \6\:SN) resistor r=85.7713 c=0
Rl46 (SN \1\:SN) resistor r=88.4615 c=0
Rl66 (\5\:Gb \6\:Gb) resistor r=30.7692 c=0
Rl67 (\6\:Gb \7\:Gb) resistor r=137.637 c=0
Rl63 (\3\:Gb \4\:Gb) resistor r=131.925 c=0
Rl60 (Gb \2\:Gb) resistor r=98.7687 c=0
Rl59 (\31\:Qint \32\:Qint) resistor r=24.7951 c=0
Rl58 (\31\:Qint \30\:Qint) resistor r=128.823 c=0
Rl24 (\8\:Qint Qint) resistor r=143.497 c=0
Rl48 (\2\:n5 n5) resistor r=28.1859 c=0
Rl51 (\3\:n5 \5\:n5) resistor r=28.0797 c=0
Rl49 (\3\:n5 \2\:n5) resistor r=7.5029 c=0
Rl61 (Gbb \2\:Gbb) resistor r=192.308 c=0
Rl62 (\2\:Gbb \3\:Gbb) resistor r=24.2328 c=0
Rz11 (\4\:VDD \3\:VDD) resistor r=7.5 c=0
Rz15 (\6\:VDD \3\:VDD) resistor r=3.125 c=0
Rz17 (\39\:VDD \3\:VDD) resistor r=18.75 c=0
Rz18 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz19 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz9 (\13\:Gb \14\:Gb) resistor r=75 c=0
Rz7 (\41\:Qint \40\:Qint) resistor r=75 c=0
Rz8 (\13\:n5 \12\:n5) resistor r=75 c=0
Rz10 (\6\:Gbb \7\:Gbb) resistor r=75 c=0
Ry14 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry15 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry17 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry25 (\42\:VDD \41\:VDD) resistor r=62 c=0
Ry26 (\5\:VSS \4\:VSS) resistor r=15.5 c=0
Ry30 (\6\:VSS \4\:VSS) resistor r=3.1 c=0
Ry28 (\8\:VSS \4\:VSS) resistor r=6.2 c=0
Ry31 (\20\:VSS \4\:VSS) resistor r=15.5 c=0
Ry12 (\11\:Gb \12\:Gb) resistor r=62 c=0
Ry11 (\9\:n5 \8\:n5) resistor r=62 c=0
Ry13 (\4\:Gbb \5\:Gbb) resistor r=62 c=0
Ry9 (net103 \2\:net103) resistor r=62 c=0
Ry10 (\3\:net103 \4\:net103) resistor r=62 c=0
Rx10 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\3\:G \5\:G) resistor r=45 c=0
Rx5 (\4\:RN \7\:RN) resistor r=45 c=0
Rx6 (\2\:RN \8\:RN) resistor r=45 c=0
Rx11 (\6\:Gb \8\:Gb) resistor r=45 c=0
Rx12 (\4\:Gb \15\:Gb) resistor r=45 c=0
Rx13 (\2\:Gb \16\:Gb) resistor r=45 c=0
Rx2 (\18\:Qbint Qbint) resistor r=45 c=0
Rx7 (\33\:Qint \31\:Qint) resistor r=45 c=0
Rx8 (\39\:Qint Qint) resistor r=45 c=0
Rx9 (\11\:n5 \2\:n5) resistor r=45 c=0
Rx14 (\3\:Gbb \8\:Gbb) resistor r=45 c=0
mn1 (\13\:Gb \1\:G net159 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn0 (net159 \3\:RN \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.355e-14 ad=8.7e-15 ps=1.13e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn21_1__rcx (Q Qbint \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.729e-14 ad=5.2e-14 ps=1.2025e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.44615e-07 sb=2e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(4)
mn20_1__rcx (\14\:Qbint \8\:Qint \6\:VSS VSS) g45n1svt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=9.815e-14 ad=4.16e-14 ps=1.275e-06 pd=8.4e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.72462e-06 sb=2e-06 sd=160n \
        sca=11.3041 scb=0.010759 scc=0.000493236 m=(4)
mn22_1__rcx (QN Qint \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.0554e-13 ad=4.16e-14 ps=1.3425e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.82865e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(4)
mn10 (17 \1\:SN \6\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.675e-14 ad=1.435e-14 ps=1.23e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.62537e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn11 (\40\:Qint \5\:n5 17 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.435e-14 ad=4.305e-14 ps=5.5e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.59171e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn11_1__rcx (\40\:Qint n5 18 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.768e-14 ad=4.305e-14 ps=6.8e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.51707e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn10_1__rcx (18 \6\:SN \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.85e-14 ad=2.768e-14 ps=1.29e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4361e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn15 (net167 \5\:RN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.85e-14 ad=2.683e-14 ps=1.29e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.695e-06 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn16 (net171 \30\:Qint net167 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.683e-14 ad=3.698e-14 ps=6.6e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.465e-06 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn17 (\12\:n5 Gb net171 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.698e-14 ad=2.393e-14 ps=8e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.165e-06 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn6 (\12\:n5 \2\:Gbb net191 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.075e-14 ad=2.393e-14 ps=9.9e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.55e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn5 (net191 \3\:D \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.998e-14 ad=5.075e-14 ps=1.3e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.6e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn2 (\6\:Gbb \7\:Gb \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.998e-14 ad=2.03e-14 ps=1.3e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mp0 (\11\:Gb \1\:RN \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0522e-13 ad=4.408e-14 ps=2.08e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.9e-07 sb=2e-06 sd=160n sca=23.7329 scb=0.0218323 \
        scc=0.00242471 m=(1)
mp21_1__rcx (Q Qbint \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.3416e-13 ad=7.8e-14 ps=1.71e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.52821e-07 sb=2e-06 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(4)
mp20_1__rcx (\14\:Qbint \8\:Qint \6\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=1.4445e-13 ad=6.825e-14 ps=1.59e-06 pd=1.13e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.72179e-06 sb=2e-06 sd=160n \
        sca=17.2385 scb=0.0152696 scc=0.00137893 m=(4)
mp22_1__rcx (QN Qint \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.122e-13 ad=9.848e-14 ps=1.44e-06 pd=1.285e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.7925e-06 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(4)
mp10 (\34\:Qint SN \6\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.604e-14 ad=4.96e-14 ps=1.67e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.03476e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(2)
mp11_1__rcx (\34\:Qint \3\:n5 \13\:VDD VDD) g45p1svt w=(3.1e-07) \
        l=4.5e-08 nf=1 as=8.35e-14 ad=4.96e-14 ps=1.84e-06 pd=9.4e-07 \
        nrd=1.16667 nrs=1.16667 sa=2e-06 sb=8.29758e-07 sd=160n \
        sca=19.1541 scb=0.0174883 scc=0.00172295 m=(2)
mp15 (\3\:net103 \6\:RN \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.327e-14 ad=3.44e-14 ps=1.82e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.05e-07 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp16 (\3\:net103 \32\:Qint \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.915e-14 ad=3.44e-14 ps=1.54e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1e-07 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp17 (\8\:n5 Gbb net103 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=4.837e-14 ps=1e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.37674e-07 sb=1.04e-06 sd=160n sca=12.3081 \
        scb=0.0110829 scc=0.000360616 m=(1)
mp6 (\8\:n5 \3\:Gb net142 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=4.837e-14 ps=5.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.07674e-07 sb=7.7e-07 sd=160n sca=12.4312 \
        scb=0.0111096 scc=0.000360619 m=(1)
mp5 (net142 \1\:D \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.245e-14 ad=1.72e-14 ps=1.29e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.32674e-07 sb=6.45e-07 sd=160n sca=12.7779 \
        scb=0.0112399 scc=0.000360661 m=(1)
mp2 (\4\:Gbb \5\:Gb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.245e-14 ad=3.655e-14 ps=1.29e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.10767e-06 sb=1.7e-07 sd=160n sca=18.9906 \
        scb=0.0207424 scc=0.000624384 m=(1)
ends TLATSRX4
// End of subcircuit definition.

// Generated for: spectre (May  9 18:38:02 2012 )
// Library name: gsclib045
// Cell name: TLATSRXL
// View name: extracted

simulator lang=spectre

subckt TLATSRXL D G Q QN RN SN VDD VSS
mp21 (\1\:Q \4\:Qbint \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.73e-14 ad=3.548e-14 ps=1.47e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=49.1385 \
        scb=0.0321853 scc=0.00591609 m=(1)
C1 (SN VSS) capacitor c=4.93682e-17
C2 (D VSS) capacitor c=6.44766e-17
C3 (Q VSS) capacitor c=2.29675e-17
C4 (VDD VSS) capacitor c=2.64264e-16
C5 (G VSS) capacitor c=5.95955e-17
C6 (QN VSS) capacitor c=3.02935e-17
C7 (Qbint VSS) capacitor c=2.08689e-17
C8 (Qint VSS) capacitor c=3.80143e-17
C9 (net183 VSS) capacitor c=9.46826e-20
C10 (n5 VSS) capacitor c=5.4435e-17
C11 (net159 VSS) capacitor c=1.69534e-18
C12 (Gb VSS) capacitor c=4.70952e-17
C13 (net167 VSS) capacitor c=3.21829e-18
C14 (net171 VSS) capacitor c=5.61054e-18
C15 (Gbb VSS) capacitor c=3.20815e-17
C16 (net103 VSS) capacitor c=6.70442e-17
C17 (net142 VSS) capacitor c=5.37863e-19
C18 (\5\:Gb VSS) capacitor c=4.13998e-17
C19 (\3\:D VSS) capacitor c=5.46628e-17
C20 (\3\:Gb VSS) capacitor c=5.85542e-17
C21 (\3\:Gbb VSS) capacitor c=5.41383e-17
C22 (\10\:Qint VSS) capacitor c=3.004e-17
C23 (\5\:RN VSS) capacitor c=3.03344e-17
C24 (\3\:RN VSS) capacitor c=2.69162e-17
C25 (\3\:G VSS) capacitor c=4.20085e-17
C26 (\1\:SN VSS) capacitor c=3.67634e-17
C27 (\7\:Qint VSS) capacitor c=3.07949e-17
C28 (\4\:Qbint VSS) capacitor c=3.62353e-17
C29 (\6\:Gb VSS) capacitor c=4.65179e-17
C30 (\1\:D VSS) capacitor c=5.2654e-17
C31 (\8\:Qint VSS) capacitor c=6.36384e-17
C32 (\1\:RN VSS) capacitor c=4.40994e-17
C33 (\4\:RN VSS) capacitor c=2.4736e-17
C34 (\1\:G VSS) capacitor c=4.31189e-17
C35 (\2\:n5 VSS) capacitor c=3.6606e-17
C36 (\3\:SN VSS) capacitor c=4.52131e-17
C37 (\6\:Qint VSS) capacitor c=2.01328e-17
C38 (\4\:Qint VSS) capacitor c=3.0913e-17
C39 (\3\:Qbint VSS) capacitor c=2.53734e-17
C40 (\7\:Gb VSS) capacitor c=2.01937e-17
C41 (\2\:D VSS) capacitor c=5.60615e-17
C42 (\2\:Gbb VSS) capacitor c=5.94168e-17
C43 (\4\:Gb VSS) capacitor c=2.48722e-17
C44 (\2\:Gb VSS) capacitor c=2.3107e-17
C45 (\9\:Qint VSS) capacitor c=5.76794e-17
C46 (\2\:RN VSS) capacitor c=7.35156e-17
C47 (\2\:G VSS) capacitor c=4.48639e-17
C48 (\3\:n5 VSS) capacitor c=1.9555e-17
C49 (\2\:SN VSS) capacitor c=3.89418e-17
C50 (\5\:Qint VSS) capacitor c=1.72079e-17
C51 (\4\:Gbb VSS) capacitor c=3.85926e-17
C52 (\1\:VDD VSS) capacitor c=3.32311e-17
C53 (\4\:n5 VSS) capacitor c=7.87603e-17
C54 (\3\:net103 VSS) capacitor c=8.73263e-17
C55 (\13\:VDD VSS) capacitor c=2.72895e-17
C56 (\15\:VDD VSS) capacitor c=8.12412e-18
C57 (\15\:Gb VSS) capacitor c=7.36036e-17
C58 (\17\:VDD VSS) capacitor c=1.55623e-17
C59 (\12\:Qint VSS) capacitor c=1.49958e-16
C60 (\19\:VDD VSS) capacitor c=3.9606e-18
C61 (\1\:QN VSS) capacitor c=3.95521e-17
C62 (\5\:Qbint VSS) capacitor c=2.38914e-17
C63 (\21\:VDD VSS) capacitor c=9.89215e-18
C64 (\1\:Q VSS) capacitor c=1.56219e-17
C65 (\3\:VDD VSS) capacitor c=1.09544e-16
C66 (\8\:Gbb VSS) capacitor c=1.92067e-17
C67 (\6\:n5 VSS) capacitor c=2.00598e-16
C68 (\13\:Gb VSS) capacitor c=3.25441e-17
C69 (\15\:Qint VSS) capacitor c=3.03236e-17
C70 (\4\:QN VSS) capacitor c=2.42629e-17
C71 (\9\:Qbint VSS) capacitor c=4.20366e-17
C72 (\3\:Q VSS) capacitor c=4.28001e-17
C73 (\2\:Qbint VSS) capacitor c=1.34041e-17
C74 (\2\:Qint VSS) capacitor c=2.83195e-17
C75 (\3\:Qint VSS) capacitor c=3.4987e-17
C76 (\7\:Qbint VSS) capacitor c=3.45014e-17
C77 (\8\:Qbint VSS) capacitor c=3.44469e-17
C78 (\3\:QN VSS) capacitor c=5.68776e-17
C79 (\4\:SN VSS) capacitor c=6.27596e-17
C80 (\4\:G VSS) capacitor c=7.57616e-17
C81 (\6\:RN VSS) capacitor c=1.3136e-16
C82 (\11\:Qint VSS) capacitor c=1.74803e-16
C83 (\14\:Qint VSS) capacitor c=1.12227e-16
C84 (\17\:Qint VSS) capacitor c=6.77043e-17
C85 (\8\:n5 VSS) capacitor c=1.58856e-16
C86 (\4\:D VSS) capacitor c=3.03208e-17
C87 (\6\:Gbb VSS) capacitor c=3.89771e-17
C88 (\7\:Gbb VSS) capacitor c=5.7375e-17
C89 (\8\:Gb VSS) capacitor c=4.53561e-17
C90 (\9\:Gb VSS) capacitor c=1.02856e-16
C91 (\10\:Gb VSS) capacitor c=1.76757e-16
C92 (\11\:Gb VSS) capacitor c=2.04997e-17
C93 (\12\:Gb VSS) capacitor c=1.55687e-16
C94 (\5\:VDD VSS) capacitor c=9.01662e-18
C95 (\11\:VDD VSS) capacitor c=9.28891e-18
Rk9 (SN \4\:SN) resistor r=0.1349 c=0
Rk19 (\4\:D D) resistor r=0.1484 c=0
Rk2 (\4\:Q Q) resistor r=0.0928 c=0
Rk1 (\2\:Q \4\:Q) resistor r=0.2241 c=0
Rk11 (RN \6\:RN) resistor r=0.006782 c=0
Rk29 (\2\:VDD \4\:VDD) resistor r=0.1787 c=0
Rk30 (\4\:VDD \5\:VDD) resistor r=0.2905 c=0
Rk31 (\5\:VDD \6\:VDD) resistor r=0.1101 c=0
Rk32 (\6\:VDD \7\:VDD) resistor r=0.09001 c=0
Rk33 (\7\:VDD \8\:VDD) resistor r=0.1602 c=0
Rk34 (\8\:VDD \9\:VDD) resistor r=0.1702 c=0
Rk35 (\9\:VDD \10\:VDD) resistor r=0.1301 c=0
Rk36 (\10\:VDD \11\:VDD) resistor r=0.1301 c=0
Rk43 (\12\:VDD VDD) resistor r=0.2509 c=0
Rk37 (\11\:VDD \12\:VDD) resistor r=0.3205 c=0
Rk38 (\5\:VDD \14\:VDD) resistor r=0.143 c=0
Rk39 (\7\:VDD \16\:VDD) resistor r=0.07334 c=0
Rk40 (\9\:VDD \18\:VDD) resistor r=0.07334 c=0
Rk41 (\11\:VDD \20\:VDD) resistor r=0.07334 c=0
Rk42 (\12\:VDD \22\:VDD) resistor r=0.2687 c=0
Rk10 (G \4\:G) resistor r=0.2005 c=0
Rk44 (\2\:VSS \3\:VSS) resistor r=0.05242 c=0
Rk45 (\3\:VSS \4\:VSS) resistor r=0.5258 c=0
Rk46 (\4\:VSS \5\:VSS) resistor r=0.1226 c=0
Rk47 (\5\:VSS \6\:VSS) resistor r=0.6112 c=0
Rk48 (\6\:VSS \7\:VSS) resistor r=0.2905 c=0
Rk50 (\8\:VSS VSS) resistor r=0.2125 c=0
Rk49 (\7\:VSS \8\:VSS) resistor r=0.03739 c=0
Rk51 (\3\:VSS \10\:VSS) resistor r=0.3115 c=0
Rk52 (\4\:VSS \12\:VSS) resistor r=0.2184 c=0
Rk53 (\6\:VSS \14\:VSS) resistor r=0.3246 c=0
Rk54 (\8\:VSS \16\:VSS) resistor r=0.3666 c=0
Rk7 (\3\:QN QN) resistor r=0.0121 c=0
Rk6 (\2\:QN \3\:QN) resistor r=0.3016 c=0
Rk8 (\3\:QN \5\:QN) resistor r=0.07419 c=0
Rk3 (\6\:Qbint \7\:Qbint) resistor r=0.1144 c=0
Rk4 (\7\:Qbint \8\:Qbint) resistor r=0.119 c=0
Rk5 (\7\:Qbint \10\:Qbint) resistor r=0.1084 c=0
Rk12 (\11\:Qint \13\:Qint) resistor r=1.2207 c=0
Rk13 (\13\:Qint \14\:Qint) resistor r=0.5552 c=0
Rk14 (\14\:Qint \16\:Qint) resistor r=0.1036 c=0
Rk15 (\14\:Qint \17\:Qint) resistor r=0.3941 c=0
Rk17 (\5\:n5 \7\:n5) resistor r=0.4493 c=0
Rk18 (\7\:n5 \8\:n5) resistor r=1.264 c=0
Rk23 (\8\:Gb \9\:Gb) resistor r=0.3764 c=0
Rk24 (\9\:Gb \10\:Gb) resistor r=0.6424 c=0
Rk25 (\9\:Gb \11\:Gb) resistor r=0.04035 c=0
Rk26 (\10\:Gb \12\:Gb) resistor r=0.7677 c=0
Rk27 (\12\:Gb \14\:Gb) resistor r=0.1156 c=0
Rk28 (\12\:Gb \16\:Gb) resistor r=0.3388 c=0
Rk20 (\5\:Gbb \6\:Gbb) resistor r=0.2728 c=0
Rk21 (\6\:Gbb \7\:Gbb) resistor r=0.2819 c=0
Rk22 (\6\:Gbb \9\:Gbb) resistor r=0.1228 c=0
Rk16 (\2\:net103 \4\:net103) resistor r=0.299 c=0
Rl10 (\1\:SN \2\:SN) resistor r=29.5379 c=0
Rl11 (\2\:SN \3\:SN) resistor r=133.384 c=0
Rl27 (\2\:D \3\:D) resistor r=51.9003 c=0
Rl26 (\1\:D \2\:D) resistor r=95.9489 c=0
Rl19 (\2\:RN \5\:RN) resistor r=81.8672 c=0
Rl17 (\2\:RN \3\:RN) resistor r=146.746 c=0
Rl16 (\1\:RN \2\:RN) resistor r=153.916 c=0
Rl18 (\2\:RN \4\:RN) resistor r=85.7134 c=0
Rl15 (\2\:G \3\:G) resistor r=137.436 c=0
Rl14 (\1\:G \2\:G) resistor r=128.593 c=0
Rl1 (Qbint \2\:Qbint) resistor r=2.0213 c=0
Rl3 (\2\:Qbint \4\:Qbint) resistor r=47.791 c=0
Rl2 (\2\:Qbint \3\:Qbint) resistor r=36.2526 c=0
Rl21 (\9\:Qint \10\:Qint) resistor r=42.9635 c=0
Rl20 (\8\:Qint \9\:Qint) resistor r=174.513 c=0
Rl8 (\5\:Qint \6\:Qint) resistor r=29.5379 c=0
Rl4 (Qint \2\:Qint) resistor r=105.003 c=0
Rl7 (\2\:Qint \5\:Qint) resistor r=24.9253 c=0
Rl9 (\3\:Qint \7\:Qint) resistor r=28.0797 c=0
Rl6 (\3\:Qint \4\:Qint) resistor r=60.772 c=0
Rl5 (\2\:Qint \3\:Qint) resistor r=170.517 c=0
Rl12 (n5 \2\:n5) resistor r=188.462 c=0
Rl13 (\2\:n5 \3\:n5) resistor r=26.1559 c=0
Rl28 (\5\:Gb \6\:Gb) resistor r=169.231 c=0
Rl29 (\5\:Gb \7\:Gb) resistor r=35.6938 c=0
Rl23 (\3\:Gb \4\:Gb) resistor r=66.5405 c=0
Rl22 (Gb \2\:Gb) resistor r=26.1559 c=0
Rl24 (Gbb \2\:Gbb) resistor r=26.098 c=0
Rl25 (\2\:Gbb \3\:Gbb) resistor r=181.433 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz8 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz9 (\3\:VDD \6\:VDD) resistor r=37.5 c=0
Rz10 (\3\:VDD \8\:VDD) resistor r=25 c=0
Rz11 (\3\:VDD \10\:VDD) resistor r=25 c=0
Rz12 (\3\:VDD \12\:VDD) resistor r=12.5 c=0
Rz13 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz14 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz15 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz16 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz3 (\4\:QN \5\:QN) resistor r=75 c=0
Rz2 (\9\:Qbint \10\:Qbint) resistor r=75 c=0
Rz4 (\15\:Qint \16\:Qint) resistor r=75 c=0
Rz5 (\6\:n5 \7\:n5) resistor r=75 c=0
Rz7 (\13\:Gb \14\:Gb) resistor r=75 c=0
Rz6 (\8\:Gbb \9\:Gbb) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=62 c=0
Ry10 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry11 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry12 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry13 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry14 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry15 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry16 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry17 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry18 (\1\:VSS \7\:VSS) resistor r=10.3333 c=0
Ry3 (\1\:QN \2\:QN) resistor r=62 c=0
Ry2 (\5\:Qbint \6\:Qbint) resistor r=62 c=0
Ry4 (\12\:Qint \13\:Qint) resistor r=62 c=0
Ry7 (\4\:n5 \5\:n5) resistor r=62 c=0
Ry9 (\15\:Gb \16\:Gb) resistor r=62 c=0
Ry8 (\4\:Gbb \5\:Gbb) resistor r=62 c=0
Ry5 (net103 \2\:net103) resistor r=62 c=0
Ry6 (\3\:net103 \4\:net103) resistor r=62 c=0
Rx2 (\2\:SN \4\:SN) resistor r=45 c=0
Rx8 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:RN \6\:RN) resistor r=45 c=0
Rx3 (\2\:G \4\:G) resistor r=45 c=0
Rx1 (Qbint \8\:Qbint) resistor r=45 c=0
Rx5 (\9\:Qint \11\:Qint) resistor r=45 c=0
Rx6 (\5\:Qint \17\:Qint) resistor r=45 c=0
Rx7 (\3\:n5 \8\:n5) resistor r=45 c=0
Rx10 (\7\:Gb \8\:Gb) resistor r=45 c=0
Rx11 (\2\:Gb \10\:Gb) resistor r=45 c=0
Rx12 (\4\:Gb \11\:Gb) resistor r=45 c=0
Rx9 (\2\:Gbb \7\:Gbb) resistor r=45 c=0
mn21 (\3\:Q \3\:Qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.392e-14 ps=6.1e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn20 (\9\:Qbint \4\:Qint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn22 (\4\:QN \6\:Qint \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.465e-14 ps=6.9e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=6.6e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn10 (net183 \3\:SN \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=3.335e-14 ps=6.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=4.15e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn11 (\15\:Qint \2\:n5 net183 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=2.03e-14 ps=7.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn1 (\13\:Gb \1\:G net159 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.407e-14 ad=2.03e-14 ps=7.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.735e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn0 (net159 \4\:RN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=3.407e-14 ps=9.9e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.2e-07 sb=1.455e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn15 (net167 \1\:RN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=1.595e-14 ps=9.9e-07 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.85e-07 sb=1.19e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn16 (net171 \8\:Qint net167 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=2.9e-14 ps=5.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.035e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn17 (\6\:n5 Gb net171 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=3.407e-14 ps=6.9e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.085e-06 sb=7.9e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn6 (\6\:n5 Gbb net191 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.74e-14 ad=3.407e-14 ps=5.3e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.365e-06 sb=5.1e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn5 (net191 \1\:D \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.74e-14 ps=6.1e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.53e-06 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn2 (\8\:Gbb \6\:Gb \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.735e-06 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mp20 (\5\:Qbint \7\:Qint \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.73e-14 ad=3.01e-14 ps=1.47e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=46.9517 scb=0.029008 \
        scc=0.00588492 m=(1)
mp22 (\1\:QN Qint \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.715e-14 ad=3.655e-14 ps=1.6e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.68e-06 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp15 (net103 \5\:RN \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.64e-14 ad=3.44e-14 ps=1.5e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.545e-06 sb=3.05e-07 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp10 (\12\:Qint \1\:SN \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.715e-14 ad=4.945e-14 ps=1.6e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=1.435e-06 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp11 (\12\:Qint n5 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.327e-14 ad=4.945e-14 ps=1.75e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=1.16e-06 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp1 (\15\:Gb \3\:G \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.327e-14 ad=6.342e-14 ps=1.75e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=8.4e-07 sd=160n sca=11.7888 \
        scb=0.0102603 scc=0.000281769 m=(1)
mp0 (\15\:Gb \3\:RN \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.64e-14 ad=6.342e-14 ps=1.5e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.35e-06 sb=5e-07 sd=160n sca=11.7888 scb=0.0102603 \
        scc=0.000281769 m=(1)
mp16 (net103 \10\:Qint \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.04e-14 ad=3.44e-14 ps=1.19e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-06 sb=1e-07 sd=160n sca=11.7888 scb=0.0102603 \
        scc=0.000281769 m=(1)
mp17 (\4\:n5 \3\:Gbb \3\:net103 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.37e-14 ad=3.44e-14 ps=1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.03256e-07 sb=7.4e-07 sd=160n sca=16.4252 \
        scb=0.0160149 scc=0.00103902 m=(1)
mp6 (\4\:n5 \3\:Gb net142 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.827e-14 ad=3.44e-14 ps=6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.08256e-07 sb=5.35e-07 sd=160n sca=17.3959 \
        scb=0.0167815 scc=0.00104031 m=(1)
mp5 (net142 \3\:D \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.47e-14 ad=1.827e-14 ps=1.66e-06 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.38256e-07 sb=4.05e-07 sd=160n sca=18.6804 \
        scb=0.0185729 scc=0.00105319 m=(1)
mp2 (\4\:Gbb \5\:Gb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.47e-14 ad=3.01e-14 ps=1.66e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.03256e-07 sb=1.4e-07 sd=160n sca=29.6999 \
        scb=0.0349125 scc=0.00244535 m=(1)
ends TLATSRXL
// End of subcircuit definition.

// Generated for: spectre (May  9 18:38:42 2012 )
// Library name: gsclib045
// Cell name: TLATX1
// View name: extracted

simulator lang=spectre

subckt TLATX1 D G Q QN VDD VSS
mp1 (\8\:Gbb \3\:Gb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=3.655e-14 ps=8.4e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.265e-06 sd=160n sca=16.8928 \
        scb=0.0171325 scc=0.000344283 m=(1)
C1 (G VSS) capacitor c=6.84916e-17
C2 (D VSS) capacitor c=5.9029e-17
C3 (VDD VSS) capacitor c=2.13757e-16
C4 (Gb VSS) capacitor c=5.43031e-17
C5 (Gbb VSS) capacitor c=7.27805e-17
C6 (net257 VSS) capacitor c=1.02346e-17
C7 (n0 VSS) capacitor c=3.46058e-17
C8 (Qint VSS) capacitor c=8.74032e-17
C9 (Qbint VSS) capacitor c=3.75069e-17
C10 (net212 VSS) capacitor c=1.24322e-18
C11 (\4\:Qint VSS) capacitor c=4.44729e-17
C12 (\10\:Qint VSS) capacitor c=3.70221e-17
C13 (\3\:G VSS) capacitor c=3.37763e-17
C14 (\3\:n0 VSS) capacitor c=5.84844e-17
C15 (\3\:Qint VSS) capacitor c=6.26849e-17
C16 (\4\:Gb VSS) capacitor c=3.54548e-17
C17 (\1\:D VSS) capacitor c=5.68871e-17
C18 (\3\:Gb VSS) capacitor c=2.53484e-17
C19 (\4\:Qbint VSS) capacitor c=3.36123e-17
C20 (\8\:Qint VSS) capacitor c=2.79502e-17
C21 (\9\:Qint VSS) capacitor c=3.24434e-17
C22 (\1\:G VSS) capacitor c=3.61369e-17
C23 (\6\:Gb VSS) capacitor c=8.12072e-17
C24 (\4\:Gbb VSS) capacitor c=3.26487e-17
C25 (\3\:D VSS) capacitor c=3.86496e-17
C26 (\3\:Qbint VSS) capacitor c=2.08668e-17
C27 (\7\:Qint VSS) capacitor c=2.24639e-17
C28 (\2\:G VSS) capacitor c=4.43944e-17
C29 (\2\:n0 VSS) capacitor c=6.46912e-17
C30 (\2\:Qint VSS) capacitor c=8.30473e-17
C31 (\7\:Gb VSS) capacitor c=3.82473e-17
C32 (\5\:Gb VSS) capacitor c=3.67169e-17
C33 (\3\:Gbb VSS) capacitor c=2.82991e-17
C34 (\2\:D VSS) capacitor c=5.27957e-17
C35 (\2\:Gb VSS) capacitor c=4.85421e-17
C36 (\1\:Q VSS) capacitor c=6.87737e-17
C37 (\1\:VDD VSS) capacitor c=8.25476e-17
C38 (\9\:Qbint VSS) capacitor c=5.93874e-17
C39 (\1\:QN VSS) capacitor c=6.81542e-17
C40 (\9\:VDD VSS) capacitor c=3.44391e-17
C41 (\14\:Gb VSS) capacitor c=1.46697e-16
C42 (\17\:Qint VSS) capacitor c=5.2554e-17
C43 (\11\:VDD VSS) capacitor c=2.3737e-17
C44 (\6\:n0 VSS) capacitor c=7.86982e-17
C45 (\13\:VDD VSS) capacitor c=3.68678e-17
C46 (\8\:Gbb VSS) capacitor c=6.22015e-17
C47 (\3\:VDD VSS) capacitor c=7.51607e-17
C48 (\3\:Q VSS) capacitor c=4.34367e-17
C49 (\7\:Qbint VSS) capacitor c=2.08592e-17
C50 (\3\:QN VSS) capacitor c=6.24708e-17
C51 (\8\:Gb VSS) capacitor c=8.58076e-17
C52 (\15\:Qint VSS) capacitor c=3.02624e-17
C53 (\8\:n0 VSS) capacitor c=4.33318e-17
C54 (\6\:Gbb VSS) capacitor c=8.60141e-17
C55 (\2\:Gbb VSS) capacitor c=3.94526e-17
C56 (\5\:Qint VSS) capacitor c=3.26823e-17
C57 (\6\:Qint VSS) capacitor c=2.26652e-17
C58 (\2\:Qbint VSS) capacitor c=1.37742e-17
C59 (\4\:D VSS) capacitor c=5.42857e-17
C60 (\5\:Gbb VSS) capacitor c=7.28723e-17
C61 (\4\:n0 VSS) capacitor c=3.90624e-17
C62 (\5\:n0 VSS) capacitor c=7.54566e-17
C63 (\10\:Gb VSS) capacitor c=1.63988e-16
C64 (\11\:Gb VSS) capacitor c=1.04097e-16
C65 (\12\:Gb VSS) capacitor c=1.41798e-16
C66 (\13\:Gb VSS) capacitor c=6.67936e-17
C67 (\4\:G VSS) capacitor c=2.46413e-17
C68 (\11\:Qint VSS) capacitor c=6.99855e-17
C69 (\12\:Qint VSS) capacitor c=5.66931e-17
C70 (\13\:Qint VSS) capacitor c=4.52707e-17
C71 (\14\:Qint VSS) capacitor c=2.82388e-17
C72 (\5\:Qbint VSS) capacitor c=3.42967e-17
C73 (\6\:Qbint VSS) capacitor c=2.18116e-17
C74 (\5\:VDD VSS) capacitor c=2.8081e-17
C75 (\7\:VDD VSS) capacitor c=2.35624e-17
Rk14 (\4\:G G) resistor r=0.00899 c=0
Rk20 (\2\:QN QN) resistor r=0.3868 c=0
Rk21 (QN \4\:QN) resistor r=0.05406 c=0
Rk1 (D \4\:D) resistor r=0.0245 c=0
Rk27 (\2\:VDD \4\:VDD) resistor r=0.4672 c=0
Rk28 (\4\:VDD \5\:VDD) resistor r=0.2981 c=0
Rk29 (\5\:VDD \6\:VDD) resistor r=0.4039 c=0
Rk30 (\6\:VDD \7\:VDD) resistor r=0.4491 c=0
Rk32 (\8\:VDD VDD) resistor r=0.04988 c=0
Rk31 (\7\:VDD \8\:VDD) resistor r=0.1026 c=0
Rk33 (\5\:VDD \10\:VDD) resistor r=0.2211 c=0
Rk34 (\6\:VDD \12\:VDD) resistor r=0.07144 c=0
Rk35 (\7\:VDD \14\:VDD) resistor r=0.2233 c=0
Rk25 (\2\:Q Q) resistor r=0.2589 c=0
Rk26 (Q \4\:Q) resistor r=0.03299 c=0
Rk36 (\2\:VSS \4\:VSS) resistor r=0.573 c=0
Rk37 (\4\:VSS \5\:VSS) resistor r=0.1126 c=0
Rk38 (\5\:VSS \6\:VSS) resistor r=0.3631 c=0
Rk39 (\6\:VSS \7\:VSS) resistor r=0.2254 c=0
Rk40 (\7\:VSS \8\:VSS) resistor r=0.2053 c=0
Rk42 (\9\:VSS VSS) resistor r=0.04988 c=0
Rk41 (\8\:VSS \9\:VSS) resistor r=0.1452 c=0
Rk43 (\5\:VSS \11\:VSS) resistor r=0.3009 c=0
Rk44 (\6\:VSS \13\:VSS) resistor r=0.07358 c=0
Rk45 (\8\:VSS \15\:VSS) resistor r=0.07358 c=0
Rk7 (\9\:Gb \10\:Gb) resistor r=0.6464 c=0
Rk8 (\10\:Gb \11\:Gb) resistor r=0.7159 c=0
Rk9 (\11\:Gb \12\:Gb) resistor r=0.1305 c=0
Rk10 (\12\:Gb \13\:Gb) resistor r=0.3437 c=0
Rk11 (\12\:Gb \15\:Gb) resistor r=1.1234 c=0
Rk2 (\5\:Gbb \7\:Gbb) resistor r=0.452 c=0
Rk3 (\7\:Gbb \9\:Gbb) resistor r=0.5659 c=0
Rk4 (\4\:n0 \5\:n0) resistor r=0.2351 c=0
Rk5 (\5\:n0 \7\:n0) resistor r=0.5031 c=0
Rk6 (\5\:n0 \9\:n0) resistor r=0.1459 c=0
Rk15 (\11\:Qint \12\:Qint) resistor r=0.384 c=0
Rk16 (\12\:Qint \13\:Qint) resistor r=0.295 c=0
Rk17 (\13\:Qint \14\:Qint) resistor r=0.1871 c=0
Rk18 (\12\:Qint \16\:Qint) resistor r=0.1231 c=0
Rk19 (\13\:Qint \18\:Qint) resistor r=0.1968 c=0
Rk22 (\5\:Qbint \6\:Qbint) resistor r=0.1519 c=0
Rk23 (\6\:Qbint \8\:Qbint) resistor r=0.1671 c=0
Rk24 (\6\:Qbint \10\:Qbint) resistor r=0.2193 c=0
Rl15 (\2\:G \3\:G) resistor r=58.7912 c=0
Rl14 (\1\:G \2\:G) resistor r=102.32 c=0
Rl3 (\1\:D \2\:D) resistor r=143 c=0
Rl4 (\2\:D \3\:D) resistor r=79.5379 c=0
Rl9 (\6\:Gb \7\:Gb) resistor r=31.0185 c=0
Rl5 (\4\:Gb \5\:Gb) resistor r=66.5405 c=0
Rl1 (Gb \2\:Gb) resistor r=194.231 c=0
Rl2 (\2\:Gb \3\:Gb) resistor r=29.9451 c=0
Rl6 (Gbb \2\:Gbb) resistor r=198.145 c=0
Rl8 (\2\:Gbb \4\:Gbb) resistor r=50.349 c=0
Rl7 (\2\:Gbb \3\:Gbb) resistor r=80.5242 c=0
Rl12 (n0 \2\:n0) resistor r=43.3029 c=0
Rl13 (\2\:n0 \3\:n0) resistor r=178.641 c=0
Rl10 (Qint \2\:Qint) resistor r=132.487 c=0
Rl11 (\2\:Qint \3\:Qint) resistor r=111.516 c=0
Rl16 (\4\:Qint \5\:Qint) resistor r=74.2335 c=0
Rl19 (\5\:Qint \8\:Qint) resistor r=28.0797 c=0
Rl21 (\6\:Qint \10\:Qint) resistor r=96.8988 c=0
Rl20 (\6\:Qint \9\:Qint) resistor r=33.4373 c=0
Rl18 (\6\:Qint \7\:Qint) resistor r=7.9329 c=0
Rl17 (\5\:Qint \6\:Qint) resistor r=206.01 c=0
Rl22 (Qbint \2\:Qbint) resistor r=34.3295 c=0
Rl24 (\2\:Qbint \4\:Qbint) resistor r=63.1757 c=0
Rl23 (\2\:Qbint \3\:Qbint) resistor r=2.0166 c=0
Rz5 (\3\:QN \4\:QN) resistor r=75 c=0
Rz8 (\3\:VDD \4\:VDD) resistor r=15 c=0
Rz9 (\3\:VDD \6\:VDD) resistor r=8.3333 c=0
Rz10 (\3\:VDD \8\:VDD) resistor r=37.5 c=0
Rz7 (\3\:Q \4\:Q) resistor r=75 c=0
Rz11 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz12 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz13 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz14 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz3 (\8\:Gb \9\:Gb) resistor r=75 c=0
Rz1 (\6\:Gbb \7\:Gbb) resistor r=75 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Rz4 (\15\:Qint \16\:Qint) resistor r=75 c=0
Rz6 (\7\:Qbint \8\:Qbint) resistor r=75 c=0
Ry5 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry8 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry9 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry10 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry11 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry7 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry12 (\3\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry13 (\3\:VSS \7\:VSS) resistor r=12.4 c=0
Ry14 (\3\:VSS \9\:VSS) resistor r=31 c=0
Ry3 (\14\:Gb \15\:Gb) resistor r=62 c=0
Ry1 (\8\:Gbb \9\:Gbb) resistor r=62 c=0
Ry2 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry4 (\17\:Qint \18\:Qint) resistor r=62 c=0
Ry6 (\9\:Qbint \10\:Qbint) resistor r=20.6667 c=0
Rx7 (\2\:G \4\:G) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\7\:Gb \10\:Gb) resistor r=45 c=0
Rx5 (\5\:Gb \11\:Gb) resistor r=45 c=0
Rx6 (\2\:Gb \13\:Gb) resistor r=45 c=0
Rx2 (\3\:Gbb \5\:Gbb) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx8 (\7\:Qint \11\:Qint) resistor r=45 c=0
Rx9 (\2\:Qint \14\:Qint) resistor r=45 c=0
Rx10 (\3\:Qbint \5\:Qbint) resistor r=45 c=0
mn1 (\6\:Gbb Gb \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.615e-14 ad=2.03e-14 ps=1.37e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.35e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn5 (net257 \3\:D \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.615e-14 ad=6.017e-14 ps=1.37e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.155e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn6 (\8\:n0 \4\:Gbb net257 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.017e-14 ad=2.32e-14 ps=1.12e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.95e-07 sb=6.95e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn16 (\8\:n0 \6\:Gb net245 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=4.9e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn15 (net245 Qint \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.035e-14 ad=8.7e-15 ps=1.44e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.105e-06 sb=3.85e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn10 (\15\:Qint n0 \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.035e-14 ad=2.755e-14 ps=1.44e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=1.9e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn0 (\8\:Gb \1\:G \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn22 (\3\:QN \9\:Qint \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.53365e-07 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn20 (\7\:Qbint \8\:Qint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn21 (\3\:Q \4\:Qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mp5 (net220 \1\:D \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=2.795e-14 ps=8.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.2e-07 sb=1.015e-06 sd=160n sca=11.9226 \
        scb=0.00878315 scc=8.35278e-05 m=(1)
mp10 (\17\:Qint \3\:n0 \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.43e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.295e-06 sb=1.4e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp6 (\6\:n0 \4\:Gb net220 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.795e-14 ad=5.483e-14 ps=6.9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=8.4e-07 sd=160n sca=10.8672 \
        scb=0.00773693 scc=8.06307e-05 m=(1)
mp16 (\6\:n0 Gbb net212 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.935e-14 ad=5.483e-14 ps=6.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=5.4e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp15 (net212 \3\:Qint \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=1.935e-14 ps=1.32e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=4.05e-07 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp0 (\14\:Gb \3\:G \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.47e-14 ad=4.085e-14 ps=1.34e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=4.65e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp22 (\1\:QN \10\:Qint \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.47e-14 ad=5.46e-14 ps=1.34e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.46731e-07 sb=1.4e-07 sd=160n sca=13.1056 \
        scb=0.0116857 scc=0.000556045 m=(1)
mp20 (\9\:Qbint \4\:Qint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.7e-07 sd=160n sca=24.5199 \
        scb=0.0210547 scc=0.00214754 m=(1)
mp21 (\1\:Q Qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.435e-14 ps=1.1e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.65e-07 sd=160n sca=32.5614 \
        scb=0.033721 scc=0.00305615 m=(1)
ends TLATX1
// End of subcircuit definition.

// Generated for: spectre (May  9 18:39:23 2012 )
// Library name: gsclib045
// Cell name: TLATX2
// View name: extracted

simulator lang=spectre

subckt TLATX2 D G Q QN VDD VSS
mp1 (\8\:Gbb Gb \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.22465e-06 sd=160n sca=19.2562 \
        scb=0.0208092 scc=0.000651488 m=(1)
C1 (QN VSS) capacitor c=5.03725e-17
C2 (D VSS) capacitor c=5.33724e-17
C3 (VDD VSS) capacitor c=2.48468e-16
C4 (Q VSS) capacitor c=2.3181e-17
C5 (Gb VSS) capacitor c=3.05e-17
C6 (Gbb VSS) capacitor c=6.83092e-17
C7 (net257 VSS) capacitor c=1.1738e-17
C8 (n0 VSS) capacitor c=5.69135e-17
C9 (Qint VSS) capacitor c=8.68989e-17
C10 (Qbint VSS) capacitor c=1.2283e-16
C11 (net220 VSS) capacitor c=6.81972e-19
C12 (net212 VSS) capacitor c=1.30876e-18
C13 (\4\:Qint VSS) capacitor c=1.09897e-16
C14 (\1\:G VSS) capacitor c=4.16926e-17
C15 (\3\:Qint VSS) capacitor c=4.71514e-17
C16 (\4\:Gb VSS) capacitor c=2.7461e-17
C17 (\1\:D VSS) capacitor c=5.00462e-17
C18 (\3\:G VSS) capacitor c=5.69025e-17
C19 (\4\:n0 VSS) capacitor c=3.6178e-17
C20 (\6\:Gb VSS) capacitor c=7.82384e-17
C21 (\4\:Gbb VSS) capacitor c=2.73538e-17
C22 (\3\:D VSS) capacitor c=2.77323e-17
C23 (\3\:Gb VSS) capacitor c=5.22149e-17
C24 (\10\:Qint VSS) capacitor c=3.28609e-17
C25 (\2\:G VSS) capacitor c=3.63785e-17
C26 (\3\:n0 VSS) capacitor c=1.63132e-17
C27 (\2\:Qint VSS) capacitor c=5.86565e-17
C28 (\7\:Gb VSS) capacitor c=2.93962e-17
C29 (\5\:Gb VSS) capacitor c=3.24707e-17
C30 (\3\:Gbb VSS) capacitor c=2.99325e-17
C31 (\2\:D VSS) capacitor c=4.58141e-17
C32 (\2\:Gb VSS) capacitor c=3.95287e-17
C33 (\1\:VDD VSS) capacitor c=2.83171e-16
C34 (\3\:Q VSS) capacitor c=7.98891e-17
C35 (\11\:Qbint VSS) capacitor c=8.55351e-17
C36 (\1\:QN VSS) capacitor c=9.09572e-17
C37 (\8\:Gb VSS) capacitor c=1.49649e-16
C38 (\20\:Qint VSS) capacitor c=5.74446e-17
C39 (\14\:VDD VSS) capacitor c=4.40693e-17
C40 (\7\:n0 VSS) capacitor c=7.99205e-17
C41 (\18\:VDD VSS) capacitor c=3.97847e-17
C42 (\8\:Gbb VSS) capacitor c=7.8154e-17
C43 (\4\:VDD VSS) capacitor c=8.93364e-17
C44 (\1\:Q VSS) capacitor c=1.27686e-17
C45 (\9\:Qbint VSS) capacitor c=1.66496e-17
C46 (\14\:Gb VSS) capacitor c=7.05154e-17
C47 (\22\:Qint VSS) capacitor c=1.8022e-17
C48 (\9\:n0 VSS) capacitor c=3.02261e-17
C49 (\6\:Gbb VSS) capacitor c=8.63528e-17
C50 (\2\:Gbb VSS) capacitor c=5.33844e-17
C51 (\2\:n0 VSS) capacitor c=1.63099e-17
C52 (\7\:Qint VSS) capacitor c=1.21042e-16
C53 (\4\:D VSS) capacitor c=6.72478e-17
C54 (\5\:Gbb VSS) capacitor c=8.56433e-17
C55 (\5\:n0 VSS) capacitor c=3.94868e-17
C56 (\6\:n0 VSS) capacitor c=7.38554e-17
C57 (\10\:Gb VSS) capacitor c=1.47372e-16
C58 (\11\:Gb VSS) capacitor c=1.15799e-16
C59 (\12\:Gb VSS) capacitor c=8.15241e-17
C60 (\13\:Gb VSS) capacitor c=1.26075e-16
C61 (\4\:G VSS) capacitor c=5.26168e-17
C62 (\6\:G VSS) capacitor c=3.20879e-17
C63 (\18\:Qint VSS) capacitor c=4.41853e-17
C64 (\19\:Qint VSS) capacitor c=4.82918e-17
C65 (\24\:Qint VSS) capacitor c=4.71567e-17
C66 (\7\:Qbint VSS) capacitor c=3.09215e-17
C67 (\8\:Qbint VSS) capacitor c=3.11089e-17
Rk12 (\4\:G \5\:G) resistor r=0.006478 c=0
Rk13 (G \6\:G) resistor r=0.00636 c=0
Rk14 (\4\:G \6\:G) resistor r=0.0219 c=0
Rk19 (\2\:QN QN) resistor r=0.4365 c=0
Rk20 (QN \4\:QN) resistor r=0.002997 c=0
Rk1 (D \4\:D) resistor r=0.08353 c=0
Rk32 (\1\:VDD \13\:VDD) resistor r=0.3631 c=0
Rk33 (\13\:VDD \15\:VDD) resistor r=0.1836 c=0
Rk34 (\13\:VDD \16\:VDD) resistor r=0.2304 c=0
Rk35 (\16\:VDD \17\:VDD) resistor r=0.2705 c=0
Rk36 (\17\:VDD \19\:VDD) resistor r=0.1878 c=0
Rk38 (\20\:VDD VDD) resistor r=0.04988 c=0
Rk37 (\17\:VDD \20\:VDD) resistor r=0.08001 c=0
Rk24 (Q \2\:Q) resistor r=0.0869 c=0
Rk25 (Q \4\:Q) resistor r=0.2667 c=0
Rk43 (\1\:VSS \8\:VSS) resistor r=0.1602 c=0
Rk44 (\8\:VSS \9\:VSS) resistor r=0.1828 c=0
Rk45 (\9\:VSS \10\:VSS) resistor r=0.2179 c=0
Rk46 (\10\:VSS \11\:VSS) resistor r=0.2545 c=0
Rk48 (\12\:VSS VSS) resistor r=0.04988 c=0
Rk47 (\11\:VSS \12\:VSS) resistor r=0.0941 c=0
Rk52 (\9\:VSS \20\:VSS) resistor r=0.07358 c=0
Rk53 (\11\:VSS \22\:VSS) resistor r=0.04328 c=0
Rk7 (\9\:Gb \10\:Gb) resistor r=1.1645 c=0
Rk8 (\10\:Gb \11\:Gb) resistor r=0.1406 c=0
Rk9 (\10\:Gb \12\:Gb) resistor r=0.4187 c=0
Rk10 (\11\:Gb \13\:Gb) resistor r=0.711 c=0
Rk11 (\13\:Gb \15\:Gb) resistor r=0.58 c=0
Rk2 (\5\:Gbb \7\:Gbb) resistor r=0.5023 c=0
Rk3 (\7\:Gbb \9\:Gbb) resistor r=0.628 c=0
Rk4 (\5\:n0 \6\:n0) resistor r=0.2717 c=0
Rk5 (\6\:n0 \8\:n0) resistor r=0.4582 c=0
Rk6 (\6\:n0 \10\:n0) resistor r=0.12 c=0
Rk15 (\18\:Qint \19\:Qint) resistor r=0.2992 c=0
Rk16 (\19\:Qint \21\:Qint) resistor r=0.2773 c=0
Rk17 (\19\:Qint \23\:Qint) resistor r=0.06732 c=0
Rk18 (\21\:Qint \24\:Qint) resistor r=0.2773 c=0
Rk21 (\7\:Qbint \8\:Qbint) resistor r=0.2506 c=0
Rk22 (\8\:Qbint \10\:Qbint) resistor r=0.1172 c=0
Rk23 (\8\:Qbint \12\:Qbint) resistor r=0.3113 c=0
Rl15 (\1\:G \2\:G) resistor r=29.5379 c=0
Rl16 (\2\:G \3\:G) resistor r=138.441 c=0
Rl3 (\1\:D \2\:D) resistor r=171.846 c=0
Rl4 (\2\:D \3\:D) resistor r=29.5379 c=0
Rl9 (\6\:Gb \7\:Gb) resistor r=77.6148 c=0
Rl5 (\4\:Gb \5\:Gb) resistor r=71.8456 c=0
Rl1 (Gb \2\:Gb) resistor r=29.5379 c=0
Rl2 (\2\:Gb \3\:Gb) resistor r=171.846 c=0
Rl6 (Gbb \2\:Gbb) resistor r=205.747 c=0
Rl8 (\2\:Gbb \4\:Gbb) resistor r=41.9892 c=0
Rl7 (\2\:Gbb \3\:Gbb) resistor r=80.6945 c=0
Rl12 (n0 \2\:n0) resistor r=84.3295 c=0
Rl14 (\2\:n0 \4\:n0) resistor r=34.3295 c=0
Rl13 (\2\:n0 \3\:n0) resistor r=1.2666 c=0
Rl10 (\2\:Qint Qint) resistor r=138.462 c=0
Rl11 (\2\:Qint \3\:Qint) resistor r=64.5604 c=0
Rl19 (\7\:Qint \4\:Qint) resistor r=72.348 c=0
Rl22 (\7\:Qint \10\:Qint) resistor r=2.9588 c=0
Rz5 (\4\:QN \3\:QN) resistor r=75 c=0
Rz8 (\1\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz9 (\16\:VDD \4\:VDD) resistor r=15 c=0
Rz10 (\20\:VDD \4\:VDD) resistor r=37.5 c=0
Rz7 (\2\:Q \1\:Q) resistor r=75 c=0
Rz15 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz16 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz3 (\14\:Gb \15\:Gb) resistor r=75 c=0
Rz1 (\6\:Gbb \7\:Gbb) resistor r=75 c=0
Rz2 (\9\:n0 \10\:n0) resistor r=75 c=0
Rz4 (\23\:Qint \22\:Qint) resistor r=75 c=0
Rz6 (\10\:Qbint \9\:Qbint) resistor r=75 c=0
Ry5 (\2\:QN \1\:QN) resistor r=20.6667 c=0
Ry12 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry13 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry7 (\4\:Q \3\:Q) resistor r=20.6667 c=0
Ry14 (\1\:VSS \4\:VSS) resistor r=7.75 c=0
Ry15 (\8\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry16 (\10\:VSS \4\:VSS) resistor r=12.4 c=0
Ry17 (\12\:VSS \4\:VSS) resistor r=31 c=0
Ry3 (\8\:Gb \9\:Gb) resistor r=62 c=0
Ry1 (\8\:Gbb \9\:Gbb) resistor r=62 c=0
Ry2 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry4 (\21\:Qint \20\:Qint) resistor r=62 c=0
Ry6 (\12\:Qbint \11\:Qbint) resistor r=20.6667 c=0
Rx7 (\2\:G \5\:G) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\5\:Gb \11\:Gb) resistor r=45 c=0
Rx5 (\2\:Gb \12\:Gb) resistor r=45 c=0
Rx6 (\7\:Gb \13\:Gb) resistor r=45 c=0
Rx2 (\3\:Gbb \5\:Gbb) resistor r=45 c=0
Rx3 (\3\:n0 \5\:n0) resistor r=45 c=0
Rx8 (\18\:Qint \10\:Qint) resistor r=45 c=0
Rx9 (\24\:Qint \2\:Qint) resistor r=45 c=0
Rx10 (\7\:Qbint Qbint) resistor r=45 c=0
mn1 (\6\:Gbb \3\:Gb \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.335e-14 ad=2.03e-14 ps=1.62e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.435e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn5 (net257 \3\:D \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.335e-14 ad=6.67e-14 ps=1.62e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.23e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn6 (\9\:n0 \4\:Gbb net257 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.67e-14 ad=2.32e-14 ps=1.21e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=7.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn16 (\9\:n0 \6\:Gb net245 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.055e-06 sb=5.2e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn15 (net245 Qint \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.575e-14 ad=8.7e-15 ps=1.71e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16e-06 sb=4.15e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn10 (\22\:Qint \4\:n0 \19\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.575e-14 ad=3.485e-14 ps=1.71e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03768e-06 sb=1.7e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn0 (\14\:Gb \3\:G \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.365e-14 ad=2.03e-14 ps=1.44e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn22 (\3\:QN \7\:Qint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.763e-14 ad=5.07e-14 ps=1.14e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.31058e-07 sb=1.38e-06 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(2)
mn20 (\9\:Qbint \4\:Qint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.85e-14 ad=4.16e-14 ps=9.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.76058e-07 sb=9.35e-07 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(2)
mn21 (\1\:Q Qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=5.46e-14 ps=9.5e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21606e-06 sb=3.95e-07 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(2)
mp5 (net220 \1\:D \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.805e-14 ps=7.5e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.01965e-06 sd=160n sca=12.9559 \
        scb=0.0103241 scc=9.95448e-05 m=(1)
mp6 (\7\:n0 \4\:Gb net220 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.805e-14 ad=5.267e-14 ps=9.7e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=7.04651e-07 sd=160n sca=10.7129 \
        scb=0.00769258 scc=8.40492e-05 m=(1)
mp16 (\7\:n0 Gbb net212 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.365e-14 ad=5.268e-14 ps=6.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.5e-07 sb=4.14651e-07 sd=160n sca=10.2431 \
        scb=0.00753556 scc=8.40048e-05 m=(1)
mp15 (net212 \3\:Qint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.258e-14 ad=2.365e-14 ps=1.46e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.105e-06 sb=2.59651e-07 sd=160n sca=10.2431 \
        scb=0.00753556 scc=8.40048e-05 m=(1)
mp10 (\20\:Qint n0 \14\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.258e-14 ad=4.34e-14 ps=1.46e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.10484e-07 sb=1.4e-07 sd=160n sca=16.415 \
        scb=0.0153923 scc=0.00118075 m=(1)
mp0 (\8\:Gb \1\:G \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.55e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp22 (\1\:QN \7\:Qint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.715e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=1.345e-06 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(2)
mp20 (\11\:Qbint \4\:Qint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=8.775e-14 ad=6.24e-14 ps=1.23e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.45064e-07 sb=9.35e-07 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(2)
mp21 (\3\:Q Qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.385e-14 ad=8.19e-14 ps=1.21e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.18506e-06 sb=3.95e-07 sd=160n sca=28.4121 \
        scb=0.0218393 scc=0.00279381 m=(2)
ends TLATX2
// End of subcircuit definition.

// Generated for: spectre (May  9 18:40:03 2012 )
// Library name: gsclib045
// Cell name: TLATX4
// View name: extracted

simulator lang=spectre

subckt TLATX4 D G Q QN VDD VSS
mp0 (\11\:Gb \1\:G \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=27.7871 scb=0.0280637 \
        scc=0.00253496 m=(1)
C1 (D VSS) capacitor c=6.72675e-17
C2 (QN VSS) capacitor c=1.78373e-16
C3 (Q VSS) capacitor c=2.01567e-17
C4 (G VSS) capacitor c=4.15743e-17
C5 (VDD VSS) capacitor c=2.22151e-16
C6 (Gb VSS) capacitor c=6.40064e-17
C7 (Qbint VSS) capacitor c=2.93716e-16
C8 (Qint VSS) capacitor c=2.29979e-16
C9 (n0 VSS) capacitor c=9.62192e-17
C10 (net245 VSS) capacitor c=2.5911e-18
C11 (Gbb VSS) capacitor c=4.12002e-17
C12 (net212 VSS) capacitor c=2.32894e-18
C13 (net220 VSS) capacitor c=1.95947e-20
C14 (\4\:Gb VSS) capacitor c=4.4804e-17
C15 (\1\:D VSS) capacitor c=3.12337e-17
C16 (\2\:Gbb VSS) capacitor c=3.94401e-17
C17 (\33\:Qint VSS) capacitor c=4.84258e-17
C18 (\1\:G VSS) capacitor c=4.07123e-17
C19 (\5\:Gb VSS) capacitor c=3.45514e-17
C20 (\3\:D VSS) capacitor c=6.94148e-17
C21 (\3\:Gbb VSS) capacitor c=7.16709e-17
C22 (\2\:Gb VSS) capacitor c=5.79922e-17
C23 (\31\:Qint VSS) capacitor c=5.31113e-17
C24 (\3\:G VSS) capacitor c=3.0023e-17
C25 (\6\:Gb VSS) capacitor c=2.02909e-17
C26 (\2\:D VSS) capacitor c=4.46101e-17
C27 (\4\:Gbb VSS) capacitor c=4.17688e-17
C28 (\3\:Gb VSS) capacitor c=2.72008e-17
C29 (\32\:Qint VSS) capacitor c=5.24831e-17
C30 (\2\:G VSS) capacitor c=3.74565e-17
C31 (\5\:Gbb VSS) capacitor c=4.28352e-17
C32 (\1\:VDD VSS) capacitor c=2.23043e-17
C33 (\12\:n0 VSS) capacitor c=2.34123e-17
C34 (\40\:Qint VSS) capacitor c=7.87474e-17
C35 (\1\:Q VSS) capacitor c=1.72227e-16
C36 (\11\:Gb VSS) capacitor c=6.51222e-17
C37 (\3\:VDD VSS) capacitor c=5.44179e-17
C38 (\9\:Gbb VSS) capacitor c=1.04976e-17
C39 (\8\:n0 VSS) capacitor c=1.13907e-16
C40 (\38\:Qint VSS) capacitor c=3.25647e-17
C41 (\1\:QN VSS) capacitor c=1.11813e-16
C42 (\15\:Qbint VSS) capacitor c=8.61149e-17
C43 (\9\:Gb VSS) capacitor c=3.76157e-16
C44 (\9\:Qint VSS) capacitor c=2.41446e-16
C45 (\3\:n0 VSS) capacitor c=1.10711e-16
C46 (\4\:G VSS) capacitor c=7.02761e-17
C47 (\4\:Q VSS) capacitor c=1.14391e-16
C48 (\19\:Qbint VSS) capacitor c=2.81794e-17
C49 (\20\:Qbint VSS) capacitor c=4.17482e-17
C50 (\21\:Qbint VSS) capacitor c=1.62389e-16
C51 (\34\:Qint VSS) capacitor c=4.04681e-17
C52 (\35\:Qint VSS) capacitor c=2.63203e-17
C53 (\36\:Qint VSS) capacitor c=3.05943e-17
C54 (\37\:Qint VSS) capacitor c=3.25808e-17
C55 (\10\:n0 VSS) capacitor c=8.91041e-17
C56 (\11\:n0 VSS) capacitor c=6.15934e-17
C57 (\4\:D VSS) capacitor c=3.30082e-17
C58 (\7\:Gb VSS) capacitor c=6.26602e-17
C59 (\8\:Gb VSS) capacitor c=3.54825e-16
C60 (\7\:Gbb VSS) capacitor c=6.31006e-17
C61 (\8\:Gbb VSS) capacitor c=7.75566e-17
C62 (\11\:Gbb VSS) capacitor c=6.89627e-17
C63 (\5\:VDD VSS) capacitor c=6.3211e-16
Rk27 (\4\:D D) resistor r=0.1037 c=0
Rk15 (\1\:QN QN) resistor r=0.3271 c=0
Rk3 (\1\:Q Q) resistor r=0.08889 c=0
Rk4 (Q \4\:Q) resistor r=0.1839 c=0
Rk1 (G \4\:G) resistor r=0.102 c=0
Rk59 (\2\:VDD \4\:VDD) resistor r=0.425 c=0
Rk70 (\5\:VDD VDD) resistor r=0.1926 c=0
Rk60 (\4\:VDD \5\:VDD) resistor r=0.3583 c=0
Rk35 (\2\:VSS \3\:VSS) resistor r=0.1151 c=0
Rk36 (\3\:VSS \4\:VSS) resistor r=0.1352 c=0
Rk48 (\5\:VSS VSS) resistor r=0.07476 c=0
Rk37 (\4\:VSS \5\:VSS) resistor r=0.1953 c=0
Rk50 (\3\:VSS \18\:VSS) resistor r=0.07369 c=0
Rk28 (\7\:Gb \8\:Gb) resistor r=0.4264 c=0
Rk29 (\8\:Gb \10\:Gb) resistor r=2.8726 c=0
Rk30 (\10\:Gb \12\:Gb) resistor r=0.5018 c=0
Rk9 (\15\:Qbint \19\:Qbint) resistor r=0.1474 c=0
Rk10 (\19\:Qbint \20\:Qbint) resistor r=0.2543 c=0
Rk11 (\19\:Qbint \21\:Qbint) resistor r=0.2081 c=0
Rk19 (\34\:Qint \35\:Qint) resistor r=0.1369 c=0
Rk20 (\35\:Qint \36\:Qint) resistor r=0.1652 c=0
Rk21 (\36\:Qint \37\:Qint) resistor r=0.236 c=0
Rk22 (\35\:Qint \39\:Qint) resistor r=0.1377 c=0
Rk23 (\36\:Qint \41\:Qint) resistor r=0.3038 c=0
Rk24 (\9\:n0 \10\:n0) resistor r=0.6268 c=0
Rk25 (\10\:n0 \11\:n0) resistor r=0.2602 c=0
Rk26 (\10\:n0 \13\:n0) resistor r=0.1996 c=0
Rk31 (\6\:Gbb \7\:Gbb) resistor r=0.3443 c=0
Rk32 (\7\:Gbb \8\:Gbb) resistor r=0.3885 c=0
Rk33 (\7\:Gbb \10\:Gbb) resistor r=0.09609 c=0
Rk34 (\8\:Gbb \11\:Gbb) resistor r=0.3443 c=0
Rl57 (\1\:D \2\:D) resistor r=71.8456 c=0
Rl58 (\2\:D \3\:D) resistor r=89.1533 c=0
Rl1 (\1\:G \2\:G) resistor r=94.5242 c=0
Rl2 (\2\:G \3\:G) resistor r=22.4021 c=0
Rl59 (\4\:Gb \5\:Gb) resistor r=186.538 c=0
Rl54 (Gb \2\:Gb) resistor r=186.104 c=0
Rl60 (\5\:Gb \6\:Gb) resistor r=29.5379 c=0
Rl55 (\2\:Gb \3\:Gb) resistor r=24.2328 c=0
Rl52 (\32\:Qint \33\:Qint) resistor r=83.8482 c=0
Rl51 (\32\:Qint \31\:Qint) resistor r=116.862 c=0
Rl23 (\9\:Qint Qint) resistor r=52.3132 c=0
Rl46 (\3\:n0 n0) resistor r=94.8893 c=0
Rl50 (\3\:n0 \7\:n0) resistor r=3.8088 c=0
Rl53 (Gbb \2\:Gbb) resistor r=57.6695 c=0
Rl56 (\3\:Gbb \4\:Gbb) resistor r=29.5379 c=0
Rz20 (\4\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz21 (\5\:VDD \3\:VDD) resistor r=4.4118 c=0
Rz11 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz9 (\9\:Gb \10\:Gb) resistor r=75 c=0
Rz7 (\39\:Qint \38\:Qint) resistor r=75 c=0
Rz8 (\9\:n0 \8\:n0) resistor r=75 c=0
Rz10 (\9\:Gbb \10\:Gbb) resistor r=75 c=0
Ry17 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (VSS \1\:VSS) resistor r=62 c=0
Ry11 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry12 (\4\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry15 (\5\:VSS \1\:VSS) resistor r=3.4444 c=0
Ry9 (\11\:Gb \12\:Gb) resistor r=62 c=0
Ry7 (\41\:Qint \40\:Qint) resistor r=31 c=0
Ry8 (\13\:n0 \12\:n0) resistor r=62 c=0
Ry10 (\5\:Gbb \6\:Gbb) resistor r=62 c=0
Rx6 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:G \4\:G) resistor r=45 c=0
Rx7 (\6\:Gb \7\:Gb) resistor r=45 c=0
Rx8 (\3\:Gb \8\:Gb) resistor r=45 c=0
Rx2 (\20\:Qbint Qbint) resistor r=45 c=0
Rx3 (\34\:Qint \32\:Qint) resistor r=45 c=0
Rx4 (\37\:Qint Qint) resistor r=45 c=0
Rx5 (\11\:n0 \7\:n0) resistor r=45 c=0
Rx9 (\4\:Gbb \8\:Gbb) resistor r=45 c=0
Rx10 (Gbb \11\:Gbb) resistor r=45 c=0
mn0 (\9\:Gb \3\:G \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.41e-14 ad=2.61e-14 ps=1.62e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=2e-06 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn21_1__rcx (\4\:Q Qbint \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.097e-14 ad=4.16e-14 ps=1.4925e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.53365e-07 sb=2e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(4)
mn20_1__rcx (\15\:Qbint \9\:Qint \5\:VSS VSS) g45n1svt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=8.66e-14 ad=4.16e-14 ps=1.45e-06 pd=8.4e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.19337e-06 sb=1.95452e-06 sd=160n \
        sca=11.3041 scb=0.010759 scc=0.000493236 m=(4)
mn22_1__rcx (\1\:QN Qint \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.591e-14 ad=4.16e-14 ps=1.45e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.99115e-06 sb=1.58144e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(4)
mn10_1__rcx (\38\:Qint n0 \5\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.26e-14 ad=3.28e-14 ps=1.535e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.11488e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(2)
mn15 (net245 \31\:Qint \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.135e-14 ad=2.827e-14 ps=1.62e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.05e-06 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn16 (\8\:n0 \2\:Gb net245 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.827e-14 ad=2.32e-14 ps=6.8e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.1e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn6 (\8\:n0 \3\:Gbb net257 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.05e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn5 (net257 \3\:D \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.945e-14 ad=8.7e-15 ps=1.51e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn1 (\9\:Gbb \5\:Gb \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.945e-14 ad=2.972e-14 ps=1.51e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.05e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mp21_1__rcx (\1\:Q Qbint \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.314e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=2e-06 sd=160n sca=18.6696 \
        scb=0.0162362 scc=0.00138051 m=(4)
mp20_1__rcx (\21\:Qbint \9\:Qint \5\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.08955e-06 sb=1.90673e-06 sd=160n \
        sca=17.2385 scb=0.0152696 scc=0.00137893 m=(4)
mp22_1__rcx (QN Qint \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.432e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.90128e-06 sb=1.53878e-06 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(4)
mp10_1__rcx (\40\:Qint \3\:n0 \5\:VDD VDD) g45p1svt w=(3.1e-07) \
        l=4.5e-08 nf=1 as=6.453e-14 ad=4.96e-14 ps=1.12e-06 pd=9.4e-07 \
        nrd=1.16667 nrs=1.16667 sa=2e-06 sb=1.22395e-06 sd=160n \
        sca=12.9031 scb=0.0116454 scc=0.000496931 m=(2)
mp15 (net212 \33\:Qint \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.895e-14 ad=2.795e-14 ps=1.08e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.15e-06 sd=160n sca=12.9303 scb=0.0120133 \
        scc=0.000461649 m=(1)
mp16 (\12\:n0 \2\:Gbb net212 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.795e-14 ad=4.192e-14 ps=6.9e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.75e-07 sd=160n sca=12.9303 scb=0.0120133 \
        scc=0.000461649 m=(1)
mp6 (\12\:n0 Gb net220 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=4.192e-14 ps=8.7e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.35e-07 sd=160n sca=13.2438 scb=0.0121009 \
        scc=0.000461666 m=(1)
mp5 (net220 \1\:D \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.375e-14 ad=4.73e-14 ps=9.3e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.7e-07 sd=160n sca=14.5574 scb=0.0132152 \
        scc=0.000464156 m=(1)
mp1 (\5\:Gbb \4\:Gb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.375e-14 ad=3.762e-14 ps=9.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.75e-07 sd=160n sca=21.3411 scb=0.0244017 \
        scc=0.000941054 m=(1)
ends TLATX4
// End of subcircuit definition.

// Generated for: spectre (May  9 18:40:44 2012 )
// Library name: gsclib045
// Cell name: TLATXL
// View name: extracted

simulator lang=spectre

subckt TLATXL D G Q QN VDD VSS
mp1 (\8\:Gbb Gb \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.655e-14 ps=7.7e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.275e-06 sd=160n sca=16.8928 \
        scb=0.0171325 scc=0.000344283 m=(1)
C1 (G VSS) capacitor c=4.85459e-17
C2 (QN VSS) capacitor c=6.70965e-17
C3 (D VSS) capacitor c=1.17466e-16
C4 (VDD VSS) capacitor c=2.16477e-16
C5 (Q VSS) capacitor c=2.28002e-17
C6 (Gb VSS) capacitor c=2.73682e-17
C7 (Gbb VSS) capacitor c=7.18912e-17
C8 (net257 VSS) capacitor c=1.11172e-17
C9 (n0 VSS) capacitor c=3.4237e-17
C10 (Qint VSS) capacitor c=8.80693e-17
C11 (Qbint VSS) capacitor c=3.06083e-17
C12 (net212 VSS) capacitor c=1.45695e-18
C13 (\4\:Qbint VSS) capacitor c=2.79412e-17
C14 (\8\:Qint VSS) capacitor c=3.66042e-17
C15 (\10\:Qint VSS) capacitor c=6.73558e-17
C16 (\3\:G VSS) capacitor c=3.2637e-17
C17 (\3\:n0 VSS) capacitor c=6.31996e-17
C18 (\3\:Qint VSS) capacitor c=6.34597e-17
C19 (\4\:Gb VSS) capacitor c=3.12023e-17
C20 (\1\:D VSS) capacitor c=5.11118e-17
C21 (\4\:Qint VSS) capacitor c=2.04051e-17
C22 (\9\:Qint VSS) capacitor c=2.49989e-17
C23 (\1\:G VSS) capacitor c=6.9761e-17
C24 (\6\:Gb VSS) capacitor c=7.86113e-17
C25 (\4\:Gbb VSS) capacitor c=3.24438e-17
C26 (\3\:D VSS) capacitor c=4.1416e-17
C27 (\3\:Gb VSS) capacitor c=4.93283e-17
C28 (\3\:Qbint VSS) capacitor c=2.14971e-17
C29 (\7\:Qint VSS) capacitor c=5.698e-17
C30 (\2\:G VSS) capacitor c=7.22274e-17
C31 (\2\:n0 VSS) capacitor c=6.26144e-17
C32 (\2\:Qint VSS) capacitor c=8.08896e-17
C33 (\7\:Gb VSS) capacitor c=3.86991e-17
C34 (\5\:Gb VSS) capacitor c=3.45758e-17
C35 (\3\:Gbb VSS) capacitor c=2.64775e-17
C36 (\2\:D VSS) capacitor c=4.8545e-17
C37 (\2\:Gb VSS) capacitor c=4.74552e-17
