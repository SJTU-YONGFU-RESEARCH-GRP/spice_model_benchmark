Rk4 (\4\:B B) resistor r=0.004054 c=0
Rk3 (A \4\:A) resistor r=0.03639 c=0
Rk2 (\13\:S0 S0) resistor r=0.08435 c=0
Rk1 (\12\:S0 \13\:S0) resistor r=0.2795 c=0
Rk13 (\14\:S0 \15\:S0) resistor r=0.04804 c=0
Rk14 (\15\:S0 \16\:S0) resistor r=0.3039 c=0
Rk15 (\15\:S0 \17\:S0) resistor r=0.6578 c=0
Rk32 (\2\:VDD \3\:VDD) resistor r=0.09261 c=0
Rk35 (\3\:VDD \6\:VDD) resistor r=0.371 c=0
Rk36 (\6\:VDD \7\:VDD) resistor r=0.3525 c=0
Rk37 (\7\:VDD \8\:VDD) resistor r=0.3977 c=0
Rk38 (\8\:VDD \9\:VDD) resistor r=0.4112 c=0
Rk39 (\9\:VDD \10\:VDD) resistor r=0.3409 c=0
Rk41 (\11\:VDD VDD) resistor r=0.1776 c=0
Rk40 (\10\:VDD \11\:VDD) resistor r=0.1227 c=0
Rk44 (\7\:VDD \17\:VDD) resistor r=0.04332 c=0
Rk45 (\9\:VDD \19\:VDD) resistor r=0.07405 c=0
Rk46 (\11\:VDD \21\:VDD) resistor r=0.2547 c=0
Rk5 (\12\:S0b \13\:S0b) resistor r=0.5985 c=0
Rk6 (\13\:S0b \14\:S0b) resistor r=0.2057 c=0
Rk7 (\14\:S0b \16\:S0b) resistor r=0.5189 c=0
Rk8 (\13\:S0b \17\:S0b) resistor r=0.4804 c=0
Rk9 (\14\:S0b \18\:S0b) resistor r=0.05533 c=0
Rk10 (\16\:S0b \20\:S0b) resistor r=0.5874 c=0
Rk12 (\21\:S0b \22\:S0b) resistor r=0.2283 c=0
Rk16 (\23\:S0b \24\:S0b) resistor r=0.1685 c=0
Rk18 (\4\:n0 \6\:n0) resistor r=2.2175 c=0
Rk19 (\6\:n0 \8\:n0) resistor r=0.5216 c=0
Rk20 (\5\:n1 \6\:n1) resistor r=0.742 c=0
Rk21 (\6\:n1 \8\:n1) resistor r=0.2571 c=0
Rk22 (\6\:n1 \9\:n1) resistor r=1.2301 c=0
Rk23 (\9\:n2 \11\:n2) resistor r=0.8101 c=0
Rk24 (\12\:n2 \14\:n2) resistor r=1.0663 c=0
Rk29 (\6\:S1b \8\:S1b) resistor r=0.3648 c=0
Rk30 (\8\:S1b \9\:S1b) resistor r=1.7769 c=0
Rk31 (\9\:S1b \10\:S1b) resistor r=0.3459 c=0
Rl38 (\5\:S1 \6\:S1) resistor r=24.7951 c=0
Rl37 (\4\:S1 \5\:S1) resistor r=37.8119 c=0
Rl26 (\2\:S1 \3\:S1) resistor r=27.9704 c=0
Rl25 (\1\:S1 \2\:S1) resistor r=101.282 c=0
Rl12 (\1\:C \2\:C) resistor r=30.7692 c=0
Rl13 (\2\:C \3\:C) resistor r=176.099 c=0
Rl20 (\1\:D \2\:D) resistor r=100.692 c=0
Rl21 (\2\:D \3\:D) resistor r=104.538 c=0
Rl11 (\2\:B \3\:B) resistor r=26.3736 c=0
Rl10 (\1\:B \2\:B) resistor r=180.769 c=0
Rl3 (\1\:A \2\:A) resistor r=45.3867 c=0
Rl4 (\2\:A \3\:A) resistor r=156.925 c=0
Rl18 (\10\:S0 \11\:S0) resistor r=93.4636 c=0
Rl16 (\8\:S0 \9\:S0) resistor r=71.8456 c=0
Rl7 (\4\:S0 \5\:S0) resistor r=83.8482 c=0
Rl9 (\6\:S0 \7\:S0) resistor r=118.464 c=0
Rl8 (\5\:S0 \6\:S0) resistor r=150.528 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=155.769 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=39.1379 c=0
Rl19 (\10\:S0b \11\:S0b) resistor r=24.2328 c=0
Rl17 (\8\:S0b \9\:S0b) resistor r=122.246 c=0
Rl14 (\5\:S0b \6\:S0b) resistor r=33.8482 c=0
Rl15 (\6\:S0b \7\:S0b) resistor r=43.4636 c=0
Rl6 (\3\:S0b \4\:S0b) resistor r=56.9251 c=0
Rl5 (S0b \2\:S0b) resistor r=66.5405 c=0
Rl22 (n0 \2\:n0) resistor r=29.5379 c=0
Rl23 (\2\:n0 \3\:n0) resistor r=104.538 c=0
Rl28 (n1 \2\:n1) resistor r=106.925 c=0
Rl29 (\2\:n1 \3\:n1) resistor r=78.4003 c=0
Rl35 (\7\:n2 n2) resistor r=46.5267 c=0
Rl27 (\3\:S1b \4\:S1b) resistor r=42.9995 c=0
Rl24 (S1b \2\:S1b) resistor r=28.0211 c=0
Rz5 (\4\:Y \3\:Y) resistor r=75 c=0
Rz14 (\17\:VSS \16\:VSS) resistor r=37.5 c=0
Rz15 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz16 (\21\:VSS \20\:VSS) resistor r=37.5 c=0
Rz7 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz8 (\3\:VDD \1\:VDD) resistor r=25 c=0
Rz9 (\6\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz10 (\8\:VDD \1\:VDD) resistor r=9.375 c=0
Rz11 (\10\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz1 (\15\:S0b \16\:S0b) resistor r=75 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz3 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz4 (\11\:n2 \10\:n2) resistor r=75 c=0
Rz6 (\7\:S1b \8\:S1b) resistor r=75 c=0
Ry5 (\2\:Y \1\:Y) resistor r=62 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry13 (\5\:VSS \1\:VSS) resistor r=6.2 c=0
Ry14 (\7\:VSS \1\:VSS) resistor r=7.75 c=0
Ry15 (\9\:VSS \1\:VSS) resistor r=12.4 c=0
Ry16 (\11\:VSS \1\:VSS) resistor r=31 c=0
Ry9 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry10 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry11 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry1 (\19\:S0b \20\:S0b) resistor r=62 c=0
Ry2 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry3 (\4\:n1 \5\:n1) resistor r=62 c=0
Ry4 (\14\:n2 \13\:n2) resistor r=62 c=0
Ry6 (\5\:S1b \6\:S1b) resistor r=62 c=0
Rx21 (\5\:S1 \7\:S1) resistor r=45 c=0
Rx22 (\2\:S1 \8\:S1) resistor r=45 c=0
Rx8 (\2\:C \4\:C) resistor r=45 c=0
Rx16 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:B \4\:B) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\6\:S0 \12\:S0) resistor r=45 c=0
Rx2 (\2\:S0 \13\:S0) resistor r=45 c=0
Rx11 (\9\:S0 \14\:S0) resistor r=45 c=0
Rx12 (\11\:S0 \16\:S0) resistor r=45 c=0
Rx13 (\5\:S0 \17\:S0) resistor r=45 c=0
Rx5 (\7\:S0b \12\:S0b) resistor r=45 c=0
Rx6 (\4\:S0b \17\:S0b) resistor r=45 c=0
Rx7 (\2\:S0b \18\:S0b) resistor r=45 c=0
Rx9 (\9\:S0b \21\:S0b) resistor r=45 c=0
Rx10 (\5\:S0b \22\:S0b) resistor r=45 c=0
Rx14 (\11\:S0b \23\:S0b) resistor r=45 c=0
Rx15 (\8\:S0b \24\:S0b) resistor r=45 c=0
Rx17 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx18 (\2\:n1 \9\:n1) resistor r=45 c=0
Rx19 (\9\:n2 \7\:n2) resistor r=45 c=0
Rx20 (\12\:n2 n2) resistor r=45 c=0
Rx23 (\4\:S1b \9\:S1b) resistor r=45 c=0
Rx24 (\2\:S1b \10\:S1b) resistor r=45 c=0
mn0 (\15\:S0b \3\:S0 \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=2.03e-14 ps=1.43e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.6069e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn2 (net349 \3\:A \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=8.7e-15 ps=1.43e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.56379e-07 sb=2e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn3 (\7\:n0 S0b net349 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=6.307e-14 ps=4.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.61379e-07 sb=2e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn5 (\7\:n0 \4\:S0 net361 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=6.307e-14 ps=5.6e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.41379e-07 sb=2e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn4 (net361 \1\:B \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.045e-14 ad=1.957e-14 ps=1.51e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12138e-06 sb=2e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn6 (net369 \3\:C \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.045e-14 ad=1.957e-14 ps=1.51e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45638e-06 sb=2e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn7 (\7\:n1 \6\:S0b net369 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=8.337e-14 ps=5.6e-07 pd=1.44e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.63638e-06 sb=2e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn9 (\7\:n1 \10\:S0 net377 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.22e-14 ad=8.337e-14 ps=1.01e-06 pd=1.44e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn8 (net377 \3\:D \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.03e-14 ad=5.22e-14 ps=1.37e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn12 (net345 \3\:n1 \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.0648e-13 ad=4.35e-14 ps=1.83e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.23862e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn10 (net329 \3\:n0 \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.03e-14 ad=2.03e-14 ps=1.37e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.94052e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn11 (\10\:n2 S1b net329 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.78862e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn13 (\10\:n2 \1\:S1 net345 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.35e-14 ad=2.32e-14 ps=8.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.58362e-06 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn14 (\3\:Y n2 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.1311e-13 ad=4.16e-14 ps=1.83e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15962e-06 sb=6.21058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn1 (\7\:S1b \4\:S1 \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.1975e-13 ad=2.03e-14 ps=1.83e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.57069e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp2 (net296 \1\:A \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=12.3871 \
        scb=0.00967424 scc=0.000140878 m=(1)
mp3 (\5\:n0 \7\:S0 net296 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=7.525e-14 ps=5.5e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=11.6786 scb=0.00891131 \
        scc=0.000138523 m=(1)
mp5 (\5\:n0 \3\:S0b net304 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=7.525e-14 ps=7.2e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=1.91826e-06 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp4 (net304 \3\:B \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.227e-13 ad=3.117e-14 ps=1.81e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.75477e-06 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp6 (net312 \1\:C \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.227e-13 ad=6.88e-14 ps=1.81e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-06 sb=1.35465e-06 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp7 (\4\:n1 \8\:S0 net312 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.88e-14 ad=9.783e-14 ps=1.07e-06 pd=1.34e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.865e-06 sb=1.04058e-06 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp9 (\4\:n1 \10\:S0b net320 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=9.782e-14 ps=9.1e-07 pd=1.34e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.10349e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp8 (net320 \1\:D \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.845e-14 ad=5.16e-14 ps=1.92e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.65116e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp10 (net280 n0 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.845e-14 ad=4.73e-14 ps=1.92e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25349e-07 sb=1.96291e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp11 (\13\:n2 \3\:S1 net280 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=5.268e-14 ps=8.7e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.53372e-07 sb=1.76488e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp13 (\13\:n2 \3\:S1b net284 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=5.267e-14 ps=9.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.02907e-07 sb=1.47488e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp12 (net284 n1 \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.6305e-13 ad=5.16e-14 ps=2.71e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.14814e-06 sb=1.18988e-06 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp14 (\1\:Y n2 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.3945e-13 ad=6.24e-14 ps=2.405e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.64808e-07 sb=5.39551e-07 sd=160n sca=29.0159 \
        scb=0.0199093 scc=0.0031585 m=(2)
mp1 (\5\:S1b \6\:S1 \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1585e-13 ad=3.01e-14 ps=2.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64314e-06 sb=1.4e-07 sd=160n sca=48.554 \
        scb=0.0361963 scc=0.00572043 m=(1)
ends MXI4X2
// End of subcircuit definition.

// Generated for: spectre (May  9 15:42:45 2012 )
// Library name: gsclib045
// Cell name: MXI4X4
// View name: extracted

simulator lang=spectre

subckt MXI4X4 A B C D S0 S1 VDD VSS Y
mp0 (\15\:S0b \1\:S0 \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.9686e-06 sd=160n sca=15.5268 \
        scb=0.0147861 scc=0.000216306 m=(1)
C1 (S1 VSS) capacitor c=1.78697e-17
C2 (C VSS) capacitor c=1.307e-16
C3 (VDD VSS) capacitor c=3.37516e-16
C4 (Y VSS) capacitor c=3.85491e-16
C5 (B VSS) capacitor c=1.11721e-16
C6 (S0 VSS) capacitor c=1.08481e-16
C7 (S0b VSS) capacitor c=6.56106e-17
C8 (n0 VSS) capacitor c=4.01778e-17
C9 (net361 VSS) capacitor c=9.03112e-19
C10 (n1 VSS) capacitor c=5.45877e-17
C11 (net377 VSS) capacitor c=5.06927e-18
C12 (net329 VSS) capacitor c=2.28165e-18
C13 (n2 VSS) capacitor c=3.00533e-16
C14 (S1b VSS) capacitor c=3.92539e-17
C15 (net345 VSS) capacitor c=3.50871e-18
C16 (net304 VSS) capacitor c=3.81493e-18
C17 (net312 VSS) capacitor c=1.37987e-18
C18 (net320 VSS) capacitor c=9.18287e-18
C19 (net280 VSS) capacitor c=4.85195e-18
C20 (net284 VSS) capacitor c=7.68119e-18
C21 (\5\:S1 VSS) capacitor c=2.03475e-17
C22 (\3\:S1b VSS) capacitor c=3.10508e-17
C23 (\4\:S1 VSS) capacitor c=2.59143e-17
C24 (\1\:D VSS) capacitor c=2.82775e-17
C25 (\5\:S0b VSS) capacitor c=6.5091e-17
C26 (\8\:S0 VSS) capacitor c=6.058e-17
C27 (\1\:C VSS) capacitor c=5.56382e-17
C28 (\3\:B VSS) capacitor c=4.4017e-17
C29 (\3\:S0b VSS) capacitor c=4.22591e-17
C30 (\7\:S0 VSS) capacitor c=3.99105e-17
C31 (\1\:A VSS) capacitor c=3.54513e-17
C32 (\1\:S0 VSS) capacitor c=4.25726e-17
C33 (\8\:S1 VSS) capacitor c=3.41431e-17
C34 (\3\:n1 VSS) capacitor c=2.65097e-17
C35 (\1\:S1 VSS) capacitor c=5.72357e-17
C36 (\3\:n0 VSS) capacitor c=4.57443e-17
C37 (\3\:D VSS) capacitor c=5.50772e-17
C38 (\10\:S0 VSS) capacitor c=4.52404e-17
C39 (\6\:S0b VSS) capacitor c=8.0577e-17
C40 (\3\:C VSS) capacitor c=7.23483e-17
C41 (\1\:B VSS) capacitor c=7.97376e-17
C42 (\4\:S0 VSS) capacitor c=2.90617e-17
C43 (\3\:A VSS) capacitor c=8.43255e-17
C44 (\3\:S0 VSS) capacitor c=4.02172e-17
C45 (\7\:S1 VSS) capacitor c=1.67121e-17
C46 (\8\:n2 VSS) capacitor c=1.90576e-17
C47 (\2\:n1 VSS) capacitor c=4.37213e-17
C48 (\4\:S1b VSS) capacitor c=3.32436e-17
C49 (\2\:S1b VSS) capacitor c=5.86641e-17
C50 (\3\:S1 VSS) capacitor c=3.48639e-17
C51 (\2\:n0 VSS) capacitor c=4.741e-17
C52 (\2\:D VSS) capacitor c=4.20542e-17
C53 (\11\:S0 VSS) capacitor c=3.81288e-17
C54 (\9\:S0 VSS) capacitor c=4.82437e-17
C55 (\7\:S0b VSS) capacitor c=3.47051e-17
C56 (\2\:C VSS) capacitor c=6.11101e-17
C57 (\2\:B VSS) capacitor c=5.72765e-17
C58 (\5\:S0 VSS) capacitor c=6.19229e-17
C59 (\4\:S0b VSS) capacitor c=4.29841e-17
C60 (\6\:S0 VSS) capacitor c=4.85545e-17
C61 (\2\:S0b VSS) capacitor c=2.53174e-17
C62 (\2\:A VSS) capacitor c=5.93549e-17
C63 (\2\:S0 VSS) capacitor c=5.27584e-17
C64 (\5\:S1b VSS) capacitor c=3.14883e-17
C65 (\20\:n2 VSS) capacitor c=1.93535e-16
C66 (\18\:VDD VSS) capacitor c=2.97676e-17
C67 (\6\:n1 VSS) capacitor c=9.3102e-17
C68 (\20\:VDD VSS) capacitor c=3.54315e-17
C69 (\5\:n0 VSS) capacitor c=2.37748e-16
C70 (\22\:VDD VSS) capacitor c=3.033e-17
C71 (\15\:S0b VSS) capacitor c=6.84338e-17
C72 (\1\:VDD VSS) capacitor c=6.16349e-17
C73 (\10\:S1b VSS) capacitor c=1.9179e-17
C74 (\17\:n2 VSS) capacitor c=1.08162e-16
C75 (\8\:n1 VSS) capacitor c=4.25588e-17
C76 (\7\:n0 VSS) capacitor c=1.24086e-16
C77 (\12\:S0b VSS) capacitor c=1.78647e-17
C78 (\2\:S1 VSS) capacitor c=5.51948e-17
C79 (\6\:S1 VSS) capacitor c=1.81632e-17
C80 (\4\:A VSS) capacitor c=4.1427e-17
C81 (\6\:A VSS) capacitor c=3.32677e-17
C82 (\12\:S0 VSS) capacitor c=8.32566e-17
C83 (\8\:S0b VSS) capacitor c=7.5875e-17
C84 (\9\:S0b VSS) capacitor c=1.38146e-16
C85 (\10\:S0b VSS) capacitor c=9.95194e-17
C86 (\11\:S0b VSS) capacitor c=1.15084e-16
C87 (\14\:S0b VSS) capacitor c=7.26908e-17
C88 (\14\:S0 VSS) capacitor c=4.83429e-17
C89 (\15\:S0 VSS) capacitor c=6.8723e-17
C90 (\16\:S0 VSS) capacitor c=5.10909e-17
C91 (\17\:S0 VSS) capacitor c=5.56533e-17
C92 (\4\:D VSS) capacitor c=1.22476e-16
C93 (\4\:n0 VSS) capacitor c=2.43361e-16
C94 (\4\:n1 VSS) capacitor c=1.75408e-16
C95 (\5\:n1 VSS) capacitor c=2.39344e-16
C96 (\16\:n2 VSS) capacitor c=1.17778e-16
C97 (\19\:n2 VSS) capacitor c=1.75779e-16
C98 (\9\:S1 VSS) capacitor c=2.66669e-17
C99 (\10\:S1 VSS) capacitor c=2.38163e-16
C100 (\11\:S1 VSS) capacitor c=2.57486e-16
C101 (\7\:S1b VSS) capacitor c=3.3445e-16
C102 (\8\:S1b VSS) capacitor c=3.61868e-16
C103 (\9\:S1b VSS) capacitor c=5.20484e-17
C104 (\3\:VDD VSS) capacitor c=1.46341e-16
C105 (\7\:VDD VSS) capacitor c=5.13143e-17
C106 (\9\:VDD VSS) capacitor c=2.87295e-17
C107 (\10\:VDD VSS) capacitor c=2.03298e-17
Rk33 (\10\:S1 S1) resistor r=0.02569 c=0
Rk31 (\9\:S1 \10\:S1) resistor r=0.1493 c=0
Rk32 (\10\:S1 \11\:S1) resistor r=2.0957 c=0
Rk7 (\4\:C C) resistor r=0.002443 c=0
Rk53 (\2\:VDD \3\:VDD) resistor r=0.193 c=0
Rk57 (\3\:VDD \7\:VDD) resistor r=0.5832 c=0
Rk58 (\7\:VDD \8\:VDD) resistor r=0.4714 c=0
Rk59 (\8\:VDD \9\:VDD) resistor r=0.04998 c=0
Rk60 (\9\:VDD \10\:VDD) resistor r=0.5314 c=0
Rk62 (\11\:VDD VDD) resistor r=0.04992 c=0
Rk61 (\10\:VDD \11\:VDD) resistor r=0.1202 c=0
Rk66 (\7\:VDD \19\:VDD) resistor r=0.123 c=0
Rk67 (\9\:VDD \21\:VDD) resistor r=0.123 c=0
Rk68 (\10\:VDD \23\:VDD) resistor r=0.2115 c=0
Rk17 (D \4\:D) resistor r=0.006814 c=0
Rk41 (\1\:VSS \7\:VSS) resistor r=0.5367 c=0
Rk42 (\7\:VSS \8\:VSS) resistor r=0.08008 c=0
Rk43 (\8\:VSS \9\:VSS) resistor r=0.4537 c=0
Rk44 (\9\:VSS \10\:VSS) resistor r=0.3184 c=0
Rk45 (\10\:VSS \11\:VSS) resistor r=0.2958 c=0
Rk47 (\12\:VSS VSS) resistor r=0.04992 c=0
Rk46 (\11\:VSS \12\:VSS) resistor r=0.1052 c=0
Rk50 (\8\:VSS \18\:VSS) resistor r=0.2704 c=0
Rk51 (\9\:VSS \20\:VSS) resistor r=0.07416 c=0
Rk52 (\11\:VSS \22\:VSS) resistor r=0.2425 c=0
Rk6 (B \4\:B) resistor r=0.003983 c=0
Rk1 (\4\:A \5\:A) resistor r=0.001415 c=0
Rk2 (A \6\:A) resistor r=0.001321 c=0
Rk3 (\4\:A \6\:A) resistor r=0.0301 c=0
Rk5 (\13\:S0 S0) resistor r=0.003006 c=0
Rk4 (\12\:S0 \13\:S0) resistor r=0.4711 c=0
Rk14 (\14\:S0 \15\:S0) resistor r=0.2491 c=0
Rk15 (\15\:S0 \16\:S0) resistor r=0.3712 c=0
Rk16 (\15\:S0 \17\:S0) resistor r=0.2689 c=0
Rk8 (\8\:S0b \9\:S0b) resistor r=0.5022 c=0
Rk9 (\9\:S0b \10\:S0b) resistor r=0.4435 c=0
Rk10 (\10\:S0b \11\:S0b) resistor r=0.5528 c=0
Rk11 (\11\:S0b \13\:S0b) resistor r=0.07531 c=0
Rk12 (\9\:S0b \14\:S0b) resistor r=0.4543 c=0
Rk13 (\11\:S0b \16\:S0b) resistor r=0.647 c=0
Rk18 (\4\:n0 \6\:n0) resistor r=1.7103 c=0
Rk19 (\6\:n0 \8\:n0) resistor r=0.6765 c=0
Rk20 (\4\:n1 \5\:n1) resistor r=1.4011 c=0
Rk21 (\5\:n1 \7\:n1) resistor r=0.7032 c=0
Rk22 (\5\:n1 \9\:n1) resistor r=0.3068 c=0
Rk23 (\16\:n2 \18\:n2) resistor r=0.7155 c=0
Rk24 (\19\:n2 \21\:n2) resistor r=1.207 c=0
Rk34 (\6\:S1b \7\:S1b) resistor r=0.2934 c=0
Rk35 (\7\:S1b \8\:S1b) resistor r=2.7243 c=0
Rk36 (\8\:S1b \9\:S1b) resistor r=0.2807 c=0
Rk37 (\7\:S1b \11\:S1b) resistor r=0.124 c=0
Rl25 (\2\:S1 \4\:S1) resistor r=32.3738 c=0
Rl23 (\1\:S1 \2\:S1) resistor r=176.901 c=0
Rl24 (\2\:S1 \3\:S1) resistor r=35.0048 c=0
Rl43 (\5\:S1 \6\:S1) resistor r=37.3411 c=0
Rl45 (\6\:S1 \8\:S1) resistor r=129.649 c=0
Rl44 (\6\:S1 \7\:S1) resistor r=5.013 c=0
Rl12 (\1\:C \2\:C) resistor r=50.6918 c=0
Rl13 (\2\:C \3\:C) resistor r=189.153 c=0
Rl18 (\1\:D \2\:D) resistor r=49.2328 c=0
Rl19 (\2\:D \3\:D) resistor r=187.694 c=0
Rl11 (\2\:B \3\:B) resistor r=76.9003 c=0
Rl10 (\1\:B \2\:B) resistor r=197.872 c=0
Rl3 (\1\:A \2\:A) resistor r=73.7687 c=0
Rl4 (\2\:A \3\:A) resistor r=181.461 c=0
Rl17 (\10\:S0 \11\:S0) resistor r=44.9225 c=0
Rl14 (\8\:S0 \9\:S0) resistor r=71.8456 c=0
Rl7 (\4\:S0 \5\:S0) resistor r=24.7951 c=0
Rl9 (\6\:S0 \7\:S0) resistor r=109.41 c=0
Rl8 (\5\:S0 \6\:S0) resistor r=232.647 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=125.692 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=129.538 c=0
Rl15 (\5\:S0b \6\:S0b) resistor r=283.747 c=0
Rl16 (\6\:S0b \7\:S0b) resistor r=24.2328 c=0
Rl6 (\3\:S0b \4\:S0b) resistor r=71.8456 c=0
Rl5 (S0b \2\:S0b) resistor r=31.9251 c=0
Rl20 (n0 \2\:n0) resistor r=29.5379 c=0
Rl21 (\2\:n0 \3\:n0) resistor r=110.307 c=0
Rl27 (n1 \2\:n1) resistor r=112.694 c=0
Rl28 (\2\:n1 \3\:n1) resistor r=78.4003 c=0
Rl35 (\8\:n2 n2) resistor r=10.9879 c=0
Rl26 (\3\:S1b \4\:S1b) resistor r=35.3072 c=0
Rl22 (S1b \2\:S1b) resistor r=61.5157 c=0
Rz14 (\2\:VDD \1\:VDD) resistor r=18.75 c=0
Rz15 (\3\:VDD \1\:VDD) resistor r=7.5 c=0
Rz16 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz17 (\11\:VDD \1\:VDD) resistor r=37.5 c=0
Rz11 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz12 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz13 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz1 (\12\:S0b \13\:S0b) resistor r=75 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz3 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz4 (\18\:n2 \17\:n2) resistor r=75 c=0
Rz7 (\10\:S1b \11\:S1b) resistor r=75 c=0
Ry15 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry16 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry17 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry8 (\1\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry9 (\7\:VSS \3\:VSS) resistor r=5.6364 c=0
Ry10 (\10\:VSS \3\:VSS) resistor r=10.3333 c=0
Ry11 (\12\:VSS \3\:VSS) resistor r=31 c=0
Ry1 (\15\:S0b \16\:S0b) resistor r=62 c=0
Ry2 (\5\:n0 \6\:n0) resistor r=62 c=0
Ry3 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry4 (\21\:n2 \20\:n2) resistor r=62 c=0
Ry7 (\5\:S1b \6\:S1b) resistor r=62 c=0
Rx17 (\7\:S1 \9\:S1) resistor r=45 c=0
Rx18 (\3\:S1 \11\:S1) resistor r=45 c=0
Rx5 (\2\:C \4\:C) resistor r=45 c=0
Rx12 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\2\:A \5\:A) resistor r=45 c=0
Rx2 (\6\:S0 \12\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \13\:S0) resistor r=45 c=0
Rx9 (\11\:S0 \14\:S0) resistor r=45 c=0
Rx10 (\5\:S0 \16\:S0) resistor r=45 c=0
Rx11 (\9\:S0 \17\:S0) resistor r=45 c=0
Rx6 (\7\:S0b \8\:S0b) resistor r=45 c=0
Rx7 (\2\:S0b \10\:S0b) resistor r=45 c=0
Rx8 (\4\:S0b \14\:S0b) resistor r=45 c=0
Rx13 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx14 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx15 (\16\:n2 \8\:n2) resistor r=45 c=0
Rx16 (\19\:n2 n2) resistor r=45 c=0
Rx19 (\4\:S1b \8\:S1b) resistor r=45 c=0
Rx20 (\2\:S1b \9\:S1b) resistor r=45 c=0
mn0 (\12\:S0b \3\:S0 \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.82259e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn2 (net349 \3\:A \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.7731e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn3 (\7\:n0 S0b net349 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=9.425e-14 ps=4.1e-07 pd=1.59e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.74776e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn5 (\7\:n0 \4\:S0 net361 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.668e-14 ad=9.425e-14 ps=5.2e-07 pd=1.59e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=1.58e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn4 (net361 \1\:B \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.015e-14 ad=1.667e-14 ps=1.41e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.305e-06 sb=1.54138e-06 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn6 (net369 \3\:C \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.015e-14 ad=1.957e-14 ps=1.41e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2e-06 sb=2e-06 sd=160n sca=10.0732 scb=0.00911402 \
        scc=0.000253284 m=(1)
mn7 (\8\:n1 \6\:S0b net369 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=3.045e-14 ps=5.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=2e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn9 (\8\:n1 \10\:S0 net377 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.045e-14 ad=3.045e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.635e-06 sb=1.97103e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn8 (net377 \3\:D \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.225e-14 ad=3.045e-14 ps=9.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.70793e-06 sb=1.93586e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn10 (net329 \3\:n0 \17\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.225e-14 ad=3.588e-14 ps=9.1e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28768e-06 sb=1.92585e-06 sd=160n sca=9.17255 \
        scb=0.0076374 scc=0.000189126 m=(1)
mn11 (\17\:n2 S1b net329 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.588e-14 ad=3.28e-14 ps=7.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38963e-06 sb=1.90439e-06 sd=160n sca=9.17255 \
        scb=0.0076374 scc=0.000189126 m=(1)
mn13 (\17\:n2 \1\:S1 net345 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.432e-14 ad=3.28e-14 ps=9.4e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48463e-06 sb=1.8561e-06 sd=160n sca=9.17255 \
        scb=0.0076374 scc=0.000189126 m=(1)
mn12 (net345 \3\:n1 \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.93e-14 ad=5.432e-14 ps=1.24e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.62829e-06 sb=1.69817e-06 sd=160n sca=9.17255 \
        scb=0.0076374 scc=0.000189126 m=(1)
mn14_1__rcx (Y n2 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.077e-14 ad=6.78e-14 ps=1.2075e-06 pd=1.075e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.42269e-06 sb=1.26077e-06 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(4)
mn1 (\10\:S1b \8\:S1 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.137e-14 ad=2.03e-14 ps=1.07e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.33388 scb=0.00788941 \
        scc=0.00017958 m=(1)
mp2 (net296 \1\:A \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.45e-14 ps=7.5e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.96384e-06 sd=160n sca=11.9362 \
        scb=0.00875484 scc=7.61791e-05 m=(1)
mp3 (\5\:n0 \7\:S0 net296 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.45e-14 ad=5.875e-14 ps=1.03e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=1.74093e-06 sd=160n sca=10.2921 \
        scb=0.00736325 scc=7.25636e-05 m=(1)
mp5 (\5\:n0 \3\:S0b net304 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=5.875e-14 ps=7.2e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.88837e-07 sb=1.53953e-06 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
mp4 (net304 \3\:B \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.117e-14 ad=3.117e-14 ps=1.3e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17884e-06 sb=1.39372e-06 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
mp6 (net312 \1\:C \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.117e-14 ad=1.505e-14 ps=1.3e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52884e-06 sb=1.12512e-06 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
mp7 (\6\:n1 \8\:S0 net312 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=3.44e-14 ps=5.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64384e-06 sb=1.03686e-06 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
mp9 (\6\:n1 \5\:S0b net320 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.988e-14 ad=3.44e-14 ps=1.08e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.84884e-06 sb=8.79535e-07 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
mp8 (net320 \1\:D \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.215e-14 ad=6.988e-14 ps=1.71e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.98442e-06 sb=5.95581e-07 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
mp10 (net280 n0 \18\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.215e-14 ad=6.82e-14 ps=1.71e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.00403e-07 sb=2e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp11 (\20\:n2 \4\:S1 net280 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.82e-14 ad=8.525e-14 ps=1.06e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.26935e-07 sb=1.9625e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp13 (\20\:n2 \3\:S1b net284 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.51e-14 ad=8.525e-14 ps=1.04e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.97097e-07 sb=1.86444e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp12 (net284 n1 \3\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.892e-13 ad=6.51e-14 ps=2.29e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.11097e-06 sb=1.64758e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp14_1__rcx (Y n2 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.4389e-13 ad=6.24e-14 ps=1.975e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.24128e-06 sb=1.10615e-06 sd=160n sca=28.7024 \
        scb=0.0198217 scc=0.00315848 m=(4)
mp1 (\5\:S1b \5\:S1 \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.3438e-13 ad=3.01e-14 ps=1.83e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=29.3395 scb=0.0284356 \
        scc=0.00289177 m=(1)
ends MXI4X4
// End of subcircuit definition.

// Generated for: spectre (May  9 15:43:23 2012 )
// Library name: gsclib045
// Cell name: MXI4XL
// View name: extracted

simulator lang=spectre

subckt MXI4XL A B C D S0 S1 VDD VSS Y
mp14 (\1\:Y n2 \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.375e-14 ad=3.44e-14 ps=1.53e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=3.75e-07 sd=160n sca=52.2659 \
        scb=0.0376451 scc=0.00612616 m=(1)
C1 (C VSS) capacitor c=5.59052e-17
C2 (S0 VSS) capacitor c=3.26341e-17
C3 (D VSS) capacitor c=4.97748e-17
C4 (A VSS) capacitor c=4.21831e-17
C5 (VDD VSS) capacitor c=2.80481e-16
C6 (S1 VSS) capacitor c=6.83538e-17
C7 (Y VSS) capacitor c=1.50261e-17
C8 (B VSS) capacitor c=7.52164e-17
C9 (n2 VSS) capacitor c=2.84328e-17
C10 (S1b VSS) capacitor c=5.08097e-17
C11 (n1 VSS) capacitor c=7.79359e-17
C12 (net329 VSS) capacitor c=1.59848e-18
C13 (n0 VSS) capacitor c=5.84746e-17
C14 (net377 VSS) capacitor c=3.34855e-18
C15 (net369 VSS) capacitor c=4.71563e-19
C16 (S0b VSS) capacitor c=5.55279e-17
C17 (net284 VSS) capacitor c=1.73501e-18
C18 (net280 VSS) capacitor c=4.003e-18
C19 (net320 VSS) capacitor c=2.69479e-18
C20 (net312 VSS) capacitor c=2.70699e-18
C21 (net304 VSS) capacitor c=7.27052e-18
C22 (\10\:S0 VSS) capacitor c=3.45721e-17
C23 (\3\:A VSS) capacitor c=4.83878e-17
C24 (\4\:S0 VSS) capacitor c=6.66775e-17
C25 (\5\:S0b VSS) capacitor c=4.45213e-17
C26 (\1\:B VSS) capacitor c=4.1684e-17
C27 (\3\:C VSS) capacitor c=4.72972e-17
C28 (\1\:S0 VSS) capacitor c=5.44057e-17
C29 (\1\:D VSS) capacitor c=5.14199e-17
C30 (\6\:S1 VSS) capacitor c=5.53642e-17
C31 (\3\:S1b VSS) capacitor c=4.6923e-17
C32 (\2\:n1 VSS) capacitor c=5.06189e-17
C33 (\1\:S1 VSS) capacitor c=3.82528e-17
C34 (\8\:S0 VSS) capacitor c=3.63243e-17
C35 (\1\:A VSS) capacitor c=5.83784e-17
C36 (\7\:S0b VSS) capacitor c=4.75057e-17
C37 (\7\:S0 VSS) capacitor c=2.69079e-17
C38 (\3\:B VSS) capacitor c=5.58099e-17
C39 (\1\:C VSS) capacitor c=8.15502e-17
C40 (\3\:S0b VSS) capacitor c=5.66721e-17
C41 (\3\:S0 VSS) capacitor c=3.835e-17
C42 (\4\:D VSS) capacitor c=3.39679e-17
C43 (\2\:n0 VSS) capacitor c=4.73771e-17
C44 (\5\:S1 VSS) capacitor c=7.5931e-17
C45 (\3\:S1 VSS) capacitor c=2.81984e-17
C46 (\3\:n2 VSS) capacitor c=2.63951e-17
C47 (\9\:S0 VSS) capacitor c=4.33603e-17
C48 (\2\:A VSS) capacitor c=7.07558e-17
C49 (\5\:S0 VSS) capacitor c=7.69619e-17
C50 (\8\:S0b VSS) capacitor c=1.83891e-17
C51 (\6\:S0b VSS) capacitor c=3.47968e-17
C52 (\6\:S0 VSS) capacitor c=6.99852e-17
C53 (\2\:B VSS) capacitor c=6.13297e-17
C54 (\2\:C VSS) capacitor c=5.64545e-17
C55 (\4\:S0b VSS) capacitor c=3.89332e-17
C56 (\2\:S0 VSS) capacitor c=5.04886e-17
C57 (\2\:S0b VSS) capacitor c=3.42549e-17
C58 (\3\:D VSS) capacitor c=1.33092e-17
C59 (\3\:n0 VSS) capacitor c=2.97366e-17
C60 (\7\:S1 VSS) capacitor c=3.87367e-17
C61 (\4\:S1 VSS) capacitor c=2.433e-17
C62 (\2\:S1b VSS) capacitor c=7.20252e-17
C63 (\3\:n1 VSS) capacitor c=2.80008e-17
C64 (\2\:S1 VSS) capacitor c=3.12059e-17
C65 (\2\:n2 VSS) capacitor c=3.29301e-17
C66 (\16\:S0b VSS) capacitor c=7.03262e-17
C67 (\1\:VDD VSS) capacitor c=3.78833e-17
C68 (\6\:n0 VSS) capacitor c=2.19694e-16
C69 (\12\:VDD VSS) capacitor c=4.05091e-17
C70 (\6\:n1 VSS) capacitor c=1.82519e-16
C71 (\14\:VDD VSS) capacitor c=1.77169e-17
C72 (\6\:n2 VSS) capacitor c=1.7026e-16
C73 (\16\:VDD VSS) capacitor c=4.41177e-17
C74 (\6\:S1b VSS) capacitor c=2.31851e-17
C75 (\18\:VDD VSS) capacitor c=1.84365e-17
C76 (\1\:Y VSS) capacitor c=3.22829e-17
C77 (\3\:VDD VSS) capacitor c=1.00044e-16
C78 (\14\:S0b VSS) capacitor c=7.5974e-17
C79 (\4\:n0 VSS) capacitor c=8.06362e-17
C80 (\4\:n1 VSS) capacitor c=1.12727e-16
C81 (\4\:n2 VSS) capacitor c=6.11862e-17
C82 (\8\:S1b VSS) capacitor c=4.0776e-17
C83 (\3\:Y VSS) capacitor c=3.65127e-17
C84 (\2\:D VSS) capacitor c=3.85157e-17
C85 (\4\:S1b VSS) capacitor c=4.27561e-17
C86 (\5\:S1b VSS) capacitor c=4.36356e-17
C87 (\8\:n2 VSS) capacitor c=1.19548e-16
C88 (\8\:S1 VSS) capacitor c=8.49317e-17
C89 (\9\:S1 VSS) capacitor c=1.13402e-16
C90 (\10\:S1 VSS) capacitor c=4.95572e-17
C91 (\5\:D VSS) capacitor c=4.46063e-17
C92 (\8\:n1 VSS) capacitor c=1.35153e-16
C93 (\4\:C VSS) capacitor c=6.47544e-17
C94 (\4\:B VSS) capacitor c=4.14289e-17
C95 (\11\:S0 VSS) capacitor c=7.25399e-17
C96 (\12\:S0 VSS) capacitor c=9.36749e-17
C97 (\8\:n0 VSS) capacitor c=1.811e-16
C98 (\6\:A VSS) capacitor c=8.36812e-17
C99 (\13\:S0 VSS) capacitor c=3.8408e-17
C100 (\14\:S0 VSS) capacitor c=3.5585e-17
C101 (\9\:S0b VSS) capacitor c=7.69244e-17
C102 (\10\:S0b VSS) capacitor c=1.22472e-16
C103 (\11\:S0b VSS) capacitor c=1.52916e-16
C104 (\12\:S0b VSS) capacitor c=9.60053e-17
C105 (\13\:S0b VSS) capacitor c=7.82937e-17
C106 (\5\:VDD VSS) capacitor c=2.0257e-17
C107 (\7\:VDD VSS) capacitor c=2.48865e-17
C108 (\9\:VDD VSS) capacitor c=3.22186e-18
C109 (\10\:VDD VSS) capacitor c=4.08885e-18
Rk14 (\4\:C C) resistor r=0.09376 c=0
Rk16 (\11\:S0 \12\:S0) resistor r=0.4241 c=0
Rk22 (\13\:S0 S0) resistor r=0.1047 c=0
Rk23 (S0 \14\:S0) resistor r=0.1233 c=0
Rk11 (\5\:D D) resistor r=0.1539 c=0
Rk19 (\4\:A A) resistor r=0.001419 c=0
Rk21 (\4\:A \6\:A) resistor r=0.04881 c=0
Rk20 (\5\:A \6\:A) resistor r=0.001419 c=0
Rk44 (\2\:VDD \4\:VDD) resistor r=0.4015 c=0
Rk45 (\4\:VDD \5\:VDD) resistor r=0.3834 c=0
Rk46 (\5\:VDD \6\:VDD) resistor r=0.2681 c=0
Rk47 (\6\:VDD \7\:VDD) resistor r=0.2054 c=0
Rk48 (\7\:VDD \8\:VDD) resistor r=0.3458 c=0
Rk49 (\8\:VDD \9\:VDD) resistor r=0.1227 c=0
Rk50 (\9\:VDD \10\:VDD) resistor r=0.1726 c=0
Rk52 (\11\:VDD VDD) resistor r=0.0499 c=0
Rk51 (\10\:VDD \11\:VDD) resistor r=0.1051 c=0
Rk53 (\5\:VDD \13\:VDD) resistor r=0.1993 c=0
Rk54 (\7\:VDD \15\:VDD) resistor r=0.07381 c=0
Rk55 (\9\:VDD \17\:VDD) resistor r=0.2671 c=0
Rk56 (\10\:VDD \19\:VDD) resistor r=0.2193 c=0
Rk9 (\9\:S1 S1) resistor r=0.5261 c=0
Rk8 (\8\:S1 \9\:S1) resistor r=0.5827 c=0
Rk10 (S1 \10\:S1) resistor r=0.2148 c=0
Rk2 (\4\:Y Y) resistor r=0.03964 c=0
Rk1 (\2\:Y \4\:Y) resistor r=0.2247 c=0
Rk30 (\2\:VSS \3\:VSS) resistor r=0.1151 c=0
Rk31 (\3\:VSS \4\:VSS) resistor r=0.2355 c=0
Rk32 (\4\:VSS \5\:VSS) resistor r=0.2957 c=0
Rk33 (\5\:VSS \6\:VSS) resistor r=0.2556 c=0
Rk34 (\6\:VSS \7\:VSS) resistor r=0.2882 c=0
Rk35 (\7\:VSS \8\:VSS) resistor r=0.3622 c=0
Rk36 (\8\:VSS \9\:VSS) resistor r=0.049 c=0
Rk38 (\10\:VSS VSS) resistor r=0.1691 c=0
Rk37 (\9\:VSS \10\:VSS) resistor r=0.1794 c=0
Rk39 (\3\:VSS \12\:VSS) resistor r=0.07381 c=0
Rk40 (\5\:VSS \14\:VSS) resistor r=0.07381 c=0
Rk41 (\7\:VSS \16\:VSS) resistor r=0.2506 c=0
Rk42 (\8\:VSS \18\:VSS) resistor r=0.0433 c=0
Rk43 (\10\:VSS \20\:VSS) resistor r=0.0433 c=0
Rk15 (B \4\:B) resistor r=0.1814 c=0
Rk6 (\5\:n2 \7\:n2) resistor r=0.3975 c=0
Rk7 (\7\:n2 \8\:n2) resistor r=0.8497 c=0
Rk3 (\4\:S1b \5\:S1b) resistor r=0.2305 c=0
Rk4 (\5\:S1b \7\:S1b) resistor r=0.07054 c=0
Rk5 (\5\:S1b \9\:S1b) resistor r=0.2173 c=0
Rk12 (\5\:n1 \7\:n1) resistor r=0.6958 c=0
Rk13 (\7\:n1 \8\:n1) resistor r=0.9523 c=0
Rk17 (\5\:n0 \7\:n0) resistor r=0.5881 c=0
Rk18 (\7\:n0 \8\:n0) resistor r=1.358 c=0
Rk24 (\9\:S0b \10\:S0b) resistor r=0.4953 c=0
Rk25 (\10\:S0b \11\:S0b) resistor r=0.6319 c=0
Rk26 (\11\:S0b \12\:S0b) resistor r=0.6957 c=0
Rk27 (\10\:S0b \13\:S0b) resistor r=0.2614 c=0
Rk28 (\13\:S0b \15\:S0b) resistor r=0.6283 c=0
Rk29 (\15\:S0b \17\:S0b) resistor r=0.5378 c=0
Rl21 (\2\:C \3\:C) resistor r=88.0156 c=0
Rl20 (\1\:C \2\:C) resistor r=147.31 c=0
Rl32 (\9\:S0 \10\:S0) resistor r=95.3297 c=0
Rl31 (\8\:S0 \9\:S0) resistor r=115.385 c=0
Rl26 (\4\:S0 \5\:S0) resistor r=85.7713 c=0
Rl28 (\6\:S0 \7\:S0) resistor r=24.2328 c=0
Rl27 (\5\:S0 \6\:S0) resistor r=239.172 c=0
Rl17 (\1\:S0 \2\:S0) resistor r=128.079 c=0
Rl18 (\2\:S0 \3\:S0) resistor r=103.4 c=0
Rl13 (\1\:D \2\:D) resistor r=34.3295 c=0
Rl15 (\2\:D \4\:D) resistor r=167.022 c=0
Rl14 (\2\:D \3\:D) resistor r=2.0166 c=0
Rl30 (\2\:A \3\:A) resistor r=26.3736 c=0
Rl29 (\1\:A \2\:A) resistor r=184.615 c=0
Rl10 (\6\:S1 \7\:S1) resistor r=39.1533 c=0
Rl7 (\4\:S1 \5\:S1) resistor r=84.1943 c=0
Rl3 (\1\:S1 \2\:S1) resistor r=37.2302 c=0
Rl4 (\2\:S1 \3\:S1) resistor r=29.5379 c=0
Rl22 (\1\:B \2\:B) resistor r=93.4057 c=0
Rl23 (\2\:B \3\:B) resistor r=95.3288 c=0
Rl1 (n2 \2\:n2) resistor r=24.2328 c=0
Rl2 (\2\:n2 \3\:n2) resistor r=39.6174 c=0
Rl8 (S1b \2\:S1b) resistor r=131.504 c=0
Rl9 (\2\:S1b \3\:S1b) resistor r=26.098 c=0
Rl5 (n1 \2\:n1) resistor r=147.643 c=0
Rl6 (\2\:n1 \3\:n1) resistor r=24.2328 c=0
Rl11 (n0 \2\:n0) resistor r=144.231 c=0
Rl12 (n0 \3\:n0) resistor r=24.2328 c=0
Rl25 (\7\:S0b \8\:S0b) resistor r=47.3097 c=0
Rl24 (\5\:S0b \6\:S0b) resistor r=29.5379 c=0
Rl19 (\3\:S0b \4\:S0b) resistor r=61.996 c=0
Rl16 (S0b \2\:S0b) resistor r=66.5405 c=0
Rz12 (\3\:VDD \4\:VDD) resistor r=9.375 c=0
Rz13 (\3\:VDD \6\:VDD) resistor r=15 c=0
Rz14 (\3\:VDD \8\:VDD) resistor r=12.5 c=0
Rz15 (\3\:VDD \11\:VDD) resistor r=37.5 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz7 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz8 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz9 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz10 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz11 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz3 (\4\:n2 \5\:n2) resistor r=75 c=0
Rz2 (\8\:S1b \9\:S1b) resistor r=75 c=0
Rz4 (\4\:n1 \5\:n1) resistor r=75 c=0
Rz5 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz6 (\14\:S0b \15\:S0b) resistor r=75 c=0
Ry11 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry12 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry13 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry14 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry15 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry7 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry8 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry9 (\1\:VSS \6\:VSS) resistor r=10.3333 c=0
Ry10 (\1\:VSS \9\:VSS) resistor r=7.75 c=0
Ry3 (\6\:n2 \7\:n2) resistor r=62 c=0
Ry2 (\6\:S1b \7\:S1b) resistor r=62 c=0
Ry4 (\6\:n1 \7\:n1) resistor r=62 c=0
Ry5 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry6 (\16\:S0b \17\:S0b) resistor r=62 c=0
Rx8 (\2\:C \4\:C) resistor r=45 c=0
Rx10 (\6\:S0 \11\:S0) resistor r=45 c=0
Rx11 (\2\:S0 \12\:S0) resistor r=45 c=0
Rx14 (\9\:S0 \13\:S0) resistor r=45 c=0
Rx15 (\5\:S0 \14\:S0) resistor r=45 c=0
Rx6 (\3\:D \5\:D) resistor r=45 c=0
Rx13 (\2\:A \5\:A) resistor r=45 c=0
Rx3 (\7\:S1 \8\:S1) resistor r=45 c=0
Rx4 (\4\:S1 \9\:S1) resistor r=45 c=0
Rx5 (\2\:S1 \10\:S1) resistor r=45 c=0
Rx9 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:n2 \8\:n2) resistor r=45 c=0
Rx1 (\2\:S1b \4\:S1b) resistor r=45 c=0
Rx7 (\3\:n1 \8\:n1) resistor r=45 c=0
Rx12 (\3\:n0 \8\:n0) resistor r=45 c=0
Rx16 (\6\:S0b \9\:S0b) resistor r=45 c=0
Rx17 (\4\:S0b \11\:S0b) resistor r=45 c=0
Rx18 (\2\:S0b \12\:S0b) resistor r=45 c=0
Rx19 (\8\:S0b \13\:S0b) resistor r=45 c=0
mn14 (\3\:Y \3\:n2 \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.77e-14 ad=2.32e-14 ps=1.68e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=4.3e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn1 (\8\:S1b \3\:S1 \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.77e-14 ad=2.828e-14 ps=1.68e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=1.95e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn12 (net345 n1 \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=8.7e-15 ps=1.5e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=6.3e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn13 (\4\:n2 \5\:S1 net345 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=5.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn11 (\4\:n2 S1b net329 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.32e-14 ps=6.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=3.2e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn10 (net329 \2\:n0 \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.983e-14 ad=2.538e-14 ps=1.2e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=1e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn8 (net377 \4\:D \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.983e-14 ad=4.785e-14 ps=1.2e-06 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=1.80259e-06 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn9 (\4\:n1 \3\:S0 net377 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.785e-14 ad=3.335e-14 ps=9.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.65931e-06 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn7 (\4\:n1 \3\:S0b net369 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.335e-14 ps=4.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=1.38431e-06 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn6 (net369 \1\:C \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=8.7e-15 ps=1.39e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.27931e-06 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn4 (net361 \3\:B \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=1.958e-14 ps=1.39e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03103e-06 sb=1.29e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn5 (\4\:n0 \7\:S0 net361 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=5.365e-14 ps=5.6e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.21103e-06 sb=1.11e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn3 (\4\:n0 \7\:S0b net349 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.683e-14 ad=5.365e-14 ps=6.6e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.62603e-06 sb=6.95e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (net349 \1\:A \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.48e-14 ad=2.683e-14 ps=1.45e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.81466e-06 sb=4.65e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn0 (\14\:S0b \8\:S0 \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.48e-14 ad=2.9e-14 ps=1.45e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.86034e-06 sb=2e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mp1 (\6\:S1b \1\:S1 \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.375e-14 ad=3.01e-14 ps=1.53e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=1.4e-07 sd=160n sca=47.5923 \
        scb=0.0297582 scc=0.00588779 m=(1)
mp12 (net284 \2\:n1 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.83e-14 ad=2.902e-14 ps=1.05e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27907e-07 sb=1.77872e-06 sd=160n sca=15.0112 \
        scb=0.0146307 scc=0.000816974 m=(1)
mp13 (\6\:n2 \3\:S1b net284 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=4.3e-14 ps=7e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.07907e-07 sb=1.73267e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp11 (\6\:n2 \6\:S1 net280 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=4.3e-14 ps=6.6e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.52907e-07 sb=1.65128e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp10 (net280 n0 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0688e-13 ad=2.473e-14 ps=1.76e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.12907e-07 sb=1.5843e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp8 (net320 \1\:D \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0688e-13 ad=1.613e-14 ps=1.76e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04291e-06 sb=1.44616e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp9 (\6\:n1 S0b net320 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.613e-14 ad=5.98e-14 ps=5.8e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.16291e-06 sb=1.39593e-06 sd=160n sca=14.8993 \
        scb=0.0146069 scc=0.000816972 m=(1)
mp7 (\6\:n1 \1\:S0 net312 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=5.98e-14 ps=7e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.1586e-06 sb=1.62826e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp6 (net312 \3\:C \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.333e-14 ad=2.903e-14 ps=1.32e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3386e-06 sb=1.44826e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp4 (net304 \1\:B \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.333e-14 ad=5.16e-14 ps=1.32e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65209e-06 sb=1.08826e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp5 (\6\:n0 \5\:S0b net304 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=6.01e-14 ps=9.1e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.725e-06 sb=8.03256e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp3 (\6\:n0 \4\:S0 net296 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.01e-14 ps=5.5e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.50267e-06 sb=6e-07 sd=160n sca=11.7109 \
        scb=0.00935053 scc=0.000188054 m=(1)
mp2 (net296 \3\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=1.29e-14 ps=9.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54663e-06 sb=4.95e-07 sd=160n sca=12.2145 \
        scb=0.00974237 scc=0.000188593 m=(1)
mp0 (\16\:S0b \10\:S0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=4.515e-14 ps=9.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.66593e-06 sb=2.1e-07 sd=160n sca=16.0514 \
        scb=0.0157827 scc=0.00029851 m=(1)
ends MXI4XL
// End of subcircuit definition.

// Generated for: spectre (May  9 15:44:01 2012 )
// Library name: gsclib045
// Cell name: NAND2BX1
// View name: extracted

simulator lang=spectre

subckt NAND2BX1 AN B VDD VSS Y
mp2 (\1\:Y \4\:B \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.315e-14 ad=6.24e-14 ps=1.75e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=4.30321e-07 sd=160n sca=40.0601 \
        scb=0.0398737 scc=0.00422188 m=(1)
C1 (Y VSS) capacitor c=7.42598e-17
C2 (VDD VSS) capacitor c=6.66419e-17
C3 (AN VSS) capacitor c=3.16327e-17
C4 (n1 VSS) capacitor c=1.56892e-18
C5 (n0 VSS) capacitor c=5.74424e-17
C6 (\1\:AN VSS) capacitor c=4.33427e-17
C7 (\4\:B VSS) capacitor c=4.00496e-17
C8 (\3\:AN VSS) capacitor c=3.56639e-17
C9 (\3\:n0 VSS) capacitor c=6.41556e-17
C10 (\1\:B VSS) capacitor c=5.4866e-17
C11 (\2\:AN VSS) capacitor c=4.07071e-17
C12 (\2\:n0 VSS) capacitor c=4.46834e-17
C13 (\3\:B VSS) capacitor c=1.09983e-17
C14 (\4\:n0 VSS) capacitor c=6.79812e-17
C15 (\1\:VDD VSS) capacitor c=4.88807e-17
C16 (\1\:Y VSS) capacitor c=4.09021e-17
C17 (\5\:VDD VSS) capacitor c=7.96771e-18
C18 (\7\:n0 VSS) capacitor c=5.06983e-17
C19 (\4\:Y VSS) capacitor c=7.48199e-17
C20 (\2\:B VSS) capacitor c=2.73708e-17
C21 (\5\:B VSS) capacitor c=3.32931e-17
C22 (\6\:B VSS) capacitor c=2.30567e-17
C23 (\6\:n0 VSS) capacitor c=1.24686e-16
C24 (\4\:AN VSS) capacitor c=5.53945e-17
C25 (\4\:VDD VSS) capacitor c=1.87648e-17
Rk4 (\2\:Y Y) resistor r=0.1553 c=0
Rk5 (Y \5\:Y) resistor r=0.4998 c=0
Rk1 (B \5\:B) resistor r=0.002797 c=0
Rk3 (\5\:B \6\:B) resistor r=0.06103 c=0
Rk2 (\6\:B \7\:B) resistor r=0.002944 c=0
Rk14 (\4\:VSS VSS) resistor r=0.1502 c=0
Rk13 (\2\:VSS \4\:VSS) resistor r=0.3411 c=0
Rk11 (\4\:VDD VDD) resistor r=0.1511 c=0
Rk10 (\2\:VDD \4\:VDD) resistor r=0.3438 c=0
Rk12 (VDD \6\:VDD) resistor r=0.06042 c=0
Rk9 (AN \4\:AN) resistor r=0.05254 c=0
Rk7 (\5\:n0 \6\:n0) resistor r=0.5513 c=0
Rk8 (\6\:n0 \8\:n0) resistor r=0.3004 c=0
Rl3 (\2\:B \4\:B) resistor r=39.8465 c=0
Rl1 (\1\:B \2\:B) resistor r=57.2019 c=0
Rl2 (\2\:B \3\:B) resistor r=6.4152 c=0
Rl6 (\1\:AN \2\:AN) resistor r=77.1442 c=0
Rl7 (\2\:AN \3\:AN) resistor r=74.5909 c=0
Rl4 (n0 \2\:n0) resistor r=49.5142 c=0
Rl5 (\2\:n0 \3\:n0) resistor r=42.2135 c=0
Rz1 (\4\:Y \5\:Y) resistor r=75 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry2 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx1 (\3\:B \7\:B) resistor r=45 c=0
Rx3 (\2\:AN \4\:AN) resistor r=45 c=0
Rx2 (\2\:n0 \6\:n0) resistor r=45 c=0
mn2 (\4\:Y \1\:B n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=3.08e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.18462e-07 sb=3.76058e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mn1 (n1 \3\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.23462e-07 sb=2.71058e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn0 (\7\:n0 \3\:AN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.41379e-07 sb=1.4e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mp1 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=2.25321e-07 sd=160n sca=30.8677 \
        scb=0.0275043 scc=0.00252863 m=(1)
mp0 (\4\:n0 \1\:AN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.63e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.22326e-07 sd=160n sca=26.8107 \
        scb=0.0301615 scc=0.00168945 m=(1)
ends NAND2BX1
// End of subcircuit definition.

// Generated for: spectre (May  9 15:44:38 2012 )
// Library name: gsclib045
// Cell name: NAND2BX2
// View name: extracted

simulator lang=spectre

subckt NAND2BX2 AN B VDD VSS Y
mp1 (\1\:Y \2\:n0 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.998e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.76346e-07 sd=160n sca=23.9635 \
        scb=0.0271412 scc=0.00147566 m=(2)
C1 (Y VSS) capacitor c=1.43829e-16
C2 (B VSS) capacitor c=6.07859e-17
C3 (VDD VSS) capacitor c=2.44849e-16
C4 (n0 VSS) capacitor c=5.82454e-17
C5 (\1\:AN VSS) capacitor c=3.77466e-17
C6 (\3\:AN VSS) capacitor c=4.21762e-17
C7 (\6\:n0 VSS) capacitor c=6.8641e-17
C8 (\1\:B VSS) capacitor c=7.54908e-17
C9 (\4\:B VSS) capacitor c=5.21137e-17
C10 (\2\:AN VSS) capacitor c=4.29874e-17
C11 (\3\:B VSS) capacitor c=1.19518e-16
C12 (\2\:n0 VSS) capacitor c=3.66988e-16
C13 (\12\:n0 VSS) capacitor c=5.95295e-17
C14 (\1\:Y VSS) capacitor c=3.07769e-16
C15 (\7\:VDD VSS) capacitor c=6.35107e-17
C16 (\7\:n0 VSS) capacitor c=3.76599e-17
C17 (\6\:Y VSS) capacitor c=9.20961e-17
C18 (\2\:B VSS) capacitor c=4.0505e-17
C19 (\7\:B VSS) capacitor c=8.33428e-17
C20 (\9\:n0 VSS) capacitor c=7.51941e-17
C21 (\4\:AN VSS) capacitor c=3.80631e-17
C22 (\6\:AN VSS) capacitor c=1.86176e-17
Rk3 (\1\:Y Y) resistor r=0.9015 c=0
Rk5 (Y \7\:Y) resistor r=0.5334 c=0
Rk1 (\7\:B B) resistor r=0.2271 c=0
Rk19 (\2\:VSS \4\:VSS) resistor r=0.3423 c=0
Rk21 (\5\:VSS VSS) resistor r=0.1024 c=0
Rk20 (\4\:VSS \5\:VSS) resistor r=0.198 c=0
Rk22 (\5\:VSS \7\:VSS) resistor r=0.2283 c=0
Rk17 (VDD \8\:VDD) resistor r=0.2371 c=0
Rk10 (\4\:AN \5\:AN) resistor r=0.004659 c=0
Rk11 (AN \6\:AN) resistor r=0.004659 c=0
Rk12 (\4\:AN \6\:AN) resistor r=0.01774 c=0
Rk7 (\9\:n0 \2\:n0) resistor r=0.0382 c=0
Rk6 (\8\:n0 \9\:n0) resistor r=0.339 c=0
Rk9 (\9\:n0 \13\:n0) resistor r=0.4918 c=0
Rl3 (\2\:B \1\:B) resistor r=113.956 c=0
Rl5 (\2\:B \4\:B) resistor r=57.6674 c=0
Rl4 (\2\:B \3\:B) resistor r=96.1289 c=0
Rl10 (\1\:AN \2\:AN) resistor r=68.4636 c=0
Rl11 (\2\:AN \3\:AN) resistor r=126.156 c=0
Rl1 (\2\:n0 n0) resistor r=56.8672 c=0
Rl9 (\2\:n0 \6\:n0) resistor r=60.3072 c=0
Rz1 (\7\:Y \6\:Y) resistor r=37.5 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=37.5 c=0
Rz2 (\8\:n0 \7\:n0) resistor r=75 c=0
Ry5 (\8\:VDD \7\:VDD) resistor r=31 c=0
Ry3 (\13\:n0 \12\:n0) resistor r=62 c=0
Rx1 (\7\:B \3\:B) resistor r=45 c=0
Rx4 (\2\:AN \5\:AN) resistor r=45 c=0
mn1 (7 n0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.64e-14 \
        ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 sa=1.4e-07 \
        sb=6.86058e-07 sd=160n sca=8.97712 scb=0.00732387 scc=0.000196032 \
        m=(1)
mn2 (\6\:Y \4\:B 7 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=5.81058e-07 sd=160n sca=8.97712 scb=0.00732387 \
        scc=0.000196032 m=(1)
mn2_1__rcx (\6\:Y \1\:B 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.76058e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn1_1__rcx (8 \6\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2.71058e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn0 (\7\:n0 \3\:AN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mp2 (\1\:Y \3\:B \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.71346e-07 sd=160n sca=14.3783 \
        scb=0.0128814 scc=0.000216758 m=(2)
mp0 (\12\:n0 \1\:AN VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.69e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=1.25116e-07 sd=160n sca=16.5512 \
        scb=0.0167219 scc=0.000369419 m=(1)
ends NAND2BX2
// End of subcircuit definition.

// Generated for: spectre (May  9 15:45:23 2012 )
// Library name: gsclib045
// Cell name: NAND2BX4
// View name: extracted

simulator lang=spectre

subckt NAND2BX4 AN B VDD VSS Y
mp1 (\1\:Y \2\:n0 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.78e-06 sd=160n sca=25.0495 \
        scb=0.0285542 scc=0.00163822 m=(4)
C1 (B VSS) capacitor c=5.41424e-17
C2 (VDD VSS) capacitor c=4.94363e-16
C3 (Y VSS) capacitor c=2.22955e-16
C4 (AN VSS) capacitor c=3.24052e-17
C5 (n0 VSS) capacitor c=5.9511e-17
C6 (\1\:AN VSS) capacitor c=4.84157e-17
C7 (\3\:AN VSS) capacitor c=4.97146e-17
C8 (\13\:n0 VSS) capacitor c=5.92754e-17
C9 (\7\:B VSS) capacitor c=7.4845e-17
C10 (\11\:B VSS) capacitor c=5.21764e-17
C11 (\4\:n0 VSS) capacitor c=5.32262e-17
C12 (\7\:n0 VSS) capacitor c=5.73295e-17
C13 (\1\:B VSS) capacitor c=7.3386e-17
C14 (\5\:B VSS) capacitor c=5.29868e-17
C15 (\2\:AN VSS) capacitor c=6.16797e-17
C16 (\3\:B VSS) capacitor c=4.59507e-16
C17 (\2\:n0 VSS) capacitor c=8.68746e-16
C18 (\14\:n0 VSS) capacitor c=8.15917e-17
C19 (\1\:Y VSS) capacitor c=6.56362e-16
C20 (\20\:n0 VSS) capacitor c=5.85454e-17
C21 (\15\:Y VSS) capacitor c=1.08782e-16
C22 (\9\:Y VSS) capacitor c=3.96435e-17
C23 (\2\:B VSS) capacitor c=4.32953e-17
C24 (\8\:B VSS) capacitor c=4.02979e-17
C25 (\8\:Y VSS) capacitor c=1.35649e-16
C26 (\5\:AN VSS) capacitor c=5.28193e-17
Rk2 (\3\:B B) resistor r=0.14 c=0
Rk31 (\2\:VSS \4\:VSS) resistor r=0.3118 c=0
Rk32 (\4\:VSS \5\:VSS) resistor r=0.2887 c=0
Rk33 (\5\:VSS \6\:VSS) resistor r=0.1631 c=0
Rk34 (\6\:VSS \7\:VSS) resistor r=0.148 c=0
Rk36 (\8\:VSS VSS) resistor r=0.05 c=0
Rk35 (\7\:VSS \8\:VSS) resistor r=0.1028 c=0
Rk37 (\5\:VSS \10\:VSS) resistor r=0.2304 c=0
Rk38 (\7\:VSS \12\:VSS) resistor r=0.2304 c=0
Rk4 (\1\:Y Y) resistor r=1.5894 c=0
Rk8 (Y \8\:Y) resistor r=0.4932 c=0
Rk9 (\8\:Y \10\:Y) resistor r=0.1197 c=0
Rk12 (\8\:Y \16\:Y) resistor r=0.674 c=0
Rk18 (\4\:AN \5\:AN) resistor r=0.003261 c=0
Rk19 (\6\:AN AN) resistor r=0.003261 c=0
Rk20 (\5\:AN \6\:AN) resistor r=0.0634 c=0
Rk13 (\15\:n0 \2\:n0) resistor r=0.6816 c=0
Rk17 (\2\:n0 \21\:n0) resistor r=0.3785 c=0
Rl3 (\2\:B \1\:B) resistor r=125.426 c=0
Rl6 (\2\:B \5\:B) resistor r=60.772 c=0
Rl4 (\2\:B \3\:B) resistor r=89.4132 c=0
Rl14 (\8\:B \7\:B) resistor r=125.426 c=0
Rl17 (\8\:B \11\:B) resistor r=60.772 c=0
Rl15 (\8\:B \3\:B) resistor r=90.7162 c=0
Rl21 (\1\:AN \2\:AN) resistor r=96.0237 c=0
Rl22 (\2\:AN \3\:AN) resistor r=106.613 c=0
Rl1 (\2\:n0 n0) resistor r=64.2323 c=0
Rl20 (\2\:n0 \13\:n0) resistor r=33.7912 c=0
Rl8 (\2\:n0 \4\:n0) resistor r=61.5385 c=0
Rl10 (\2\:n0 \7\:n0) resistor r=92.6161 c=0
Rz6 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz7 (\9\:VSS \10\:VSS) resistor r=37.5 c=0
Rz8 (\11\:VSS \12\:VSS) resistor r=37.5 c=0
Rz1 (\10\:Y \9\:Y) resistor r=37.5 c=0
Rz2 (\16\:Y \15\:Y) resistor r=37.5 c=0
Rz3 (\21\:n0 \20\:n0) resistor r=37.5 c=0
Ry11 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry12 (\3\:VSS \6\:VSS) resistor r=20.6667 c=0
Ry13 (\3\:VSS \8\:VSS) resistor r=31 c=0
Ry5 (\15\:n0 \14\:n0) resistor r=20.6667 c=0
Rx6 (\2\:AN \4\:AN) resistor r=45 c=0
mn1_1__rcx (7 n0 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.38e-06 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn2_1__rcx (\9\:Y \5\:B 7 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.275e-06 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn2_2__rcx (\9\:Y \1\:B 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.07e-06 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn1_2__rcx (8 \7\:n0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=9.65e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn1 (9 \4\:n0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=7.6e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn2 (\15\:Y \11\:B 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.65e-07 sb=6.55e-07 sd=160n sca=8.36684 scb=0.00633377 \
        scc=0.000139167 m=(1)
mn2_3__rcx (\15\:Y \7\:B 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=4.5e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn1_3__rcx (10 \13\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=3.45e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mn0 (\20\:n0 \3\:AN \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=1.4e-07 sd=160n sca=8.36684 \
        scb=0.00633377 scc=0.000139167 m=(1)
mp2 (\1\:Y \3\:B VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.575e-06 sd=160n sca=15.0157 \
        scb=0.0138815 scc=0.000273597 m=(4)
mp0 (\14\:n0 \1\:AN VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=1.4e-07 sd=160n sca=16.1834 \
        scb=0.0159482 scc=0.0003331 m=(1)
ends NAND2BX4
// End of subcircuit definition.

// Generated for: spectre (May  8 15:12:37 2012 )
// Library name: gsclib045
// Cell name: NAND2BXL
// View name: extracted

simulator lang=spectre

subckt NAND2BXL AN B VDD VSS Y
mp2 (\1\:Y \3\:B \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.125e-14 ad=3.44e-14 ps=1.44e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-07 sb=5.5e-07 sd=160n sca=29.0688 \
        scb=0.0326842 scc=0.00215013 m=(1)
C1 (B VSS) capacitor c=7.51943e-17
C2 (VDD VSS) capacitor c=7.67656e-17
C3 (Y VSS) capacitor c=2.31569e-17
C4 (AN VSS) capacitor c=3.51207e-17
C5 (n1 VSS) capacitor c=3.04313e-18
C6 (n0 VSS) capacitor c=3.8251e-17
C7 (\1\:AN VSS) capacitor c=3.3633e-17
C8 (\3\:B VSS) capacitor c=2.89936e-17
C9 (\3\:AN VSS) capacitor c=3.56982e-17
C10 (\3\:n0 VSS) capacitor c=4.8185e-17
C11 (\1\:B VSS) capacitor c=3.80563e-17
C12 (\2\:AN VSS) capacitor c=3.91351e-17
C13 (\2\:n0 VSS) capacitor c=4.9423e-17
C14 (\2\:B VSS) capacitor c=3.79523e-17
C15 (\7\:n0 VSS) capacitor c=4.41217e-17
C16 (\6\:VDD VSS) capacitor c=1.15015e-17
C17 (\1\:Y VSS) capacitor c=4.18884e-17
C18 (\8\:VDD VSS) capacitor c=2.13738e-17
C19 (\1\:VDD VSS) capacitor c=2.30902e-17
C20 (\4\:n0 VSS) capacitor c=6.50136e-17
C21 (\4\:Y VSS) capacitor c=7.93142e-17
C22 (\3\:Y VSS) capacitor c=3.56559e-17
C23 (\4\:B VSS) capacitor c=6.36551e-17
C24 (\6\:n0 VSS) capacitor c=1.12549e-16
C25 (\4\:AN VSS) capacitor c=6.15437e-17
C26 (\3\:VDD VSS) capacitor c=1.89868e-18
Rk4 (B \4\:B) resistor r=0.2021 c=0
Rk15 (\4\:VSS VSS) resistor r=0.1502 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.4176 c=0
Rk8 (\2\:VDD \3\:VDD) resistor r=0.05247 c=0
Rk10 (\4\:VDD VDD) resistor r=0.1006 c=0
Rk9 (\3\:VDD \4\:VDD) resistor r=0.09761 c=0
Rk12 (\3\:VDD \7\:VDD) resistor r=0.07393 c=0
Rk13 (VDD \9\:VDD) resistor r=0.1021 c=0
Rk3 (\3\:Y Y) resistor r=0.07463 c=0
Rk1 (\2\:Y \3\:Y) resistor r=0.1099 c=0
Rk2 (\3\:Y \5\:Y) resistor r=0.3398 c=0
Rk7 (AN \4\:AN) resistor r=0.04974 c=0
Rk5 (\5\:n0 \6\:n0) resistor r=0.3855 c=0
Rk6 (\6\:n0 \8\:n0) resistor r=0.3127 c=0
Rl2 (\2\:B \3\:B) resistor r=41.4835 c=0
Rl1 (\1\:B \2\:B) resistor r=98.0769 c=0
Rl5 (\1\:AN \2\:AN) resistor r=33.8482 c=0
Rl6 (\2\:AN \3\:AN) resistor r=101.156 c=0
Rl3 (n0 \2\:n0) resistor r=24.2328 c=0
Rl4 (\2\:n0 \3\:n0) resistor r=110.771 c=0
Rz6 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\1\:VDD VDD) resistor r=75 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \4\:VDD) resistor r=75 c=0
Rz1 (\4\:Y \5\:Y) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Ry3 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry4 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry2 (\7\:n0 \8\:n0) resistor r=62 c=0
Rx1 (\2\:B \4\:B) resistor r=45 c=0
Rx3 (\2\:AN \4\:AN) resistor r=45 c=0
Rx2 (\2\:n0 \6\:n0) resistor r=45 c=0
mn2 (\4\:Y \1\:B n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.522e-14 ad=2.175e-14 ps=5e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=4.95e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (n1 \3\:n0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.522e-14 ps=6.1e-07 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=3.45e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn0 (\4\:n0 \3\:AN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp1 (\1\:Y n0 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=3.44e-14 ps=1.53e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=3.45e-07 sd=160n sca=19.8763 \
        scb=0.0203148 scc=0.000456883 m=(1)
mp0 (\7\:n0 \1\:AN \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=3.01e-14 ps=1.53e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.4e-07 sd=160n sca=27.33 scb=0.0309842 \
        scc=0.00176829 m=(1)
ends NAND2BXL
// End of subcircuit definition.

// Generated for: spectre (May  9 15:46:38 2012 )
// Library name: gsclib045
// Cell name: NAND2X1
// View name: extracted

simulator lang=spectre

subckt NAND2X1 A B VDD VSS Y
mp0 (\3\:Y \1\:A \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.25e-07 sd=160n sca=36.5212 \
        scb=0.040075 scc=0.00317187 m=(1)
C1 (B VSS) capacitor c=2.45927e-17
C2 (VDD VSS) capacitor c=3.98714e-17
C3 (Y VSS) capacitor c=5.32372e-17
C4 (\1\:B VSS) capacitor c=4.12085e-17
C5 (\1\:A VSS) capacitor c=3.48823e-17
C6 (\3\:B VSS) capacitor c=4.71311e-17
C7 (\4\:A VSS) capacitor c=6.01256e-17
C8 (\2\:B VSS) capacitor c=3.9399e-17
C9 (\3\:A VSS) capacitor c=1.33251e-17
C10 (\1\:VDD VSS) capacitor c=4.91642e-18
C11 (\3\:Y VSS) capacitor c=8.07256e-17
C12 (\5\:VDD VSS) capacitor c=3.9301e-17
C13 (\1\:Y VSS) capacitor c=5.93872e-17
C14 (\2\:A VSS) capacitor c=2.63649e-17
C15 (\5\:A VSS) capacitor c=5.8306e-17
C16 (\4\:B VSS) capacitor c=6.68122e-17
C17 (\4\:VDD VSS) capacitor c=1.08731e-17
Rk11 (VSS \4\:VSS) resistor r=0.2793 c=0
Rk4 (\4\:B B) resistor r=0.01 c=0
Rk2 (\4\:B \5\:B) resistor r=0.001047 c=0
Rk8 (\4\:VDD VDD) resistor r=0.1003 c=0
Rk7 (\2\:VDD \4\:VDD) resistor r=0.1406 c=0
Rk9 (VDD \6\:VDD) resistor r=0.3286 c=0
Rk1 (\5\:A A) resistor r=0.01023 c=0
Rk5 (\2\:Y Y) resistor r=0.2303 c=0
Rk6 (Y \4\:Y) resistor r=0.3412 c=0
Rl4 (\1\:B \2\:B) resistor r=90.782 c=0
Rl5 (\2\:B \3\:B) resistor r=29.9451 c=0
Rl1 (\1\:A \2\:A) resistor r=37.3411 c=0
Rl3 (\2\:A \4\:A) resistor r=96.9565 c=0
Rl2 (\2\:A \3\:A) resistor r=1.2301 c=0
Rz3 (\3\:VSS \4\:VSS) resistor r=37.5 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=31 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Rx2 (\2\:B \5\:B) resistor r=45 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
mn0 (n0 \4\:A \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.82e-14 ps=8e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1 (\1\:Y \3\:B n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.82e-14 \
        ad=4.81e-14 ps=6.6e-07 pd=8.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.55e-07 sb=1.85e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mp1 (\3\:Y \1\:B \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.31e-14 ad=6.24e-14 ps=1.7e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.2e-07 sd=160n sca=37.5084 \
        scb=0.0409147 scc=0.00340882 m=(1)
ends NAND2X1
// End of subcircuit definition.

// Generated for: spectre (May  9 15:47:17 2012 )
// Library name: gsclib045
// Cell name: NAND2X2
// View name: extracted

simulator lang=spectre

subckt NAND2X2 A B VDD VSS Y
mp0 (\1\:Y \2\:A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.385e-14 ad=6.24e-14 ps=1.38e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.35e-07 sd=160n sca=33.0928 \
        scb=0.0355004 scc=0.00312201 m=(2)
C1 (Y VSS) capacitor c=9.85564e-17
C2 (A VSS) capacitor c=2.31828e-17
C3 (VDD VSS) capacitor c=1.28247e-16
C4 (7 VSS) capacitor c=1.48184e-18
C5 (\1\:B VSS) capacitor c=1.41539e-16
C6 (\6\:A VSS) capacitor c=5.35883e-17
C7 (\6\:B VSS) capacitor c=5.02732e-17
C8 (\5\:B VSS) capacitor c=5.10687e-17
C9 (\1\:A VSS) capacitor c=5.52087e-17
C10 (\2\:A VSS) capacitor c=3.86067e-16
C11 (\1\:Y VSS) capacitor c=2.29699e-16
C12 (\7\:VDD VSS) capacitor c=8.57239e-17
C13 (\6\:Y VSS) capacitor c=9.71619e-17
C14 (\8\:B VSS) capacitor c=4.15725e-17
C15 (\10\:B VSS) capacitor c=4.94896e-17
Rk9 (\1\:Y Y) resistor r=0.2619 c=0
Rk10 (Y \7\:Y) resistor r=0.5741 c=0
Rk5 (\2\:A A) resistor r=0.08778 c=0
Rk14 (VDD \8\:VDD) resistor r=0.2521 c=0
Rk15 (\2\:VSS \4\:VSS) resistor r=0.2037 c=0
Rk17 (\5\:VSS VSS) resistor r=0.02707 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.1506 c=0
Rk19 (\5\:VSS \8\:VSS) resistor r=0.2574 c=0
Rk1 (\8\:B \9\:B) resistor r=0.001288 c=0
Rk2 (B \10\:B) resistor r=0.001288 c=0
Rk3 (\8\:B \10\:B) resistor r=0.04084 c=0
Rl10 (\2\:A \6\:A) resistor r=46.9721 c=0
Rl1 (\2\:A \1\:A) resistor r=50 c=0
Rl7 (\1\:B \6\:B) resistor r=40.849 c=0
Rl6 (\1\:B \5\:B) resistor r=53.6577 c=0
Rz1 (\7\:Y \6\:Y) resistor r=37.5 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz4 (\7\:VSS \8\:VSS) resistor r=37.5 c=0
Ry5 (\8\:VDD \7\:VDD) resistor r=31 c=0
Ry7 (\3\:VSS VSS) resistor r=62 c=0
Ry6 (\3\:VSS \4\:VSS) resistor r=15.5 c=0
Rx1 (\9\:B \1\:B) resistor r=45 c=0
mn0 (6 \1\:A \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.85e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1 (\6\:Y \5\:B 6 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=4.8e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1_1__rcx (\6\:Y \6\:B 7 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2.75e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn0_1__rcx (7 \6\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.24e-14 ad=1.56e-14 ps=1.33e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.7e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mp1 (\1\:Y \1\:B \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.3e-07 sd=160n sca=24.0497 \
        scb=0.0216272 scc=0.0017588 m=(2)
ends NAND2X2
// End of subcircuit definition.

// Generated for: spectre (May  9 15:47:55 2012 )
// Library name: gsclib045
// Cell name: NAND2X4
// View name: extracted

simulator lang=spectre

subckt NAND2X4 A B VDD VSS Y
mp0 (\1\:Y A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=5.85e-14 \
        ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.575e-06 sd=160n sca=32.0426 scb=0.0350053 \
        scc=0.00300251 m=(4)
C1 (A VSS) capacitor c=6.4704e-16
C2 (VDD VSS) capacitor c=4.14502e-16
C3 (Y VSS) capacitor c=5.787e-17
C4 (B VSS) capacitor c=4.05375e-16
C5 (7 VSS) capacitor c=1.36339e-18
C6 (8 VSS) capacitor c=1.36339e-18
C7 (9 VSS) capacitor c=1.36339e-18
C8 (\12\:A VSS) capacitor c=4.94613e-17
C9 (\13\:B VSS) capacitor c=6.15385e-17
C10 (\11\:B VSS) capacitor c=5.38452e-17
C11 (\4\:A VSS) capacitor c=4.87216e-17
C12 (\6\:A VSS) capacitor c=6.07272e-17
C13 (\1\:B VSS) capacitor c=5.43502e-17
C14 (\4\:B VSS) capacitor c=5.86344e-17
C15 (\1\:A VSS) capacitor c=7.22735e-17
C16 (\1\:Y VSS) capacitor c=4.6204e-16
C17 (\10\:Y VSS) capacitor c=2.67781e-17
C18 (\19\:Y VSS) capacitor c=1.01079e-16
C19 (\2\:B VSS) capacitor c=3.37572e-17
C20 (\10\:B VSS) capacitor c=3.5068e-17
C21 (\9\:Y VSS) capacitor c=1.33911e-16
Rk29 (\2\:VSS \3\:VSS) resistor r=0.1076 c=0
Rk30 (\3\:VSS \4\:VSS) resistor r=0.3256 c=0
Rk31 (\4\:VSS \5\:VSS) resistor r=0.0675 c=0
Rk33 (\6\:VSS VSS) resistor r=0.1074 c=0
Rk32 (\5\:VSS \6\:VSS) resistor r=0.243 c=0
Rk34 (\3\:VSS \8\:VSS) resistor r=0.1822 c=0
Rk35 (\4\:VSS \10\:VSS) resistor r=0.2273 c=0
Rk36 (\6\:VSS \12\:VSS) resistor r=0.264 c=0
Rk11 (\1\:Y Y) resistor r=0.1521 c=0
Rk12 (Y \9\:Y) resistor r=0.4921 c=0
Rk13 (\9\:Y \11\:Y) resistor r=0.0698 c=0
Rk19 (\9\:Y \20\:Y) resistor r=0.5733 c=0
Rl20 (A \12\:A) resistor r=28.6412 c=0
Rl8 (A \4\:A) resistor r=28.3837 c=0
Rl9 (A \6\:A) resistor r=78.5649 c=0
Rl1 (A \1\:A) resistor r=86.5156 c=0
Rl4 (\2\:B B) resistor r=6.458 c=0
Rl3 (\2\:B \1\:B) resistor r=92.7662 c=0
Rl5 (\2\:B \4\:B) resistor r=104.305 c=0
Rl15 (\10\:B B) resistor r=10.5426 c=0
Rl18 (\10\:B \13\:B) resistor r=116.792 c=0
Rl16 (\10\:B \11\:B) resistor r=67.3711 c=0
Rz4 (\7\:VSS \8\:VSS) resistor r=37.5 c=0
Rz5 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz6 (\11\:VSS \12\:VSS) resistor r=37.5 c=0
Rz1 (\11\:Y \10\:Y) resistor r=37.5 c=0
Rz2 (\20\:Y \19\:Y) resistor r=37.5 c=0
Ry14 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry15 (\1\:VSS \5\:VSS) resistor r=7.75 c=0
mn0 (6 \1\:A \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.205e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1 (\19\:Y \4\:B 6 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.1e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1_1__rcx (\19\:Y \1\:B 7 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=8.95e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0_1__rcx (7 \6\:A \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=7.9e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0_2__rcx (8 \4\:A \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=5.85e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_2__rcx (\10\:Y \11\:B 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=4.8e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_3__rcx (\10\:Y \13\:B 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=2.75e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0_3__rcx (9 \12\:A \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.92e-14 ad=1.56e-14 ps=1.11e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.7e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mp1 (\1\:Y B VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=1.37e-06 sd=160n sca=22.0088 scb=0.0203326 \
        scc=0.00163789 m=(4)
ends NAND2X4
// End of subcircuit definition.

// Generated for: spectre (May  9 15:48:33 2012 )
// Library name: gsclib045
// Cell name: NAND2X6
// View name: extracted

simulator lang=spectre

subckt NAND2X6 A B VDD VSS Y
mp0 (\1\:Y \2\:A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.98e-14 ad=6.305e-14 ps=1.08667e-06 pd=1.10333e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=32.0426 scb=0.0350053 \
        scc=0.00300251 m=(6)
C1 (A VSS) capacitor c=1.09833e-17
C2 (VDD VSS) capacitor c=6.07866e-16
C3 (Y VSS) capacitor c=8.70174e-17
C4 (B VSS) capacitor c=8.12451e-16
C5 (6 VSS) capacitor c=5.30371e-18
C6 (7 VSS) capacitor c=2.54934e-18
C7 (8 VSS) capacitor c=8.51492e-18
C8 (9 VSS) capacitor c=1.81017e-18
C9 (10 VSS) capacitor c=1.79953e-18
C10 (\16\:B VSS) capacitor c=6.74483e-17
C11 (\11\:A VSS) capacitor c=5.43052e-17
C12 (\15\:A VSS) capacitor c=5.29641e-17
C13 (\8\:B VSS) capacitor c=6.33569e-17
C14 (\12\:B VSS) capacitor c=2.66662e-17
C15 (\4\:A VSS) capacitor c=2.42982e-17
C16 (\8\:A VSS) capacitor c=4.33458e-17
C17 (\1\:B VSS) capacitor c=4.74317e-17
C18 (\5\:B VSS) capacitor c=5.812e-17
C19 (\1\:A VSS) capacitor c=5.47336e-17
C20 (\2\:A VSS) capacitor c=9.54788e-16
C21 (\1\:Y VSS) capacitor c=6.76679e-16
C22 (\11\:Y VSS) capacitor c=1.72429e-17
C23 (\22\:Y VSS) capacitor c=2.33043e-17
C24 (\24\:Y VSS) capacitor c=1.16735e-16
C25 (\10\:Y VSS) capacitor c=1.17913e-16
C26 (\21\:Y VSS) capacitor c=1.17406e-16
Rk41 (\2\:VSS \3\:VSS) resistor r=0.4606 c=0
Rk42 (\3\:VSS \4\:VSS) resistor r=0.1896 c=0
Rk43 (\4\:VSS \5\:VSS) resistor r=0.2473 c=0
Rk45 (\6\:VSS VSS) resistor r=0.04974 c=0
Rk44 (\5\:VSS \6\:VSS) resistor r=0.3525 c=0
Rk47 (\3\:VSS \9\:VSS) resistor r=0.1262 c=0
Rk48 (\5\:VSS \11\:VSS) resistor r=0.1262 c=0
Rk49 (\6\:VSS \13\:VSS) resistor r=0.2827 c=0
Rk8 (\2\:A A) resistor r=0.01242 c=0
Rk15 (\1\:Y Y) resistor r=0.1688 c=0
Rk16 (Y \10\:Y) resistor r=0.6436 c=0
Rk17 (\10\:Y \12\:Y) resistor r=0.04664 c=0
Rk22 (\10\:Y \21\:Y) resistor r=0.5467 c=0
Rk23 (\21\:Y \23\:Y) resistor r=0.04664 c=0
Rk24 (\21\:Y \25\:Y) resistor r=0.7599 c=0
Rl20 (\2\:A \11\:A) resistor r=34.6466 c=0
Rl23 (\2\:A \15\:A) resistor r=34.3295 c=0
Rl9 (\2\:A \4\:A) resistor r=34.0954 c=0
Rl12 (\2\:A \8\:A) resistor r=34.7148 c=0
Rl1 (\2\:A \1\:A) resistor r=26.9231 c=0
Rl27 (B \16\:B) resistor r=76.7373 c=0
Rl15 (B \8\:B) resistor r=91.0296 c=0
Rl18 (B \12\:B) resistor r=75.8974 c=0
Rl3 (B \1\:B) resistor r=80.7323 c=0
Rl6 (B \5\:B) resistor r=81.9857 c=0
Rz7 (\8\:VSS \9\:VSS) resistor r=37.5 c=0
Rz8 (\10\:VSS \11\:VSS) resistor r=37.5 c=0
Rz9 (\12\:VSS \13\:VSS) resistor r=37.5 c=0
Rz1 (\12\:Y \11\:Y) resistor r=37.5 c=0
Rz2 (\23\:Y \22\:Y) resistor r=37.5 c=0
Rz3 (\25\:Y \24\:Y) resistor r=37.5 c=0
Ry16 (\1\:VSS VSS) resistor r=62 c=0
Ry14 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry15 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (6 \1\:A \12\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=1.86e-14 ps=9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.855e-06 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn1_1__rcx (\24\:Y \5\:B 6 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=5.89e-14 ps=7.4e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.75e-06 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn1 (\24\:Y \1\:B 7 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=2.635e-14 \
        ad=5.89e-14 ps=7.9e-07 pd=1e-06 nrd=1.16667 nrs=1.16667 sa=4.8e-07 \
        sb=1.515e-06 sd=160n sca=12.1492 scb=0.0116051 scc=0.000678556 \
        m=(1)
mn0 (7 \8\:A \10\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.26e-14 ad=2.635e-14 ps=1.3e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.385e-06 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn0_3__rcx (9 \15\:A \8\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.26e-14 ad=1.86e-14 ps=1.3e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.485e-06 sb=5.1e-07 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn0_2__rcx (8 \4\:A \10\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.26e-14 ad=7.905e-14 ps=1.3e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=1.12e-06 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn0_4__rcx (10 \11\:A \8\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.26e-14 ad=1.86e-14 ps=1.3e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-06 sb=2.45e-07 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn1_2__rcx (\22\:Y \12\:B 8 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=4.96e-14 ps=1.13e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=8.2e-07 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn1_3__rcx (\22\:Y \8\:B 9 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=6.15e-07 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mn1_4__rcx (\11\:Y \16\:B 10 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.34e-14 ps=7.4e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.855e-06 sb=1.4e-07 sd=160n sca=12.1492 \
        scb=0.0116051 scc=0.000678556 m=(1)
mp1 (\1\:Y B VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=6.305e-14 ps=1.1e-06 pd=1.10333e-06 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=2e-06 sd=160n sca=22.0088 scb=0.0203326 \
        scc=0.00163789 m=(6)
ends NAND2X6
// End of subcircuit definition.

// Generated for: spectre (May  9 15:49:12 2012 )
// Library name: gsclib045
// Cell name: NAND2X8
// View name: extracted

simulator lang=spectre

subckt NAND2X8 A B VDD VSS Y
mp0 (\4\:Y \2\:A VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=7.12e-14 ps=1.20429e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=27.8642 scb=0.0316804 \
        scc=0.00218972 m=(7)
C1 (B VSS) capacitor c=1.52251e-17
C2 (VDD VSS) capacitor c=6.69537e-16
C3 (A VSS) capacitor c=2.51578e-17
C4 (Y VSS) capacitor c=4.77352e-17
C5 (7 VSS) capacitor c=1.5146e-18
C6 (8 VSS) capacitor c=4.01751e-18
C7 (9 VSS) capacitor c=3.26021e-18
C8 (10 VSS) capacitor c=3.28164e-18
C9 (11 VSS) capacitor c=2.52434e-18
C10 (12 VSS) capacitor c=1.5146e-18
C11 (\1\:B VSS) capacitor c=1.06721e-15
C12 (\24\:B VSS) capacitor c=6.86429e-17
C13 (\21\:A VSS) capacitor c=5.16377e-17
C14 (\22\:A VSS) capacitor c=3.81755e-17
C15 (\20\:B VSS) capacitor c=4.3411e-17
C16 (\19\:B VSS) capacitor c=3.71461e-17
C17 (\11\:A VSS) capacitor c=3.20052e-17
C18 (\15\:A VSS) capacitor c=3.21115e-17
C19 (\13\:B VSS) capacitor c=3.70186e-17
C20 (\12\:B VSS) capacitor c=3.25366e-17
C21 (\9\:A VSS) capacitor c=2.81666e-17
C22 (\8\:A VSS) capacitor c=7.20918e-17
C23 (\6\:B VSS) capacitor c=5.90065e-17
C24 (\5\:B VSS) capacitor c=6.06253e-17
C25 (\1\:A VSS) capacitor c=5.18277e-17
C26 (\2\:A VSS) capacitor c=1.13162e-15
C27 (\1\:Y VSS) capacitor c=1.97549e-17
C28 (\13\:Y VSS) capacitor c=1.89373e-16
C29 (\28\:Y VSS) capacitor c=1.98109e-16
C30 (\30\:Y VSS) capacitor c=1.34972e-16
C31 (\3\:Y VSS) capacitor c=8.57004e-17
C32 (\4\:Y VSS) capacitor c=7.99722e-16
Rk49 (\2\:VSS \3\:VSS) resistor r=0.1848 c=0
Rk50 (\3\:VSS \4\:VSS) resistor r=0.3947 c=0
Rk51 (\4\:VSS \5\:VSS) resistor r=0.1697 c=0
Rk52 (\5\:VSS \6\:VSS) resistor r=0.2627 c=0
Rk54 (\7\:VSS VSS) resistor r=0.0498 c=0
Rk53 (\6\:VSS \7\:VSS) resistor r=0.3378 c=0
Rk56 (\3\:VSS \10\:VSS) resistor r=0.1866 c=0
Rk57 (\4\:VSS \12\:VSS) resistor r=0.1866 c=0
Rk58 (\6\:VSS \14\:VSS) resistor r=0.1854 c=0
Rk59 (\7\:VSS \16\:VSS) resistor r=0.3013 c=0
Rk9 (\1\:B B) resistor r=0.005605 c=0
Rk4 (\2\:A A) resistor r=0.03147 c=0
Rk11 (\3\:Y Y) resistor r=0.3219 c=0
Rk10 (\2\:Y \3\:Y) resistor r=0.07404 c=0
Rk12 (Y \4\:Y) resistor r=0.1435 c=0
Rk19 (\3\:Y \12\:Y) resistor r=0.5996 c=0
Rk20 (\12\:Y \14\:Y) resistor r=0.07404 c=0
Rk27 (\12\:Y \27\:Y) resistor r=0.7166 c=0
Rk28 (\27\:Y \29\:Y) resistor r=0.07404 c=0
Rk29 (\27\:Y \31\:Y) resistor r=0.7924 c=0
Rl39 (\1\:B \24\:B) resistor r=82.1429 c=0
Rl31 (\1\:B \20\:B) resistor r=90.0987 c=0
Rl30 (\1\:B \19\:B) resistor r=90.0987 c=0
Rl19 (\1\:B \13\:B) resistor r=90.0987 c=0
Rl18 (\1\:B \12\:B) resistor r=90.0987 c=0
Rl7 (\1\:B \6\:B) resistor r=90.0987 c=0
Rl6 (\1\:B \5\:B) resistor r=90.0987 c=0
Rl35 (\2\:A \21\:A) resistor r=37.3411 c=0
Rl36 (\2\:A \22\:A) resistor r=36.6367 c=0
Rl21 (\2\:A \11\:A) resistor r=34.7464 c=0
Rl24 (\2\:A \15\:A) resistor r=32.6324 c=0
Rl13 (\2\:A \9\:A) resistor r=38.5087 c=0
Rl12 (\2\:A \8\:A) resistor r=44.3957 c=0
Rl1 (\2\:A \1\:A) resistor r=24.7951 c=0
Rz9 (\9\:VSS \10\:VSS) resistor r=37.5 c=0
Rz10 (\11\:VSS \12\:VSS) resistor r=37.5 c=0
Rz11 (\13\:VSS \14\:VSS) resistor r=37.5 c=0
Rz12 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz1 (\2\:Y \1\:Y) resistor r=37.5 c=0
Rz2 (\14\:Y \13\:Y) resistor r=37.5 c=0
Rz3 (\29\:Y \28\:Y) resistor r=37.5 c=0
Rz4 (\31\:Y \30\:Y) resistor r=37.5 c=0
Ry18 (\1\:VSS VSS) resistor r=62 c=0
Ry16 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry17 (\1\:VSS \5\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (6 \1\:A \15\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.13e-14 ad=1.77e-14 ps=8.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=15.3363 scb=0.0149793 \
        scc=0.00123645 m=(1)
mn1_1__rcx (\30\:Y \5\:B 6 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=1.77e-14 ad=4.72e-14 ps=7.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=15.3363 scb=0.0149793 \
        scc=0.00123645 m=(1)
mn1_2__rcx (\30\:Y \6\:B 7 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=1.77e-14 ad=4.72e-14 ps=7.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=15.3363 scb=0.0149793 \
        scc=0.00123645 m=(1)
mn0_2__rcx (7 \8\:A \13\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=8.45e-14 ad=1.77e-14 ps=1.24e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2e-06 sd=160n sca=15.3363 scb=0.0149793 \
        scc=0.00123645 m=(1)
mn0_3__rcx (8 \9\:A \13\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=8.45e-14 ad=4.72e-14 ps=1.24e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.885e-06 sd=160n sca=15.3363 \
        scb=0.0149793 scc=0.00123645 m=(1)
mn0_6__rcx (11 \22\:A \9\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=7.27e-14 ad=2.95e-14 ps=1.16e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.1e-07 sd=160n sca=15.3363 scb=0.0149793 \
        scc=0.00123645 m=(1)
mn1_3__rcx (\28\:Y \12\:B 8 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.72e-14 ad=4.72e-14 ps=9.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=1.68e-06 sd=160n sca=15.3363 \
        scb=0.0149793 scc=0.00123645 m=(1)
mn1_4__rcx (\28\:Y \13\:B 9 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=3.835e-14 ad=4.72e-14 ps=8.5e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27e-06 sb=1.475e-06 sd=160n sca=15.3363 \
        scb=0.0149793 scc=0.00123645 m=(1)
mn0_4__rcx (9 \15\:A \11\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=7.27e-14 ad=3.835e-14 ps=1.16e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.3e-06 sd=160n sca=15.3363 \
        scb=0.0149793 scc=0.00123645 m=(1)
mn0_5__rcx (10 \11\:A \11\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=7.27e-14 ad=3.835e-14 ps=1.16e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.71e-06 sb=1.035e-06 sd=160n sca=15.3363 \
        scb=0.0149793 scc=0.00123645 m=(1)
mn1_5__rcx (\13\:Y \19\:B 10 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=3.835e-14 ad=4.72e-14 ps=8.5e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.885e-06 sb=8.6e-07 sd=160n sca=15.3363 \
        scb=0.0149793 scc=0.00123645 m=(1)
mn1_6__rcx (\13\:Y \20\:B 11 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=2.95e-14 ad=4.72e-14 ps=7.9e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.55e-07 sd=160n sca=15.3363 scb=0.0149793 \
        scc=0.00123645 m=(1)
mn0 (12 \21\:A \9\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=7.27e-14 ad=1.77e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=15.3363 scb=0.0149793 \
        scc=0.00123645 m=(1)
mn1 (\1\:Y \24\:B 12 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=1.77e-14 ad=4.13e-14 ps=7.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.3363 scb=0.0149793 \
        scc=0.00123645 m=(1)
mp1 (\4\:Y \1\:B VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=7.12e-14 ps=1.20429e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=17.8304 scb=0.0170078 \
        scc=0.000825102 m=(7)
ends NAND2X8
// End of subcircuit definition.

// Generated for: spectre (May  8 15:13:23 2012 )
// Library name: gsclib045
// Cell name: NAND2XL
// View name: extracted

simulator lang=spectre

subckt NAND2XL A B VDD VSS Y
mp0 (\3\:Y \3\:A \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.618e-14 ad=3.44e-14 ps=1.31e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35e-07 sb=3.4e-07 sd=160n sca=34.4364 \
        scb=0.0404765 scc=0.00269477 m=(1)
C1 (B VSS) capacitor c=2.71641e-17
C2 (VDD VSS) capacitor c=4.30624e-17
C3 (A VSS) capacitor c=2.70756e-17
C4 (\1\:B VSS) capacitor c=2.87969e-17
C5 (\3\:A VSS) capacitor c=3.68575e-17
C6 (\3\:B VSS) capacitor c=4.789e-17
C7 (\1\:A VSS) capacitor c=3.675e-17
C8 (\2\:B VSS) capacitor c=4.4863e-17
C9 (\2\:A VSS) capacitor c=5.14503e-17
C10 (\1\:VDD VSS) capacitor c=2.03659e-17
C11 (\3\:Y VSS) capacitor c=6.08143e-17
C12 (\5\:VDD VSS) capacitor c=3.11241e-18
C13 (\1\:Y VSS) capacitor c=8.9608e-17
C14 (\4\:A VSS) capacitor c=3.47778e-17
C15 (\4\:B VSS) capacitor c=5.2765e-17
C16 (\4\:VDD VSS) capacitor c=1.19557e-17
Rk9 (\3\:VSS VSS) resistor r=0.01706 c=0
Rk10 (\3\:VSS \5\:VSS) resistor r=0.2976 c=0
Rk2 (\4\:B B) resistor r=0.03695 c=0
Rk6 (\4\:VDD VDD) resistor r=0.1001 c=0
Rk5 (\2\:VDD \4\:VDD) resistor r=0.2592 c=0
Rk7 (VDD \6\:VDD) resistor r=0.1677 c=0
Rk1 (\4\:A A) resistor r=0.05013 c=0
Rk3 (Y \2\:Y) resistor r=0.002476 c=0
Rk4 (\2\:Y \4\:Y) resistor r=0.5783 c=0
Rl3 (\1\:B \2\:B) resistor r=65.3846 c=0
Rl4 (\2\:B \3\:B) resistor r=83.7912 c=0
Rl2 (\2\:A \3\:A) resistor r=114.56 c=0
Rl1 (\1\:A \2\:A) resistor r=26.098 c=0
Rz3 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
mn0 (n0 \1\:A \4\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn1 (\1\:Y \3\:B n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 scb=0.0129007 \
        scc=0.000589158 m=(1)
mp1 (\3\:Y \1\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.618e-14 ad=3.44e-14 ps=1.31e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.4e-07 sb=1.35e-07 sd=160n sca=34.4364 \
        scb=0.0404765 scc=0.00269477 m=(1)
ends NAND2XL
// End of subcircuit definition.

// Generated for: spectre (May  9 15:50:26 2012 )
// Library name: gsclib045
// Cell name: NAND3BX1
// View name: extracted

simulator lang=spectre

subckt NAND3BX1 AN B C VDD VSS Y
mp3 (\6\:Y \3\:C \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.82308e-07 sd=160n sca=19.3275 \
        scb=0.0211052 scc=0.000636468 m=(1)
C1 (B VSS) capacitor c=5.06617e-17
C2 (C VSS) capacitor c=3.97111e-17
C3 (VDD VSS) capacitor c=1.15838e-16
C4 (Y VSS) capacitor c=1.03157e-16
C5 (AN VSS) capacitor c=4.34864e-17
C6 (n0 VSS) capacitor c=6.19161e-17
C7 (\1\:AN VSS) capacitor c=3.85992e-17
C8 (\1\:B VSS) capacitor c=5.52944e-17
C9 (\3\:C VSS) capacitor c=4.583e-17
C10 (\3\:AN VSS) capacitor c=3.63924e-17
C11 (\3\:n0 VSS) capacitor c=5.19525e-17
C12 (\3\:B VSS) capacitor c=6.3295e-17
C13 (\1\:C VSS) capacitor c=4.79944e-17
C14 (\2\:AN VSS) capacitor c=4.74572e-17
C15 (\2\:n0 VSS) capacitor c=5.76256e-17
C16 (\2\:B VSS) capacitor c=5.41434e-17
C17 (\2\:C VSS) capacitor c=4.4597e-17
C18 (\4\:n0 VSS) capacitor c=5.35519e-17
C19 (\7\:VDD VSS) capacitor c=4.15717e-17
C20 (\1\:Y VSS) capacitor c=9.75274e-17
C21 (\9\:VDD VSS) capacitor c=6.90742e-17
C22 (\6\:Y VSS) capacitor c=2.99542e-17
C23 (\1\:VDD VSS) capacitor c=2.78331e-17
C24 (\8\:n0 VSS) capacitor c=1.57105e-17
C25 (\4\:Y VSS) capacitor c=7.60771e-17
C26 (\4\:C VSS) capacitor c=8.70378e-17
C27 (\5\:B VSS) capacitor c=4.70027e-17
C28 (\4\:AN VSS) capacitor c=4.83544e-17
C29 (\6\:n0 VSS) capacitor c=6.26226e-17
C30 (\7\:n0 VSS) capacitor c=5.79488e-17
C31 (\3\:VDD VSS) capacitor c=1.67359e-18
C32 (\5\:VDD VSS) capacitor c=3.21594e-18
Rk4 (B \5\:B) resistor r=0.02394 c=0
Rk21 (\4\:VSS VSS) resistor r=0.2503 c=0
Rk20 (\2\:VSS \4\:VSS) resistor r=0.3462 c=0
Rk1 (C \4\:C) resistor r=0.1137 c=0
Rk13 (\2\:VDD \3\:VDD) resistor r=0.105 c=0
Rk14 (\3\:VDD \4\:VDD) resistor r=0.09502 c=0
Rk15 (\4\:VDD \5\:VDD) resistor r=0.1101 c=0
Rk17 (\6\:VDD VDD) resistor r=0.04986 c=0
Rk16 (\5\:VDD \6\:VDD) resistor r=0.09001 c=0
Rk18 (\3\:VDD \8\:VDD) resistor r=0.2363 c=0
Rk19 (\5\:VDD \10\:VDD) resistor r=0.2492 c=0
Rk6 (\3\:Y Y) resistor r=0.04558 c=0
Rk5 (\2\:Y \3\:Y) resistor r=0.4817 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.4932 c=0
Rk8 (Y \7\:Y) resistor r=0.1337 c=0
Rk9 (AN \4\:AN) resistor r=0.09311 c=0
Rk10 (\5\:n0 \6\:n0) resistor r=0.4199 c=0
Rk11 (\6\:n0 \7\:n0) resistor r=0.2802 c=0
Rk12 (\6\:n0 \9\:n0) resistor r=0.08538 c=0
Rl3 (\1\:B \2\:B) resistor r=75.6918 c=0
Rl4 (\2\:B \3\:B) resistor r=94.9225 c=0
Rl2 (\2\:C \3\:C) resistor r=79.9451 c=0
Rl1 (\1\:C \2\:C) resistor r=92.3077 c=0
Rl7 (\1\:AN \2\:AN) resistor r=84.6154 c=0
Rl8 (\2\:AN \3\:AN) resistor r=87.5194 c=0
Rl5 (n0 \2\:n0) resistor r=103.378 c=0
Rl6 (\2\:n0 \3\:n0) resistor r=68.5619 c=0
Rz6 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VDD \6\:VDD) resistor r=37.5 c=0
Rz1 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry5 (\9\:VDD \10\:VDD) resistor r=31 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry2 (\6\:Y \7\:Y) resistor r=31 c=0
Ry3 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx2 (\2\:B \5\:B) resistor r=45 c=0
Rx1 (\2\:C \4\:C) resistor r=45 c=0
Rx3 (\2\:AN \4\:AN) resistor r=45 c=0
Rx4 (\2\:n0 \7\:n0) resistor r=45 c=0
mn3 (\4\:Y \1\:C n2 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.73e-14 \
        ad=3.64e-14 ps=7.3e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 sa=1.4e-07 \
        sb=5.81058e-07 sd=160n sca=11.0409 scb=0.0104003 scc=0.000454168 \
        m=(1)
mn2 (n1 \3\:B n2 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.73e-14 \
        ad=2.99e-14 ps=7.3e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.9e-07 sb=4.31058e-07 sd=160n sca=11.0409 scb=0.0104003 \
        scc=0.000454168 m=(1)
mn1 (n1 \3\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.99e-14 ps=9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2.71058e-07 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(1)
mn0 (\8\:n0 \3\:AN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.85e-07 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mp2 (\1\:Y \1\:B \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=4.77308e-07 sd=160n sca=14.532 \
        scb=0.0121946 scc=0.000242813 m=(1)
mp1 (\1\:Y n0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.643e-14 ad=6.24e-14 ps=1.17e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2.72308e-07 sd=160n sca=14.3198 \
        scb=0.0117685 scc=0.000238368 m=(1)
mp0 (\4\:n0 \1\:AN \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.643e-14 ad=3.01e-14 ps=1.17e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=20.3233 \
        scb=0.0227744 scc=0.000772584 m=(1)
ends NAND3BX1
// End of subcircuit definition.

// Generated for: spectre (May  9 15:51:03 2012 )
// Library name: gsclib045
// Cell name: NAND3BX2
// View name: extracted

simulator lang=spectre

subckt NAND3BX2 AN B C VDD VSS Y
mp1 (\1\:Y \2\:n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.997e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.32109e-06 sd=160n sca=25.2782 \
        scb=0.0260046 scc=0.0018836 m=(2)
C1 (Y VSS) capacitor c=9.56339e-17
C2 (B VSS) capacitor c=4.06427e-16
C3 (C VSS) capacitor c=8.25503e-17
C4 (VDD VSS) capacitor c=7.47479e-17
C5 (AN VSS) capacitor c=1.12396e-16
C6 (8 VSS) capacitor c=4.52973e-18
C7 (n0 VSS) capacitor c=3.98999e-17
C8 (9 VSS) capacitor c=4.76826e-18
C9 (10 VSS) capacitor c=6.63251e-18
C10 (11 VSS) capacitor c=3.95926e-18
C11 (\1\:AN VSS) capacitor c=2.90462e-17
C12 (\1\:C VSS) capacitor c=1.0186e-16
C13 (\3\:AN VSS) capacitor c=4.09002e-17
C14 (\6\:n0 VSS) capacitor c=4.89436e-17
C15 (\6\:B VSS) capacitor c=4.60257e-17
C16 (\6\:C VSS) capacitor c=3.24691e-17
C17 (\4\:C VSS) capacitor c=3.12613e-17
C18 (\3\:B VSS) capacitor c=5.5144e-17
C19 (\2\:AN VSS) capacitor c=3.20563e-17
C20 (\2\:n0 VSS) capacitor c=4.61382e-16
C21 (\7\:n0 VSS) capacitor c=4.93425e-17
C22 (\1\:Y VSS) capacitor c=1.99397e-16
C23 (\6\:Y VSS) capacitor c=3.40038e-17
C24 (\1\:VDD VSS) capacitor c=1.27766e-16
C25 (\9\:n0 VSS) capacitor c=5.59169e-17
C26 (\9\:Y VSS) capacitor c=1.31444e-16
C27 (\3\:C VSS) capacitor c=2.56971e-17
C28 (\7\:C VSS) capacitor c=4.79566e-17
C29 (\5\:VDD VSS) capacitor c=8.86363e-17
Rk8 (\1\:Y Y) resistor r=0.06436 c=0
Rk9 (\1\:Y \7\:Y) resistor r=0.05786 c=0
Rk11 (Y \10\:Y) resistor r=0.9641 c=0
Rk3 (\7\:C C) resistor r=0.006301 c=0
Rk18 (\1\:VDD \4\:VDD) resistor r=0.1173 c=0
Rk22 (\5\:VDD \1\:VDD) resistor r=0.1023 c=0
Rk19 (\4\:VDD \5\:VDD) resistor r=0.08756 c=0
Rk31 (\3\:VSS VSS) resistor r=0.0663 c=0
Rk30 (\2\:VSS \3\:VSS) resistor r=0.0433 c=0
Rk32 (\3\:VSS \5\:VSS) resistor r=0.3323 c=0
Rk33 (\5\:VSS \7\:VSS) resistor r=0.4632 c=0
Rk12 (AN \4\:AN) resistor r=0.01842 c=0
Rk14 (\10\:n0 \2\:n0) resistor r=0.2267 c=0
Rk13 (\8\:n0 \10\:n0) resistor r=0.4049 c=0
Rl11 (B \6\:B) resistor r=44.9225 c=0
Rl4 (B \3\:B) resistor r=33.3841 c=0
Rl6 (\3\:C \1\:C) resistor r=24.6542 c=0
Rl9 (\3\:C \6\:C) resistor r=82.1768 c=0
Rl7 (\3\:C \4\:C) resistor r=32.7557 c=0
Rl14 (\1\:AN \2\:AN) resistor r=30.7692 c=0
Rl15 (\2\:AN \3\:AN) resistor r=95.3297 c=0
Rl1 (\2\:n0 n0) resistor r=24.7951 c=0
Rl13 (\2\:n0 \6\:n0) resistor r=39.5604 c=0
Rz1 (\10\:Y \9\:Y) resistor r=75 c=0
Rz7 (VDD \1\:VDD) resistor r=0.04716 c=0
Rz8 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz9 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (\10\:n0 \9\:n0) resistor r=75 c=0
Ry3 (\7\:Y \6\:Y) resistor r=31 c=0
Ry5 (\8\:n0 \7\:n0) resistor r=62 c=0
Rx1 (\7\:C \1\:C) resistor r=45 c=0
Rx4 (\2\:AN \4\:AN) resistor r=45 c=0
mn1 (8 n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=7.12e-14 \
        ad=2.34e-14 ps=1.31e-06 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.7e-07 sb=1.18106e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn2 (8 \3\:B 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=2.34e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.05e-07 sb=1.04606e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn3 (\9\:Y \4\:C 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.99e-14 \
        ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.65e-07 sb=8.86058e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn3_1__rcx (\9\:Y \6\:C 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=4.16e-14 ps=9.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=6.81058e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn2_1__rcx (10 \6\:B 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.73e-14 ad=5.59e-14 ps=7.3e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=4.21058e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_1__rcx (11 \6\:n0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.73e-14 ps=9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08e-06 sb=2.71058e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0 (\9\:n0 \3\:AN \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.315e-06 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp2 (\1\:Y B \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.11609e-06 sd=160n sca=20.5883 \
        scb=0.0179916 scc=0.00160367 m=(2)
mp3 (\6\:Y \1\:C \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=9.0109e-07 sd=160n sca=19.0783 \
        scb=0.0162806 scc=0.00159629 m=(2)
mp0 (\7\:n0 \1\:AN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.655e-14 ps=1.16e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41e-06 sb=1.7e-07 sd=160n sca=35.6104 \
        scb=0.0382002 scc=0.00366805 m=(1)
ends NAND3BX2
// End of subcircuit definition.

// Generated for: spectre (May  9 15:51:42 2012 )
// Library name: gsclib045
// Cell name: NAND3BX4
// View name: extracted

simulator lang=spectre

subckt NAND3BX4 AN B C VDD VSS Y
mp1 (\1\:Y \2\:n0 VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.9235 scb=0.0274556 \
        scc=0.0014135 m=(4)
C1 (Y VSS) capacitor c=8.68998e-17
C2 (B VSS) capacitor c=8.31864e-16
C3 (C VSS) capacitor c=5.21786e-16
C4 (AN VSS) capacitor c=5.84853e-17
C5 (VDD VSS) capacitor c=5.65497e-16
C6 (8 VSS) capacitor c=3.11501e-18
C7 (n0 VSS) capacitor c=5.1633e-17
C8 (9 VSS) capacitor c=4.39052e-18
C9 (10 VSS) capacitor c=3.54276e-18
C10 (11 VSS) capacitor c=3.17329e-18
C11 (12 VSS) capacitor c=5.46912e-18
C12 (13 VSS) capacitor c=2.26498e-18
C13 (\1\:AN VSS) capacitor c=5.07362e-17
C14 (\3\:AN VSS) capacitor c=3.51362e-17
C15 (\12\:n0 VSS) capacitor c=6.14392e-17
C16 (\13\:B VSS) capacitor c=5.09485e-17
C17 (\11\:C VSS) capacitor c=2.95873e-17
C18 (\12\:C VSS) capacitor c=3.69331e-17
C19 (\9\:B VSS) capacitor c=6.00437e-17
C20 (\9\:n0 VSS) capacitor c=2.90521e-17
C21 (\7\:n0 VSS) capacitor c=5.18488e-17
C22 (\6\:B VSS) capacitor c=6.19973e-17
C23 (\6\:C VSS) capacitor c=2.56169e-17
C24 (\4\:C VSS) capacitor c=3.74581e-17
C25 (\3\:B VSS) capacitor c=4.79336e-17
C26 (\2\:AN VSS) capacitor c=3.55018e-17
C27 (\2\:n0 VSS) capacitor c=8.32574e-16
C28 (\17\:n0 VSS) capacitor c=6.94782e-17
C29 (\1\:Y VSS) capacitor c=6.21803e-16
C30 (\1\:VDD VSS) capacitor c=7.64301e-17
C31 (\13\:n0 VSS) capacitor c=4.3446e-17
C32 (\20\:Y VSS) capacitor c=1.13393e-16
C33 (\18\:Y VSS) capacitor c=1.23524e-16
C34 (\6\:n0 VSS) capacitor c=2.80618e-17
C35 (\4\:AN VSS) capacitor c=4.70066e-17
C36 (\15\:n0 VSS) capacitor c=5.65978e-17
Rk12 (\1\:Y Y) resistor r=0.6276 c=0
Rk18 (Y \19\:Y) resistor r=0.4544 c=0
Rk19 (\19\:Y \21\:Y) resistor r=0.8456 c=0
Rk43 (\2\:VSS \3\:VSS) resistor r=0.1353 c=0
Rk44 (\3\:VSS \4\:VSS) resistor r=0.567 c=0
Rk46 (\5\:VSS VSS) resistor r=0.5949 c=0
Rk45 (\4\:VSS \5\:VSS) resistor r=0.05752 c=0
Rk48 (\3\:VSS \8\:VSS) resistor r=0.2323 c=0
Rk49 (\5\:VSS \10\:VSS) resistor r=0.1032 c=0
Rk50 (VSS \12\:VSS) resistor r=0.1326 c=0
Rk20 (\4\:AN AN) resistor r=0.1101 c=0
Rk27 (\2\:VDD VDD) resistor r=0.1077 c=0
Rk22 (\15\:n0 \2\:n0) resistor r=0.2546 c=0
Rk21 (\14\:n0 \15\:n0) resistor r=0.3639 c=0
Rk23 (\15\:n0 \18\:n0) resistor r=0.1074 c=0
Rl26 (B \13\:B) resistor r=95.0334 c=0
Rl18 (B \9\:B) resistor r=75.6918 c=0
Rl11 (B \6\:B) resistor r=87.2302 c=0
Rl4 (B \3\:B) resistor r=29.5379 c=0
Rl22 (C \11\:C) resistor r=76.0994 c=0
Rl23 (C \12\:C) resistor r=26.3736 c=0
Rl9 (C \6\:C) resistor r=24.2328 c=0
Rl7 (C \4\:C) resistor r=105.323 c=0
Rl29 (\1\:AN \2\:AN) resistor r=100 c=0
Rl30 (\2\:AN \3\:AN) resistor r=53.022 c=0
Rl1 (\2\:n0 n0) resistor r=97.872 c=0
Rl28 (\2\:n0 \12\:n0) resistor r=122.253 c=0
Rl16 (\6\:n0 \9\:n0) resistor r=33.2809 c=0
Rl14 (\6\:n0 \7\:n0) resistor r=110.401 c=0
Rl13 (\6\:n0 \2\:n0) resistor r=44.0838 c=0
Rz1 (\19\:Y \18\:Y) resistor r=75 c=0
Rz2 (\21\:Y \20\:Y) resistor r=75 c=0
Rz8 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz9 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz10 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz7 (VDD \1\:VDD) resistor r=5.7692 c=0
Rz4 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz3 (\14\:n0 \13\:n0) resistor r=75 c=0
Ry17 (\1\:VSS VSS) resistor r=62 c=0
Ry15 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry16 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry7 (\18\:n0 \17\:n0) resistor r=20.6667 c=0
Rx7 (\2\:AN \4\:AN) resistor r=45 c=0
mn1_1__rcx (8 n0 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.24e-14 ad=2.34e-14 ps=1.33e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn2_1__rcx (8 \3\:B 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=2.34e-14 ps=8.4e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn3_1__rcx (\18\:Y \4\:C 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn3_2__rcx (\18\:Y \6\:C 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=4.16e-14 ps=7.9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.93e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2_2__rcx (10 \6\:B 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=3.51e-14 ps=7.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=1.75e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn1_2__rcx (11 \7\:n0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=2.99e-14 ps=1.43e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.055e-06 sb=1.59e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn1_3__rcx (12 \9\:n0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=4.42e-14 ps=1.43e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32e-06 sb=1.325e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2_3__rcx (12 \9\:B 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.08e-14 ad=4.42e-14 ps=6.8e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=1.11e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3_3__rcx (\20\:Y \12\:C 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.08e-14 ad=4.16e-14 ps=6.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.66e-06 sb=9.85e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3 (\20\:Y \11\:C 14 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.16e-14 ps=1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.865e-06 sb=7.8e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2 (14 \13\:B 15 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.73e-14 \
        ad=6.24e-14 ps=7.3e-07 pd=1e-06 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=4.95e-07 sd=160n sca=10.79 scb=0.0100512 scc=0.000418069 m=(1)
mn1 (15 \12\:n0 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=2.73e-14 ps=8.4e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn0 (\13\:n0 \3\:AN \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mp2 (\1\:Y B VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=2e-06 sd=160n sca=15.882 scb=0.0147893 \
        scc=0.000504893 m=(4)
mp3 (\1\:Y C VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.5e-07 sb=2e-06 sd=160n sca=13.8083 scb=0.0118505 \
        scc=0.000478838 m=(4)
mp0 (\17\:n0 \1\:AN VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=18.9839 scb=0.0202117 \
        scc=0.000700179 m=(1)
ends NAND3BX4
// End of subcircuit definition.

// Generated for: spectre (May  8 15:14:11 2012 )
// Library name: gsclib045
// Cell name: NAND3BXL
// View name: extracted

simulator lang=spectre

subckt NAND3BXL AN B C VDD VSS Y
mp3 (\3\:Y \3\:C \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.9e-14 ad=2.63e-14 ps=1.53e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=7.17326e-07 sd=160n sca=26.1913 \
        scb=0.0299385 scc=0.0017385 m=(1)
C1 (B VSS) capacitor c=3.84338e-17
C2 (Y VSS) capacitor c=1.46371e-17
C3 (C VSS) capacitor c=2.24714e-17
C4 (VDD VSS) capacitor c=1.00908e-16
C5 (n0 VSS) capacitor c=6.41911e-17
C6 (\1\:AN VSS) capacitor c=3.9175e-17
C7 (\1\:B VSS) capacitor c=5.14392e-17
C8 (\3\:C VSS) capacitor c=5.18334e-17
C9 (\3\:AN VSS) capacitor c=3.69713e-17
C10 (\3\:n0 VSS) capacitor c=2.97621e-17
C11 (\3\:B VSS) capacitor c=4.68893e-17
C12 (\1\:C VSS) capacitor c=2.75064e-17
C13 (\2\:AN VSS) capacitor c=4.63904e-17
C14 (\2\:n0 VSS) capacitor c=5.79854e-17
C15 (\2\:B VSS) capacitor c=5.25334e-17
C16 (\2\:C VSS) capacitor c=4.4065e-17
C17 (\4\:n0 VSS) capacitor c=5.03058e-17
C18 (\1\:VDD VSS) capacitor c=2.13852e-17
C19 (\1\:Y VSS) capacitor c=4.0649e-17
C20 (\6\:VDD VSS) capacitor c=1.24286e-17
C21 (\3\:Y VSS) capacitor c=4.21405e-17
C22 (\8\:n0 VSS) capacitor c=1.87482e-17
C23 (\5\:Y VSS) capacitor c=6.71509e-17
C24 (\4\:C VSS) capacitor c=4.86386e-17
C25 (\4\:B VSS) capacitor c=2.77944e-17
C26 (\4\:AN VSS) capacitor c=6.74569e-17
C27 (\6\:AN VSS) capacitor c=4.63647e-17
C28 (\6\:n0 VSS) capacitor c=4.90514e-17
C29 (\7\:n0 VSS) capacitor c=4.78232e-17
C30 (\4\:VDD VSS) capacitor c=6.08763e-18
C31 (\5\:VDD VSS) capacitor c=1.58864e-18
Rk2 (B \4\:B) resistor r=0.02441 c=0
Rk17 (\4\:VSS VSS) resistor r=0.2003 c=0
Rk16 (\2\:VSS \4\:VSS) resistor r=0.4089 c=0
Rk5 (\4\:Y Y) resistor r=0.05294 c=0
Rk3 (\2\:Y \4\:Y) resistor r=0.2876 c=0
Rk4 (\4\:Y \6\:Y) resistor r=0.4768 c=0
Rk1 (C \4\:C) resistor r=0.02587 c=0
Rk6 (\4\:AN \5\:AN) resistor r=0.006173 c=0
Rk7 (AN \6\:AN) resistor r=0.00607 c=0
Rk8 (\4\:AN \6\:AN) resistor r=0.06409 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.1386 c=0
Rk14 (\5\:VDD VDD) resistor r=0.1176 c=0
Rk13 (\4\:VDD \5\:VDD) resistor r=0.08023 c=0
Rk15 (\5\:VDD \7\:VDD) resistor r=0.05128 c=0
Rk9 (\5\:n0 \6\:n0) resistor r=0.3387 c=0
Rk10 (\6\:n0 \7\:n0) resistor r=0.1884 c=0
Rk11 (\6\:n0 \9\:n0) resistor r=0.1249 c=0
Rl3 (\1\:B \2\:B) resistor r=75.6918 c=0
Rl4 (\2\:B \3\:B) resistor r=94.9225 c=0
Rl2 (\2\:C \3\:C) resistor r=129.319 c=0
Rl1 (\1\:C \2\:C) resistor r=38.3096 c=0
Rl7 (\1\:AN \2\:AN) resistor r=68.4057 c=0
Rl8 (\2\:AN \3\:AN) resistor r=95.3288 c=0
Rl5 (n0 \2\:n0) resistor r=137.637 c=0
Rl6 (\2\:n0 \3\:n0) resistor r=26.098 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz1 (\5\:Y \6\:Y) resistor r=75 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry2 (\3\:Y \4\:Y) resistor r=62 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry3 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\2\:C \4\:C) resistor r=45 c=0
Rx3 (\2\:AN \5\:AN) resistor r=45 c=0
Rx4 (\2\:n0 \7\:n0) resistor r=45 c=0
mn3 (\5\:Y \1\:C n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=2.03e-14 ps=5.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.15e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn2 (n1 \3\:B n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=1.957e-14 \
        ad=2.102e-14 ps=5.6e-07 pd=5.8e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.2e-07 sb=5.35e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn1 (n1 \3\:n0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.102e-14 ps=6.1e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn0 (\8\:n0 \3\:AN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mp2 (\1\:Y \1\:B \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.9e-14 ad=3.44e-14 ps=1.53e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.17326e-07 sb=5.22326e-07 sd=160n sca=17.2808 \
        scb=0.0163439 scc=0.000383193 m=(1)
mp1 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.83e-14 ad=3.44e-14 ps=1.52e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.22326e-07 sb=3.17326e-07 sd=160n sca=17.2808 \
        scb=0.0163439 scc=0.000383193 m=(1)
mp0 (\4\:n0 \1\:AN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.83e-14 ad=2.63e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.17326e-07 sb=1.22326e-07 sd=160n sca=26.1913 \
        scb=0.0299385 scc=0.0017385 m=(1)
ends NAND3BXL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:15:00 2012 )
// Library name: gsclib045
// Cell name: NAND3X1
// View name: extracted

simulator lang=spectre

subckt NAND3X1 A B C VDD VSS Y
mp0 (\4\:Y \1\:A \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=25.4535 \
        scb=0.0286798 scc=0.00163825 m=(1)
C1 (C VSS) capacitor c=2.04013e-17
C2 (VDD VSS) capacitor c=7.74681e-17
C3 (Y VSS) capacitor c=6.14524e-18
C4 (B VSS) capacitor c=1.96774e-17
C5 (n1 VSS) capacitor c=3.35995e-18
C6 (\1\:C VSS) capacitor c=4.92231e-17
C7 (\1\:B VSS) capacitor c=5.76847e-17
C8 (\1\:A VSS) capacitor c=3.61639e-17
C9 (\3\:C VSS) capacitor c=4.61067e-17
C10 (\3\:B VSS) capacitor c=6.41878e-17
C11 (\3\:A VSS) capacitor c=4.30211e-17
C12 (\2\:C VSS) capacitor c=4.08304e-17
C13 (\2\:B VSS) capacitor c=4.8777e-17
C14 (\2\:A VSS) capacitor c=3.84925e-17
C15 (\6\:Y VSS) capacitor c=3.96567e-17
C16 (\1\:VDD VSS) capacitor c=6.80735e-17
C17 (\4\:Y VSS) capacitor c=8.23938e-17
C18 (\5\:VDD VSS) capacitor c=4.6962e-17
C19 (\1\:Y VSS) capacitor c=8.30142e-17
C20 (\5\:A VSS) capacitor c=1.71278e-17
C21 (\6\:A VSS) capacitor c=3.06625e-17
C22 (\4\:B VSS) capacitor c=2.9002e-17
C23 (\4\:C VSS) capacitor c=6.54631e-17
C24 (\3\:Y VSS) capacitor c=5.25966e-17
C25 (\4\:VDD VSS) capacitor c=2.62883e-17
Rk1 (\4\:A \5\:A) resistor r=0.009432 c=0
Rk2 (A \6\:A) resistor r=0.009274 c=0
Rk3 (\4\:A \6\:A) resistor r=0.0314 c=0
Rk14 (VSS \4\:VSS) resistor r=0.3197 c=0
Rk5 (C \4\:C) resistor r=0.02186 c=0
Rk11 (\4\:VDD VDD) resistor r=0.2001 c=0
Rk10 (\2\:VDD \4\:VDD) resistor r=0.2926 c=0
Rk12 (VDD \6\:VDD) resistor r=0.2441 c=0
Rk8 (\3\:Y Y) resistor r=0.05218 c=0
Rk6 (\2\:Y \3\:Y) resistor r=0.4304 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.386 c=0
Rk9 (Y \7\:Y) resistor r=0.06453 c=0
Rk4 (B \4\:B) resistor r=0.02903 c=0
Rl1 (\1\:A \2\:A) resistor r=26.098 c=0
Rl2 (\2\:A \3\:A) resistor r=114.56 c=0
Rl5 (\1\:C \2\:C) resistor r=127.402 c=0
Rl6 (\2\:C \3\:C) resistor r=26.3736 c=0
Rl3 (\1\:B \2\:B) resistor r=75.6918 c=0
Rl4 (\2\:B \3\:B) resistor r=71.8456 c=0
Rz3 (\3\:VSS \4\:VSS) resistor r=37.5 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry4 (\5\:VDD \6\:VDD) resistor r=31 c=0
Ry1 (\4\:Y \5\:Y) resistor r=31 c=0
Ry2 (\6\:Y \7\:Y) resistor r=31 c=0
Rx1 (\2\:A \5\:A) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
mn0 (n0 \3\:A \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.15e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn1 (n0 \3\:B n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.82e-14 \
        ad=4.16e-14 ps=6.6e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=3.1e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mn2 (\1\:Y \3\:C n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.82e-14 \
        ad=5.07e-14 ps=6.6e-07 pd=9.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.6e-07 sb=1.95e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mp1 (\4\:Y \1\:B \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=16.4103 \
        scb=0.0148066 scc=0.000275039 m=(1)
mp2 (\6\:Y \1\:C \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=16.6925 \
        scb=0.0153965 scc=0.00029244 m=(1)
ends NAND3X1
// End of subcircuit definition.

// Generated for: spectre (May  9 15:53:35 2012 )
// Library name: gsclib045
// Cell name: NAND3X2
// View name: extracted

simulator lang=spectre

subckt NAND3X2 A B C VDD VSS Y
mp0 (\1\:Y \2\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.165e-06 sd=160n sca=26.6291 \
        scb=0.0267491 scc=0.00213017 m=(2)
C1 (Y VSS) capacitor c=8.92927e-17
C2 (C VSS) capacitor c=5.71526e-17
C3 (A VSS) capacitor c=1.49412e-17
C4 (B VSS) capacitor c=3.05806e-17
C5 (VDD VSS) capacitor c=6.08897e-17
C6 (7 VSS) capacitor c=3.65106e-18
C7 (8 VSS) capacitor c=6.62718e-18
C8 (9 VSS) capacitor c=4.80329e-18
C9 (10 VSS) capacitor c=4.56737e-18
C10 (\1\:B VSS) capacitor c=3.69808e-16
C11 (\6\:A VSS) capacitor c=4.41234e-17
C12 (\6\:B VSS) capacitor c=6.03632e-17
C13 (\1\:C VSS) capacitor c=4.92942e-17
C14 (\5\:C VSS) capacitor c=2.38554e-17
C15 (\3\:B VSS) capacitor c=4.73636e-17
C16 (\1\:A VSS) capacitor c=3.70321e-17
C17 (\3\:C VSS) capacitor c=9.23665e-17
C18 (\2\:A VSS) capacitor c=4.08111e-16
C19 (\1\:Y VSS) capacitor c=2.08989e-16
C20 (\9\:Y VSS) capacitor c=3.46727e-17
C21 (\1\:VDD VSS) capacitor c=1.26576e-16
C22 (\7\:Y VSS) capacitor c=1.3205e-16
C23 (\2\:C VSS) capacitor c=1.60637e-17
C24 (\7\:C VSS) capacitor c=6.50072e-17
C25 (\5\:VDD VSS) capacitor c=9.04403e-17
Rk9 (\1\:Y Y) resistor r=0.2013 c=0
Rk10 (Y \8\:Y) resistor r=0.9494 c=0
Rk11 (\1\:Y \10\:Y) resistor r=0.05797 c=0
Rk1 (C \7\:C) resistor r=0.03835 c=0
Rk5 (\2\:A A) resistor r=0.01817 c=0
Rk25 (\2\:VSS \4\:VSS) resistor r=0.2839 c=0
Rk27 (\5\:VSS VSS) resistor r=0.06726 c=0
Rk26 (\4\:VSS \5\:VSS) resistor r=0.3333 c=0
Rk29 (\5\:VSS \8\:VSS) resistor r=0.2196 c=0
Rk2 (B \1\:B) resistor r=0.08407 c=0
Rk17 (\5\:VDD \1\:VDD) resistor r=0.04861 c=0
Rl5 (\2\:C \1\:C) resistor r=100.426 c=0
Rl8 (\2\:C \5\:C) resistor r=35.772 c=0
Rl6 (\2\:C \3\:C) resistor r=54.2356 c=0
Rl13 (\2\:A \6\:A) resistor r=24.7951 c=0
Rl1 (\2\:A \1\:A) resistor r=24.7951 c=0
Rl11 (\1\:B \6\:B) resistor r=44.9225 c=0
Rl4 (\1\:B \3\:B) resistor r=33.3841 c=0
Rz1 (\8\:Y \7\:Y) resistor r=75 c=0
Rz7 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz8 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz6 (VDD \1\:VDD) resistor r=0.04717 c=0
Ry3 (\10\:Y \9\:Y) resistor r=31 c=0
Ry9 (\3\:VSS VSS) resistor r=62 c=0
Ry8 (\3\:VSS \4\:VSS) resistor r=8.8571 c=0
Rx1 (\7\:C \3\:C) resistor r=45 c=0
mn0 (7 \1\:A \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.34e-14 ps=8e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.045e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn1 (7 \3\:B 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=5.33e-14 \
        ad=2.34e-14 ps=9.3e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.75e-07 sb=9.1e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn2 (\7\:Y \5\:C 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=5.33e-14 \
        ad=4.16e-14 ps=9.3e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.25e-07 sb=6.6e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(1)
mn2_1__rcx (\7\:Y \1\:C 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=4.55e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn1_1__rcx (9 \6\:B 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.08e-14 ad=2.99e-14 ps=6.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.9e-07 sb=2.95e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn0_1__rcx (10 \6\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.08e-14 ps=1.31e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.015e-06 sb=1.7e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mp1 (\1\:Y \1\:B \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.6e-07 sd=160n sca=21.9392 \
        scb=0.0187361 scc=0.00185024 m=(2)
mp2 (\9\:Y \3\:C \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=20.6186 \
        scb=0.0170876 scc=0.00184289 m=(2)
ends NAND3X2
// End of subcircuit definition.

// Generated for: spectre (May  9 15:54:13 2012 )
// Library name: gsclib045
// Cell name: NAND3X4
// View name: extracted

simulator lang=spectre

subckt NAND3X4 A B C VDD VSS Y
mp0 (\1\:Y \2\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.8021 scb=0.0193662 \
        scc=0.00077923 m=(4)
C1 (Y VSS) capacitor c=9.61611e-17
C2 (C VSS) capacitor c=5.40331e-16
C3 (A VSS) capacitor c=2.47973e-17
C4 (B VSS) capacitor c=8.53304e-16
C5 (VDD VSS) capacitor c=1.40123e-16
C6 (9 VSS) capacitor c=2.1232e-18
C7 (10 VSS) capacitor c=4.14367e-18
C8 (11 VSS) capacitor c=3.48423e-18
C9 (12 VSS) capacitor c=6.12528e-18
C10 (13 VSS) capacitor c=4.99533e-18
C11 (14 VSS) capacitor c=2.08455e-18
C12 (\12\:A VSS) capacitor c=6.58883e-17
C13 (\12\:B VSS) capacitor c=5.69758e-17
C14 (\14\:C VSS) capacitor c=3.38897e-17
C15 (\13\:C VSS) capacitor c=2.10703e-17
C16 (\9\:B VSS) capacitor c=5.72115e-17
C17 (\4\:A VSS) capacitor c=4.14343e-17
C18 (\6\:A VSS) capacitor c=5.07408e-17
C19 (\6\:B VSS) capacitor c=7.94352e-17
C20 (\1\:C VSS) capacitor c=4.42854e-17
C21 (\4\:C VSS) capacitor c=1.90642e-17
C22 (\3\:B VSS) capacitor c=5.69242e-17
C23 (\1\:A VSS) capacitor c=7.35201e-17
C24 (\2\:A VSS) capacitor c=7.74045e-16
C25 (\1\:VDD VSS) capacitor c=3.87127e-16
C26 (\1\:Y VSS) capacitor c=5.8377e-16
C27 (\3\:VDD VSS) capacitor c=1.98035e-17
C28 (\10\:Y VSS) capacitor c=1.64821e-16
C29 (\12\:Y VSS) capacitor c=1.0844e-16
C30 (\5\:A VSS) capacitor c=2.99542e-17
Rk17 (\1\:Y Y) resistor r=0.213 c=0
Rk18 (Y \11\:Y) resistor r=0.8581 c=0
Rk19 (\11\:Y \13\:Y) resistor r=0.8133 c=0
Rk10 (\2\:A A) resistor r=0.0486 c=0
Rk40 (\2\:VSS \3\:VSS) resistor r=0.04997 c=0
Rk41 (\3\:VSS \4\:VSS) resistor r=0.3008 c=0
Rk42 (\4\:VSS \5\:VSS) resistor r=0.2883 c=0
Rk43 (\5\:VSS \6\:VSS) resistor r=0.3635 c=0
Rk45 (\7\:VSS VSS) resistor r=0.1199 c=0
Rk44 (\6\:VSS \7\:VSS) resistor r=0.1804 c=0
Rk46 (\3\:VSS \9\:VSS) resistor r=0.1028 c=0
Rk47 (\5\:VSS \11\:VSS) resistor r=0.1028 c=0
Rk48 (\7\:VSS \13\:VSS) resistor r=0.2313 c=0
Rk32 (\1\:VDD VDD) resistor r=0.06978 c=0
Rl25 (C \14\:C) resistor r=99.7716 c=0
Rl24 (C \13\:C) resistor r=62.5704 c=0
Rl5 (C \1\:C) resistor r=26.9231 c=0
Rl7 (C \4\:C) resistor r=69.2184 c=0
Rl29 (\2\:A \12\:A) resistor r=99.7951 c=0
Rl1 (\2\:A \1\:A) resistor r=111.211 c=0
Rl13 (\5\:A \4\:A) resistor r=61.5164 c=0
Rl14 (\5\:A \6\:A) resistor r=94.2087 c=0
Rl15 (\5\:A \2\:A) resistor r=69.7363 c=0
Rl27 (B \12\:B) resistor r=29.5379 c=0
Rl19 (B \9\:B) resistor r=87.6374 c=0
Rl12 (B \6\:B) resistor r=87.2302 c=0
Rl4 (B \3\:B) resistor r=44.9225 c=0
Rz1 (\11\:Y \10\:Y) resistor r=75 c=0
Rz2 (\13\:Y \12\:Y) resistor r=75 c=0
Rz6 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz7 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz8 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz5 (VDD \3\:VDD) resistor r=75 c=0
Rz4 (\1\:VDD \3\:VDD) resistor r=5.7692 c=0
Ry14 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry15 (\1\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry16 (\1\:VSS \6\:VSS) resistor r=8.8571 c=0
mn0_1__rcx (7 \1\:A \12\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1_1__rcx (7 \3\:B 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=1.56e-14 ps=1.04e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn2_1__rcx (\12\:Y \4\:C 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=4.16e-14 ps=1.04e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.815e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2_2__rcx (\12\:Y \1\:C 9 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.61e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn1_2__rcx (9 \6\:B 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=1.56e-14 ps=7.5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.505e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn0_2__rcx (10 \6\:A \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=2.99e-14 ps=1.43e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02e-06 sb=1.345e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn0_3__rcx (11 \4\:A \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=2.47e-14 ps=1.43e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.285e-06 sb=1.08e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2_3__rcx (\10\:Y \13\:C 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.66e-06 sb=7.05e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn1_3__rcx (11 \9\:B 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=2.47e-14 ps=9e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.425e-06 sb=9.4e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn2 (\10\:Y \14\:C 13 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.68e-14 ad=4.16e-14 ps=8.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.865e-06 sb=5e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn1 (13 \12\:B 14 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.68e-14 ps=6.4e-07 pd=8.8e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=2.75e-07 sd=160n sca=10.79 scb=0.0100512 scc=0.000418069 m=(1)
mn0 (14 \12\:A \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.24e-14 ad=1.56e-14 ps=1.33e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.7e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mp1 (\1\:Y B \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=15.3235 scb=0.0135506 \
        scc=0.000650815 m=(4)
mp2 (\1\:Y C \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.985e-06 sd=160n sca=14.1261 \
        scb=0.0123878 scc=0.000647585 m=(4)
ends NAND3X4
// End of subcircuit definition.

// Generated for: spectre (May  9 15:54:51 2012 )
// Library name: gsclib045
// Cell name: NAND3X6
// View name: extracted

simulator lang=spectre

subckt NAND3X6 A B C VDD VSS Y
mp0_1__rcx (\1\:Y \2\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.98e-14 ad=6.402e-14 ps=1.08667e-06 pd=1.10833e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.6153 scb=0.0196772 \
        scc=0.000647465 m=(6)
C1 (Y VSS) capacitor c=1.10996e-16
C2 (C VSS) capacitor c=9.72249e-16
C3 (A VSS) capacitor c=1.90376e-17
C4 (B VSS) capacitor c=1.6848e-17
C5 (VDD VSS) capacitor c=2.25856e-16
C6 (9 VSS) capacitor c=9.86254e-18
C7 (10 VSS) capacitor c=5.83404e-18
C8 (11 VSS) capacitor c=4.69902e-18
C9 (12 VSS) capacitor c=7.28392e-18
C10 (13 VSS) capacitor c=1.51807e-17
C11 (14 VSS) capacitor c=4.94436e-18
C12 (15 VSS) capacitor c=7.20453e-18
C13 (16 VSS) capacitor c=4.87818e-18
C14 (\1\:B VSS) capacitor c=1.34109e-15
C15 (\15\:C VSS) capacitor c=3.67581e-17
C16 (\16\:B VSS) capacitor c=4.85406e-17
C17 (\15\:A VSS) capacitor c=4.67943e-17
C18 (\14\:A VSS) capacitor c=4.73584e-17
C19 (\12\:B VSS) capacitor c=4.12857e-17
C20 (\11\:C VSS) capacitor c=1.88839e-17
C21 (\10\:C VSS) capacitor c=2.73233e-17
C22 (\9\:B VSS) capacitor c=6.63646e-17
C23 (\4\:A VSS) capacitor c=5.63696e-17
C24 (\8\:A VSS) capacitor c=4.93497e-17
C25 (\6\:B VSS) capacitor c=5.5011e-17
C26 (\5\:C VSS) capacitor c=2.6339e-17
C27 (\4\:C VSS) capacitor c=3.19262e-17
C28 (\3\:B VSS) capacitor c=8.1759e-17
C29 (\1\:A VSS) capacitor c=6.46163e-17
C30 (\2\:A VSS) capacitor c=1.31763e-15
C31 (\1\:Y VSS) capacitor c=7.88039e-16
C32 (\1\:VDD VSS) capacitor c=5.06796e-16
C33 (\10\:Y VSS) capacitor c=1.96985e-16
C34 (\22\:Y VSS) capacitor c=2.25824e-16
C35 (\24\:Y VSS) capacitor c=1.15272e-16
Rk19 (\1\:Y Y) resistor r=0.2692 c=0
Rk20 (Y \11\:Y) resistor r=0.8701 c=0
Rk26 (\11\:Y \23\:Y) resistor r=1.0357 c=0
Rk27 (\23\:Y \25\:Y) resistor r=0.9598 c=0
Rk12 (\2\:A A) resistor r=0.02677 c=0
Rk59 (\2\:VSS \3\:VSS) resistor r=0.3611 c=0
Rk60 (\3\:VSS \4\:VSS) resistor r=0.341 c=0
Rk61 (\4\:VSS \5\:VSS) resistor r=0.3511 c=0
Rk62 (\5\:VSS \6\:VSS) resistor r=0.3511 c=0
Rk64 (\7\:VSS VSS) resistor r=0.1074 c=0
Rk63 (\6\:VSS \7\:VSS) resistor r=0.193 c=0
Rk65 (\3\:VSS \9\:VSS) resistor r=0.1031 c=0
Rk66 (\5\:VSS \11\:VSS) resistor r=0.1031 c=0
Rk67 (\7\:VSS \13\:VSS) resistor r=0.2991 c=0
Rk4 (B \1\:B) resistor r=0.01685 c=0
Rl36 (C \15\:C) resistor r=24.2328 c=0
Rl23 (C \11\:C) resistor r=45.7894 c=0
Rl22 (C \10\:C) resistor r=35.2336 c=0
Rl8 (C \5\:C) resistor r=24.2328 c=0
Rl7 (C \4\:C) resistor r=52.7541 c=0
Rl30 (\2\:A \15\:A) resistor r=106.926 c=0
Rl29 (\2\:A \14\:A) resistor r=120.708 c=0
Rl12 (\2\:A \4\:A) resistor r=118.246 c=0
Rl15 (\2\:A \8\:A) resistor r=115.362 c=0
Rl1 (\2\:A \1\:A) resistor r=73.0541 c=0
Rl34 (\1\:B \16\:B) resistor r=53.5603 c=0
Rl26 (\1\:B \12\:B) resistor r=44.9225 c=0
Rl19 (\1\:B \9\:B) resistor r=87.6374 c=0
Rl11 (\1\:B \6\:B) resistor r=66.0764 c=0
Rl4 (\1\:B \3\:B) resistor r=83.7903 c=0
Rz1 (\11\:Y \10\:Y) resistor r=37.5 c=0
Rz2 (\23\:Y \22\:Y) resistor r=37.5 c=0
Rz3 (\25\:Y \24\:Y) resistor r=37.5 c=0
Rz15 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz16 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz17 (\12\:VSS \13\:VSS) resistor r=37.5 c=0
Rz14 (VDD \1\:VDD) resistor r=0.05722 c=0
Ry20 (\1\:VSS \2\:VSS) resistor r=8.8571 c=0
Ry21 (\1\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry22 (\1\:VSS \6\:VSS) resistor r=8.8571 c=0
mn0 (7 \1\:A \12\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=1.86e-14 ps=9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn1 (7 \3\:B 8 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=4.185e-14 \
        ad=1.86e-14 ps=8.9e-07 pd=7.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=2e-06 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn1_4__rcx (15 \16\:B 16 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.875e-14 ad=4.96e-14 ps=8.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.25e-07 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn2 (\24\:Y \4\:C 8 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=4.185e-14 \
        ad=4.96e-14 ps=8.9e-07 pd=9.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.25e-07 sb=2e-06 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn2_1__rcx (\24\:Y \5\:C 9 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.735e-14 ad=4.96e-14 ps=9.9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=2e-06 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn1_1__rcx (9 \6\:B 10 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.565e-14 ad=5.735e-14 ps=8.5e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=2e-06 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn0_1__rcx (10 \8\:A \10\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.7e-14 ad=3.565e-14 ps=1.54e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02e-06 sb=2e-06 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn0_2__rcx (11 \4\:A \10\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.7e-14 ad=2.79e-14 ps=1.54e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.285e-06 sb=1.91e-06 sd=160n sca=13.2036 \
        scb=0.0127776 scc=0.000861941 m=(1)
mn1_2__rcx (11 \9\:B 12 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.65e-14 ad=2.79e-14 ps=9.2e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=1.775e-06 sd=160n sca=13.2036 \
        scb=0.0127776 scc=0.000861941 m=(1)
mn2_2__rcx (\22\:Y \10\:C 12 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.65e-14 ad=4.96e-14 ps=9.2e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.615e-06 sb=1.58e-06 sd=160n sca=13.2036 \
        scb=0.0127776 scc=0.000861941 m=(1)
mn2_3__rcx (\22\:Y \11\:C 13 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1315e-13 ad=4.96e-14 ps=1.35e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.82e-06 sb=1.375e-06 sd=160n sca=13.2036 \
        scb=0.0127776 scc=0.000861941 m=(1)
mn1_3__rcx (13 \12\:B 14 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.875e-14 ad=1.1315e-13 ps=8.7e-07 pd=1.35e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.65e-07 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn0_3__rcx (14 \14\:A \8\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.7e-14 ad=3.875e-14 ps=1.54e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.95e-07 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn0_4__rcx (15 \15\:A \8\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.7e-14 ad=4.96e-14 ps=1.54e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.3e-07 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mn2_4__rcx (\10\:Y \15\:C 16 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.875e-14 ad=4.805e-14 ps=8.7e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.55e-07 sd=160n sca=13.2036 scb=0.0127776 \
        scc=0.000861941 m=(1)
mp1 (\1\:Y \1\:B \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.15e-14 ad=6.402e-14 ps=1.14667e-06 pd=1.10833e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=14.5247 scb=0.0127136 \
        scc=0.000449121 m=(6)
mp2_1__rcx (\1\:Y C \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.15e-14 ad=6.24e-14 ps=1.14667e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2e-06 sd=160n sca=13.1869 scb=0.0112853 \
        scc=0.000444017 m=(6)
ends NAND3X6
// End of subcircuit definition.

// Generated for: spectre (May  9 15:55:30 2012 )
// Library name: gsclib045
// Cell name: NAND3X8
// View name: extracted

simulator lang=spectre

subckt NAND3X8 A B C VDD VSS Y
mp0_1__rcx (\3\:Y A \1\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=7.565e-14 ps=1.20429e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.275 scb=0.0264752 \
        scc=0.0013153 m=(7)
C1 (A VSS) capacitor c=1.29634e-15
C2 (Y VSS) capacitor c=3.99858e-17
C3 (C VSS) capacitor c=1.36241e-15
C4 (B VSS) capacitor c=1.58356e-15
C5 (VDD VSS) capacitor c=2.1658e-16
C6 (9 VSS) capacitor c=5.22845e-18
C7 (10 VSS) capacitor c=2.74606e-18
C8 (11 VSS) capacitor c=1.00044e-17
C9 (12 VSS) capacitor c=5.54197e-18
C10 (13 VSS) capacitor c=1.21677e-17
C11 (14 VSS) capacitor c=8.78181e-18
C12 (15 VSS) capacitor c=2.77099e-18
C13 (16 VSS) capacitor c=1.0665e-17
C14 (17 VSS) capacitor c=7.90337e-18
C15 (18 VSS) capacitor c=7.25811e-18
C16 (19 VSS) capacitor c=7.79274e-18
C17 (20 VSS) capacitor c=3.43879e-18
C18 (\21\:C VSS) capacitor c=5.57274e-17
C19 (\22\:B VSS) capacitor c=6.28285e-17
C20 (\20\:A VSS) capacitor c=4.40016e-17
C21 (\19\:A VSS) capacitor c=4.05076e-17
C22 (\18\:B VSS) capacitor c=4.32792e-17
C23 (\17\:C VSS) capacitor c=2.58889e-17
C24 (\16\:C VSS) capacitor c=1.95623e-17
C25 (\15\:B VSS) capacitor c=5.92851e-17
C26 (\10\:A VSS) capacitor c=6.39994e-17
C27 (\13\:A VSS) capacitor c=3.682e-17
C28 (\12\:B VSS) capacitor c=3.54401e-17
C29 (\11\:C VSS) capacitor c=1.85724e-17
C30 (\10\:C VSS) capacitor c=3.22971e-17
C31 (\9\:B VSS) capacitor c=4.27846e-17
C32 (\7\:A VSS) capacitor c=3.51885e-17
C33 (\8\:A VSS) capacitor c=6.78066e-17
C34 (\6\:B VSS) capacitor c=7.09512e-17
C35 (\1\:C VSS) capacitor c=2.95968e-17
C36 (\4\:C VSS) capacitor c=1.91787e-17
C37 (\3\:B VSS) capacitor c=7.02686e-17
C38 (\1\:A VSS) capacitor c=5.87351e-17
C39 (\1\:VDD VSS) capacitor c=5.94143e-16
C40 (\1\:Y VSS) capacitor c=1.44639e-16
C41 (\6\:Y VSS) capacitor c=2.17568e-16
C42 (\8\:Y VSS) capacitor c=2.12769e-16
C43 (\10\:Y VSS) capacitor c=1.23881e-16
C44 (\3\:Y VSS) capacitor c=9.59615e-16
Rk19 (\2\:Y Y) resistor r=0.5124 c=0
Rk20 (Y \3\:Y) resistor r=0.0144 c=0
Rk22 (\2\:Y \7\:Y) resistor r=0.8662 c=0
Rk23 (\7\:Y \9\:Y) resistor r=0.9783 c=0
Rk24 (\9\:Y \11\:Y) resistor r=0.8532 c=0
Rk62 (\2\:VSS \4\:VSS) resistor r=0.2028 c=0
Rk63 (\4\:VSS \5\:VSS) resistor r=0.4481 c=0
Rk64 (\5\:VSS \6\:VSS) resistor r=0.6853 c=0
Rk65 (\6\:VSS \7\:VSS) resistor r=0.06661 c=0
Rk67 (\8\:VSS VSS) resistor r=0.08739 c=0
Rk66 (\7\:VSS \8\:VSS) resistor r=0.4641 c=0
Rk68 (\5\:VSS \10\:VSS) resistor r=0.04335 c=0
Rk69 (\6\:VSS \12\:VSS) resistor r=0.04335 c=0
Rk70 (\8\:VSS \14\:VSS) resistor r=0.2659 c=0
Rk61 (\1\:VDD VDD) resistor r=0.01963 c=0
Rl43 (A \20\:A) resistor r=85.772 c=0
Rl42 (A \19\:A) resistor r=83.8482 c=0
Rl26 (A \10\:A) resistor r=99.9779 c=0
Rl28 (A \13\:A) resistor r=83.8482 c=0
Rl14 (A \7\:A) resistor r=84.7767 c=0
Rl15 (A \8\:A) resistor r=118.346 c=0
Rl1 (A \1\:A) resistor r=74.5443 c=0
Rl49 (C \21\:C) resistor r=45.4267 c=0
Rl36 (C \17\:C) resistor r=47.3105 c=0
Rl35 (C \16\:C) resistor r=24.2328 c=0
Rl22 (C \11\:C) resistor r=22.4021 c=0
Rl21 (C \10\:C) resistor r=67.2856 c=0
Rl5 (C \1\:C) resistor r=34.2718 c=0
Rl7 (C \4\:C) resistor r=23.7402 c=0
Rl47 (B \22\:B) resistor r=34.3295 c=0
Rl39 (B \18\:B) resistor r=29.5379 c=0
Rl32 (B \15\:B) resistor r=26.098 c=0
Rl25 (B \12\:B) resistor r=29.5379 c=0
Rl18 (B \9\:B) resistor r=29.5379 c=0
Rl11 (B \6\:B) resistor r=35.3072 c=0
Rl4 (B \3\:B) resistor r=81.461 c=0
Rz1 (\2\:Y \1\:Y) resistor r=75 c=0
Rz2 (\7\:Y \6\:Y) resistor r=75 c=0
Rz3 (\9\:Y \8\:Y) resistor r=75 c=0
Rz4 (\11\:Y \10\:Y) resistor r=75 c=0
Rz11 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz12 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz13 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz14 (\13\:VSS \14\:VSS) resistor r=75 c=0
Ry23 (\3\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry24 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
mn0_1__rcx (7 \1\:A \13\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.13e-14 ad=1.77e-14 ps=8.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn1_1__rcx (7 \3\:B 8 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=6.047e-14 ad=1.77e-14 ps=1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn2_1__rcx (\10\:Y \4\:C 8 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=6.047e-14 ad=4.72e-14 ps=1e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn2 (\10\:Y \1\:C 9 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=3.393e-14 ad=4.72e-14 ps=8.2e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn1 (9 \6\:B 10 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 as=1.77e-14 \
        ad=3.393e-14 ps=7.1e-07 pd=8.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.6e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn0 (10 \8\:A \11\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=9.91e-14 ad=1.77e-14 ps=1.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn0_2__rcx (11 \7\:A \11\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=9.91e-14 ad=5.9e-14 ps=1.6e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23e-06 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn1_2__rcx (11 \9\:B 12 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=3.54e-14 ad=5.9e-14 ps=8.3e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=2e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(1)
mn0_4__rcx (15 \10\:A \9\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=9.91e-14 ad=1.77e-14 ps=1.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.655e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(1)
mn2_2__rcx (\8\:Y \10\:C 12 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=3.54e-14 ad=4.72e-14 ps=8.3e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64e-06 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn2_3__rcx (\8\:Y \11\:C 13 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=7.08e-14 ad=4.72e-14 ps=1.07e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=2e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(1)
mn1_3__rcx (13 \12\:B 14 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.72e-14 ad=7.08e-14 ps=9.1e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn0_3__rcx (14 \13\:A \9\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=9.91e-14 ad=4.72e-14 ps=1.6e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.92e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn1_4__rcx (15 \15\:B 16 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=5.9e-14 ad=1.77e-14 ps=9.9e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.55e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn2_4__rcx (\6\:Y \16\:C 16 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=5.9e-14 ad=4.72e-14 ps=9.9e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.305e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(1)
mn2_5__rcx (\6\:Y \17\:C 17 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.72e-14 ad=4.72e-14 ps=9.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.1e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn1_5__rcx (17 \18\:B 18 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=3.983e-14 ad=4.72e-14 ps=8.6e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.95e-07 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn0_5__rcx (18 \19\:A \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=9.91e-14 ad=3.983e-14 ps=1.6e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.15e-07 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn0_6__rcx (19 \20\:A \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=9.91e-14 ad=4.72e-14 ps=1.6e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn1_6__rcx (19 \22\:B 20 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=1.77e-14 ad=4.72e-14 ps=7.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mn2_6__rcx (\1\:Y \21\:C 20 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=1.77e-14 ad=4.13e-14 ps=7.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(1)
mp1_1__rcx (\3\:Y B \1\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.374e-14 ad=7.565e-14 ps=1.22143e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.8e-07 sb=2e-06 sd=160n sca=15.6896 scb=0.014147 \
        scc=0.000596665 m=(7)
mp2_1__rcx (\3\:Y C \1\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.374e-14 ad=6.993e-14 ps=1.22143e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=5.85e-07 sb=2e-06 sd=160n sca=14.0773 \
        scb=0.0121711 scc=0.000586094 m=(7)
ends NAND3X8
// End of subcircuit definition.

// Generated for: spectre (May  9 15:56:07 2012 )
// Library name: gsclib045
// Cell name: NAND3XL
// View name: extracted

simulator lang=spectre

subckt NAND3XL A B C VDD VSS Y
mp0 (\5\:Y \1\:A \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.65e-07 sd=160n sca=22.6868 \
        scb=0.0236005 scc=0.00131066 m=(1)
C1 (C VSS) capacitor c=5.53459e-17
C2 (VDD VSS) capacitor c=7.18324e-17
C3 (Y VSS) capacitor c=2.30022e-17
C4 (B VSS) capacitor c=5.50388e-17
C5 (n0 VSS) capacitor c=1.78429e-18
C6 (n1 VSS) capacitor c=3.97147e-20
C7 (\1\:C VSS) capacitor c=4.26142e-17
C8 (\1\:B VSS) capacitor c=5.21851e-17
C9 (\1\:A VSS) capacitor c=2.88485e-17
C10 (\3\:C VSS) capacitor c=3.56602e-17
C11 (\3\:B VSS) capacitor c=3.6082e-17
C12 (\4\:A VSS) capacitor c=3.00451e-17
C13 (\2\:C VSS) capacitor c=3.66419e-17
C14 (\2\:B VSS) capacitor c=4.7921e-17
C15 (\3\:A VSS) capacitor c=3.21207e-17
C16 (\3\:Y VSS) capacitor c=2.09949e-17
C17 (\5\:VDD VSS) capacitor c=9.16269e-18
C18 (\5\:Y VSS) capacitor c=3.42858e-17
C19 (\7\:VDD VSS) capacitor c=3.29761e-17
C20 (\1\:VDD VSS) capacitor c=1.80454e-17
C21 (\1\:Y VSS) capacitor c=4.78391e-17
C22 (\5\:A VSS) capacitor c=8.19686e-17
C23 (\4\:B VSS) capacitor c=6.38494e-17
C24 (\4\:C VSS) capacitor c=6.73106e-17
C25 (\3\:VDD VSS) capacitor c=3.87646e-18
Rk1 (\5\:A A) resistor r=0.001027 c=0
Rk13 (\3\:VSS VSS) resistor r=0.0797 c=0
Rk14 (\3\:VSS \5\:VSS) resistor r=0.3674 c=0
Rk3 (C \4\:C) resistor r=0.2064 c=0
Rk7 (\2\:VDD \3\:VDD) resistor r=0.08496 c=0
Rk11 (\4\:VDD VDD) resistor r=0.1005 c=0
Rk8 (\3\:VDD \4\:VDD) resistor r=0.1651 c=0
Rk9 (\3\:VDD \6\:VDD) resistor r=0.07323 c=0
Rk10 (\4\:VDD \8\:VDD) resistor r=0.3876 c=0
Rk4 (\2\:Y Y) resistor r=0.2882 c=0
Rk5 (Y \4\:Y) resistor r=0.07178 c=0
Rk6 (\4\:Y \6\:Y) resistor r=0.2771 c=0
Rk2 (\4\:B B) resistor r=0.1702 c=0
Rl1 (\1\:A \2\:A) resistor r=56.5719 c=0
Rl3 (\2\:A \4\:A) resistor r=68.1104 c=0
Rl2 (\2\:A \3\:A) resistor r=0.6051 c=0
Rl6 (\1\:C \2\:C) resistor r=61.5385 c=0
Rl7 (\2\:C \3\:C) resistor r=49.4506 c=0
Rl4 (\1\:B \2\:B) resistor r=81.9251 c=0
Rl5 (\2\:B \3\:B) resistor r=24.2328 c=0
Rz4 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz2 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz3 (\1\:VDD \4\:VDD) resistor r=25 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry2 (\5\:Y \6\:Y) resistor r=62 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
mn0 (n0 \4\:A \4\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (n0 \3\:B n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=1.087e-14 \
        ad=2.32e-14 ps=4.4e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=3.7e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn2 (\1\:Y \3\:C n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.087e-14 ad=3.625e-14 ps=4.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=2.5e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp1 (\5\:Y \1\:B \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.09e-14 ad=3.44e-14 ps=1.68e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.6e-07 sd=160n sca=21.6855 \
        scb=0.0215209 scc=0.00124628 m=(1)
mp2 (\3\:Y \1\:C \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.09e-14 ad=3.548e-14 ps=1.68e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=1.65e-07 sd=160n sca=27.8541 \
        scb=0.032188 scc=0.00201007 m=(1)
ends NAND3XL
// End of subcircuit definition.

// Generated for: spectre (May  9 15:56:45 2012 )
// Library name: gsclib045
// Cell name: NAND4BBX1
// View name: extracted

simulator lang=spectre

subckt NAND4BBX1 AN BN C D VDD VSS Y
mp1 (\5\:n1 \1\:BN \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.15e-14 ps=7.1e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.39535e-07 sd=160n sca=28.2276 \
        scb=0.0332165 scc=0.00215993 m=(1)
C1 (BN VSS) capacitor c=5.00593e-17
C2 (AN VSS) capacitor c=1.21065e-16
C3 (Y VSS) capacitor c=1.06456e-16
C4 (D VSS) capacitor c=4.90806e-17
C5 (VDD VSS) capacitor c=1.42503e-16
C6 (n1 VSS) capacitor c=6.72367e-17
C7 (n4 VSS) capacitor c=2.996e-18
C8 (n3 VSS) capacitor c=9.94033e-18
C9 (n2 VSS) capacitor c=5.52646e-18
C10 (n0 VSS) capacitor c=6.3996e-17
C11 (\1\:AN VSS) capacitor c=3.40288e-17
C12 (\1\:C VSS) capacitor c=5.5557e-17
C13 (\1\:D VSS) capacitor c=6.15543e-17
C14 (\1\:BN VSS) capacitor c=2.51365e-17
C15 (\3\:AN VSS) capacitor c=3.94858e-17
C16 (\3\:n0 VSS) capacitor c=4.49883e-17
C17 (\4\:n1 VSS) capacitor c=3.34039e-17
C18 (\3\:C VSS) capacitor c=7.32442e-17
C19 (\4\:D VSS) capacitor c=5.86972e-17
C20 (\4\:BN VSS) capacitor c=3.48965e-17
C21 (\2\:AN VSS) capacitor c=3.93622e-17
C22 (\4\:n0 VSS) capacitor c=1.92905e-17
C23 (\3\:n1 VSS) capacitor c=1.25903e-17
C24 (\2\:C VSS) capacitor c=6.41867e-17
C25 (\3\:D VSS) capacitor c=9.79458e-18
C26 (\3\:BN VSS) capacitor c=1.25388e-17
C27 (\5\:n0 VSS) capacitor c=6.57163e-17
C28 (\9\:VDD VSS) capacitor c=6.59812e-17
C29 (\6\:Y VSS) capacitor c=3.40473e-17
C30 (\11\:VDD VSS) capacitor c=3.6739e-17
C31 (\1\:Y VSS) capacitor c=7.11492e-17
C32 (\13\:VDD VSS) capacitor c=2.00675e-17
C33 (\5\:n1 VSS) capacitor c=7.02866e-17
C34 (\7\:VDD VSS) capacitor c=2.81073e-17
C35 (\1\:VDD VSS) capacitor c=2.46956e-17
C36 (\9\:n0 VSS) capacitor c=1.26228e-17
C37 (\4\:Y VSS) capacitor c=1.34316e-16
C38 (\7\:n1 VSS) capacitor c=1.21425e-16
C39 (\2\:BN VSS) capacitor c=1.6415e-17
C40 (\2\:D VSS) capacitor c=4.52206e-17
C41 (\2\:n1 VSS) capacitor c=3.35847e-17
C42 (\2\:n0 VSS) capacitor c=3.27866e-17
C43 (\5\:BN VSS) capacitor c=5.36591e-17
C44 (\5\:D VSS) capacitor c=6.23305e-17
C45 (\4\:C VSS) capacitor c=1.01076e-16
C46 (\9\:n1 VSS) capacitor c=1.1378e-16
C47 (\3\:Y VSS) capacitor c=3.21135e-17
C48 (\7\:n0 VSS) capacitor c=5.39692e-17
C49 (\8\:n0 VSS) capacitor c=3.50567e-17
C50 (\3\:VDD VSS) capacitor c=8.78527e-18
C51 (\4\:VDD VSS) capacitor c=1.62604e-17
C52 (\6\:VDD VSS) capacitor c=5.32499e-18
Rk1 (\5\:BN BN) resistor r=0.1612 c=0
Rk24 (\4\:VSS VSS) resistor r=0.4512 c=0
Rk23 (\2\:VSS \4\:VSS) resistor r=0.445 c=0
Rk25 (VSS \6\:VSS) resistor r=0.2845 c=0
Rk7 (\3\:Y Y) resistor r=0.1153 c=0
Rk6 (\2\:Y \3\:Y) resistor r=0.3422 c=0
Rk8 (Y \5\:Y) resistor r=0.9418 c=0
Rk9 (\3\:Y \7\:Y) resistor r=0.08594 c=0
Rk3 (\4\:C C) resistor r=0.002794 c=0
Rk2 (\5\:D D) resistor r=0.1916 c=0
Rk14 (\2\:VDD \3\:VDD) resistor r=0.1427 c=0
Rk15 (\3\:VDD \4\:VDD) resistor r=0.2152 c=0
Rk16 (\4\:VDD \5\:VDD) resistor r=0.1427 c=0
Rk18 (\6\:VDD VDD) resistor r=0.2881 c=0
Rk17 (\5\:VDD \6\:VDD) resistor r=0.06247 c=0
Rk19 (VDD \8\:VDD) resistor r=0.3318 c=0
Rk20 (\3\:VDD \10\:VDD) resistor r=0.2776 c=0
Rk21 (\4\:VDD \12\:VDD) resistor r=0.1825 c=0
Rk22 (\6\:VDD \14\:VDD) resistor r=0.1778 c=0
Rk4 (\6\:n1 \8\:n1) resistor r=0.4574 c=0
Rk5 (\8\:n1 \9\:n1) resistor r=0.6491 c=0
Rk11 (\6\:n0 \7\:n0) resistor r=0.4503 c=0
Rk12 (\7\:n0 \8\:n0) resistor r=0.1947 c=0
Rk13 (\7\:n0 \10\:n0) resistor r=0.09758 c=0
Rl1 (\1\:BN \2\:BN) resistor r=34.3295 c=0
Rl3 (\2\:BN \4\:BN) resistor r=155.483 c=0
Rl2 (\2\:BN \3\:BN) resistor r=1.2666 c=0
Rl15 (\1\:AN \2\:AN) resistor r=85.3072 c=0
Rl16 (\2\:AN \3\:AN) resistor r=102.615 c=0
Rl7 (\1\:C \2\:C) resistor r=82.4824 c=0
Rl8 (\2\:C \3\:C) resistor r=108.791 c=0
Rl4 (\1\:D \2\:D) resistor r=162.341 c=0
Rl6 (\2\:D \4\:D) resistor r=41.1873 c=0
Rl5 (\2\:D \3\:D) resistor r=6.9867 c=0
Rl9 (n1 \2\:n1) resistor r=170.868 c=0
Rl11 (\2\:n1 \4\:n1) resistor r=34.3295 c=0
Rl10 (\2\:n1 \3\:n1) resistor r=2.0166 c=0
Rl12 (n0 \2\:n0) resistor r=151.912 c=0
Rl13 (\2\:n0 \3\:n0) resistor r=49.759 c=0
Rl14 (\2\:n0 \4\:n0) resistor r=11.4385 c=0
Rz6 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz7 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz2 (\4\:Y \5\:Y) resistor r=75 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VDD \5\:VDD) resistor r=9.375 c=0
Rz1 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz3 (\9\:n0 \10\:n0) resistor r=75 c=0
Ry2 (\1\:Y \2\:Y) resistor r=31 c=0
Ry3 (\6\:Y \7\:Y) resistor r=31 c=0
Ry5 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry6 (\9\:VDD \10\:VDD) resistor r=20.6667 c=0
Ry7 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry8 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry1 (\5\:n1 \6\:n1) resistor r=62 c=0
Ry4 (\5\:n0 \6\:n0) resistor r=62 c=0
Rx1 (\3\:BN \5\:BN) resistor r=45 c=0
Rx5 (\2\:AN AN) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\3\:D \5\:D) resistor r=45 c=0
Rx4 (\3\:n1 \9\:n1) resistor r=45 c=0
Rx6 (\4\:n0 \8\:n0) resistor r=45 c=0
mn1 (\7\:n1 \4\:BN \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.05e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn5 (\4\:Y \4\:D n4 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 sa=1.4e-07 \
        sb=9.05096e-07 sd=160n sca=9.14564 scb=0.00759168 scc=0.000213449 \
        m=(1)
mn4 (n4 \3\:C n3 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=6.76e-14 \
        ad=1.56e-14 ps=1.04e-06 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=8.00096e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn3 (n3 \4\:n1 n2 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.64e-14 \
        ad=6.76e-14 ps=8e-07 pd=1.04e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.5e-07 sb=4.95096e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2 (n2 \3\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.38e-14 ad=3.64e-14 ps=1.04e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=3.10096e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0 (\9\:n0 \3\:AN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.38e-14 ad=2.03e-14 ps=1.04e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mp5 (\1\:Y \1\:D \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.38e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=9.84487e-07 sd=160n sca=11.8564 \
        scb=0.00969513 scc=0.0002319 m=(1)
mp4 (\1\:Y \1\:C \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.17308e-07 sb=7.79487e-07 sd=160n sca=11.3866 \
        scb=0.00953811 scc=0.000231855 m=(1)
mp3 (\6\:Y n1 \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=7.02e-14 ps=1.1e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.22308e-07 sb=5.74487e-07 sd=160n sca=11.7441 \
        scb=0.00964347 scc=0.000231878 m=(1)
mp2 (\6\:Y n0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=7.02e-14 ps=1.22e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.47308e-07 sb=3.49487e-07 sd=160n sca=12.8177 \
        scb=0.0105047 scc=0.000233437 m=(1)
mp0 (\5\:n0 \1\:AN \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=5.483e-14 ps=1.22e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=2.55e-07 sd=160n sca=18.0262 scb=0.0191386 \
        scc=0.000518763 m=(1)
ends NAND4BBX1
// End of subcircuit definition.

// Generated for: spectre (May  9 15:57:23 2012 )
// Library name: gsclib045
// Cell name: NAND4BBX2
// View name: extracted

simulator lang=spectre

subckt NAND4BBX2 AN BN C D VDD VSS Y
mp1 (\10\:n1 \1\:BN \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.655e-14 ps=7.5e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=3.45e-07 sd=160n sca=14.4249 \
        scb=0.0128702 scc=0.000158043 m=(1)
C1 (BN VSS) capacitor c=4.19132e-17
C2 (D VSS) capacitor c=4.01775e-17
C3 (C VSS) capacitor c=3.6011e-17
C4 (Y VSS) capacitor c=2.89515e-17
C5 (AN VSS) capacitor c=8.03441e-17
C6 (VDD VSS) capacitor c=1.7315e-16
C7 (n1 VSS) capacitor c=1.80228e-16
C8 (n0 VSS) capacitor c=1.55921e-16
C9 (n2 VSS) capacitor c=2.30609e-16
C10 (n3 VSS) capacitor c=9.21118e-17
C11 (n4 VSS) capacitor c=1.67639e-16
C12 (\3\:AN VSS) capacitor c=3.6898e-17
C13 (\1\:BN VSS) capacitor c=3.76732e-17
C14 (\1\:D VSS) capacitor c=1.66347e-16
C15 (\1\:C VSS) capacitor c=1.92625e-16
C16 (\1\:AN VSS) capacitor c=4.19456e-17
C17 (\3\:BN VSS) capacitor c=3.54063e-17
C18 (\2\:AN VSS) capacitor c=4.02827e-17
C19 (\2\:BN VSS) capacitor c=3.90037e-17
C20 (\1\:VDD VSS) capacitor c=2.68314e-16
C21 (\9\:Y VSS) capacitor c=3.69287e-17
C22 (\11\:Y VSS) capacitor c=3.59132e-17
C23 (\13\:Y VSS) capacitor c=3.47615e-17
C24 (\7\:Y VSS) capacitor c=4.11829e-17
C25 (\10\:n0 VSS) capacitor c=6.91255e-17
C26 (\22\:VDD VSS) capacitor c=3.50426e-17
C27 (\10\:n1 VSS) capacitor c=5.67033e-17
C28 (\3\:VDD VSS) capacitor c=8.24209e-17
C29 (\1\:Y VSS) capacitor c=6.16766e-17
C30 (\3\:n3 VSS) capacitor c=7.72493e-17
C31 (\12\:n0 VSS) capacitor c=6.88846e-17
C32 (\12\:n1 VSS) capacitor c=1.6119e-17
C33 (\4\:BN VSS) capacitor c=7.54845e-17
C34 (\4\:AN VSS) capacitor c=4.2222e-17
C35 (\8\:n0 VSS) capacitor c=6.1232e-17
C36 (\9\:n0 VSS) capacitor c=7.90112e-17
C37 (\8\:n1 VSS) capacitor c=2.17447e-16
C38 (\9\:n1 VSS) capacitor c=2.47427e-16
C39 (\7\:C VSS) capacitor c=7.62276e-17
C40 (\7\:D VSS) capacitor c=7.6323e-17
C41 (\3\:Y VSS) capacitor c=8.3843e-17
C42 (\4\:Y VSS) capacitor c=6.82914e-17
C43 (\5\:Y VSS) capacitor c=2.6134e-17
C44 (\6\:Y VSS) capacitor c=2.77921e-17
C45 (\13\:VDD VSS) capacitor c=7.27723e-18
Rk1 (BN \4\:BN) resistor r=0.07076 c=0
Rk13 (\7\:D D) resistor r=0.02379 c=0
Rk41 (\2\:VSS \3\:VSS) resistor r=0.6619 c=0
Rk42 (\3\:VSS \4\:VSS) resistor r=0.1402 c=0
Rk44 (\5\:VSS VSS) resistor r=0.2077 c=0
Rk43 (\4\:VSS \5\:VSS) resistor r=0.3434 c=0
Rk45 (\3\:VSS \7\:VSS) resistor r=0.2367 c=0
Rk46 (\5\:VSS \9\:VSS) resistor r=0.327 c=0
Rk12 (C \7\:C) resistor r=0.02484 c=0
Rk14 (\2\:Y \3\:Y) resistor r=0.5148 c=0
Rk15 (\3\:Y \4\:Y) resistor r=0.3409 c=0
Rk16 (\4\:Y \5\:Y) resistor r=0.309 c=0
Rk22 (\6\:Y Y) resistor r=0.02589 c=0
Rk17 (\5\:Y \6\:Y) resistor r=0.1921 c=0
Rk18 (\6\:Y \8\:Y) resistor r=0.07409 c=0
Rk19 (\3\:Y \10\:Y) resistor r=0.06391 c=0
Rk20 (\4\:Y \12\:Y) resistor r=0.05797 c=0
Rk21 (\5\:Y \14\:Y) resistor r=0.05797 c=0
Rk2 (AN \4\:AN) resistor r=0.1348 c=0
Rk33 (\1\:VDD \12\:VDD) resistor r=0.3384 c=0
Rk35 (\13\:VDD VDD) resistor r=0.1952 c=0
Rk34 (\12\:VDD \13\:VDD) resistor r=0.1051 c=0
Rk40 (\13\:VDD \23\:VDD) resistor r=0.2421 c=0
Rk6 (\8\:n1 \9\:n1) resistor r=1.6447 c=0
Rk7 (\9\:n1 \11\:n1) resistor r=0.5767 c=0
Rk8 (\9\:n1 \13\:n1) resistor r=0.09278 c=0
Rk3 (\8\:n0 \9\:n0) resistor r=0.3117 c=0
Rk4 (\9\:n0 \11\:n0) resistor r=0.446 c=0
Rk5 (\9\:n0 \13\:n0) resistor r=0.2934 c=0
Rk11 (\2\:n3 \4\:n3) resistor r=0.4745 c=0
Rl1 (\1\:BN \2\:BN) resistor r=100.692 c=0
Rl2 (\2\:BN \3\:BN) resistor r=98.7687 c=0
Rl4 (\2\:AN \3\:AN) resistor r=101.099 c=0
Rl3 (\1\:AN \2\:AN) resistor r=100 c=0
Rz17 (\7\:VSS \6\:VSS) resistor r=75 c=0
Rz18 (\9\:VSS \8\:VSS) resistor r=75 c=0
Rz8 (\2\:Y \1\:Y) resistor r=75 c=0
Rz14 (\1\:VDD \3\:VDD) resistor r=8.3333 c=0
Rz16 (\12\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz2 (\13\:n1 \12\:n1) resistor r=75 c=0
Rz1 (\13\:n0 \12\:n0) resistor r=75 c=0
Rz6 (\2\:n3 n3) resistor r=75 c=0
Rz7 (\4\:n3 \3\:n3) resistor r=75 c=0
Ry13 (\2\:VSS \1\:VSS) resistor r=15.5 c=0
Ry14 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry3 (\8\:Y \7\:Y) resistor r=20.6667 c=0
Ry4 (\10\:Y \9\:Y) resistor r=31 c=0
Ry5 (\12\:Y \11\:Y) resistor r=31 c=0
Ry6 (\14\:Y \13\:Y) resistor r=31 c=0
Ry12 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry2 (\11\:n1 \10\:n1) resistor r=62 c=0
Ry1 (\11\:n0 \10\:n0) resistor r=62 c=0
Rx1 (\2\:BN \4\:BN) resistor r=45 c=0
Rx6 (\7\:D \1\:D) resistor r=45 c=0
Rx5 (\7\:C \1\:C) resistor r=45 c=0
Rx2 (\2\:AN \4\:AN) resistor r=45 c=0
Rx4 (\8\:n1 n1) resistor r=45 c=0
Rx3 (\8\:n0 n0) resistor r=45 c=0
mn1 (\12\:n1 \3\:BN \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.175e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.85e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn0 (\12\:n0 \1\:AN \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.175e-14 ad=3.263e-14 ps=7.3e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=2.25e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn2 (n2 n0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=4.095e-14 ps=8.4e-07 pd=8.35e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.7e-07 sd=160n sca=11.3041 scb=0.010759 \
        scc=0.000493236 m=(2)
mn3 (\3\:n3 n1 n2 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.095e-14 \
        ad=4.16e-14 ps=8.35e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.65e-07 sb=3.45e-07 sd=160n sca=11.3041 scb=0.010759 \
        scc=0.000493236 m=(2)
mn4 (n4 \1\:C n3 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.55e-07 sd=160n sca=10.104 scb=0.00906063 \
        scc=0.000325539 m=(2)
mn5 (\1\:Y \1\:D n4 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.9e-14 \
        ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.5e-07 sb=3.45e-07 sd=160n sca=10.104 scb=0.00906063 \
        scc=0.000325539 m=(2)
mp0 (\10\:n0 \3\:AN \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=11.7702 \
        scb=0.00871161 scc=9.98964e-05 m=(1)
mp2 (\7\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.615e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(2)
mp3 (\13\:Y n1 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.205e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(2)
mp4 (\11\:Y \1\:C \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.95e-07 sd=160n sca=15.5579 \
        scb=0.0139499 scc=0.00102271 m=(2)
mp5 (\9\:Y \1\:D \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=7.8e-14 ps=1.08e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=3.85e-07 sd=160n sca=17.7593 scb=0.0161 \
        scc=0.00103173 m=(2)
ends NAND4BBX2
// End of subcircuit definition.

// Generated for: spectre (May  9 15:58:02 2012 )
// Library name: gsclib045
// Cell name: NAND4BBX4
// View name: extracted

simulator lang=spectre

subckt NAND4BBX4 AN BN C D VDD VSS Y
mp1 (\18\:n1 \1\:BN \35\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=16.9422 \
        scb=0.0172816 scc=0.000388705 m=(1)
C1 (BN VSS) capacitor c=1.0018e-16
C2 (D VSS) capacitor c=6.17102e-17
C3 (C VSS) capacitor c=2.77224e-17
C4 (Y VSS) capacitor c=3.34295e-17
C5 (AN VSS) capacitor c=8.07289e-17
C6 (VDD VSS) capacitor c=2.22921e-16
C7 (n1 VSS) capacitor c=2.7554e-16
C8 (n0 VSS) capacitor c=2.55215e-16
C9 (n2 VSS) capacitor c=3.84332e-16
C10 (n3 VSS) capacitor c=1.64598e-16
C11 (n4 VSS) capacitor c=3.09356e-16
C12 (\1\:AN VSS) capacitor c=4.32818e-17
C13 (\1\:BN VSS) capacitor c=4.59567e-17
C14 (\1\:D VSS) capacitor c=2.57268e-16
C15 (\1\:C VSS) capacitor c=2.83089e-16
C16 (\3\:AN VSS) capacitor c=3.5923e-17
C17 (\3\:BN VSS) capacitor c=2.90949e-17
C18 (\2\:AN VSS) capacitor c=3.27598e-17
C19 (\2\:BN VSS) capacitor c=3.90851e-17
C20 (\16\:n0 VSS) capacitor c=6.38487e-17
C21 (\35\:VDD VSS) capacitor c=3.44239e-17
C22 (\18\:n1 VSS) capacitor c=8.45805e-17
C23 (\1\:VDD VSS) capacitor c=3.79602e-17
C24 (\1\:Y VSS) capacitor c=1.31505e-16
C25 (\4\:n3 VSS) capacitor c=1.42177e-16
C26 (\18\:n0 VSS) capacitor c=6.0001e-17
C27 (\16\:n1 VSS) capacitor c=2.76285e-16
C28 (\4\:BN VSS) capacitor c=3.4142e-17
C29 (\4\:AN VSS) capacitor c=5.13365e-17
C30 (\14\:n0 VSS) capacitor c=5.90175e-17
C31 (\15\:n0 VSS) capacitor c=6.97404e-17
C32 (\15\:n1 VSS) capacitor c=2.01376e-16
C33 (\14\:C VSS) capacitor c=6.74889e-17
C34 (\16\:D VSS) capacitor c=5.14373e-17
C35 (\5\:Y VSS) capacitor c=1.71812e-16
C36 (\7\:Y VSS) capacitor c=1.64642e-16
C37 (\9\:Y VSS) capacitor c=1.37557e-16
C38 (\11\:Y VSS) capacitor c=1.27789e-16
C39 (\3\:VDD VSS) capacitor c=5.16707e-16
C40 (\15\:VDD VSS) capacitor c=1.50898e-17
Rk1 (\4\:BN BN) resistor r=0.021 c=0
Rk17 (D \16\:D) resistor r=0.1098 c=0
Rk65 (\2\:VSS \3\:VSS) resistor r=0.8525 c=0
Rk66 (\3\:VSS \4\:VSS) resistor r=0.3759 c=0
Rk68 (\4\:VSS \6\:VSS) resistor r=0.1904 c=0
Rk69 (\6\:VSS \7\:VSS) resistor r=0.2205 c=0
Rk71 (\8\:VSS VSS) resistor r=0.0499 c=0
Rk70 (\7\:VSS \8\:VSS) resistor r=0.08004 c=0
Rk74 (\7\:VSS \14\:VSS) resistor r=0.2799 c=0
Rk12 (C \14\:C) resistor r=0.02606 c=0
Rk19 (\1\:Y \5\:Y) resistor r=0.432 c=0
Rk21 (\5\:Y \7\:Y) resistor r=0.3033 c=0
Rk23 (\7\:Y \9\:Y) resistor r=0.3044 c=0
Rk35 (\11\:Y Y) resistor r=0.01692 c=0
Rk25 (\9\:Y \11\:Y) resistor r=0.2996 c=0
Rk2 (AN \4\:AN) resistor r=0.135 c=0
Rk40 (\2\:VDD \3\:VDD) resistor r=0.065 c=0
Rk52 (\3\:VDD \15\:VDD) resistor r=0.3281 c=0
Rk54 (\16\:VDD VDD) resistor r=0.0499 c=0
Rk53 (\15\:VDD \16\:VDD) resistor r=0.1177 c=0
Rk64 (\15\:VDD \36\:VDD) resistor r=0.181 c=0
Rk6 (\15\:n1 \17\:n1) resistor r=1.7189 c=0
Rk7 (\17\:n1 \19\:n1) resistor r=0.651 c=0
Rk3 (\14\:n0 \15\:n0) resistor r=0.3252 c=0
Rk4 (\15\:n0 \17\:n0) resistor r=0.3093 c=0
Rk5 (\15\:n0 \19\:n0) resistor r=0.2262 c=0
Rk14 (n3 \4\:n3) resistor r=0.4388 c=0
Rl1 (\1\:BN \2\:BN) resistor r=92.3077 c=0
Rl2 (\2\:BN \3\:BN) resistor r=57.1429 c=0
Rl3 (\1\:AN \2\:AN) resistor r=91.0764 c=0
Rl4 (\2\:AN \3\:AN) resistor r=56.461 c=0
Rz26 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz19 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz22 (\3\:VDD \1\:VDD) resistor r=3.75 c=0
Rz23 (\16\:VDD \1\:VDD) resistor r=37.5 c=0
Rz2 (\17\:n1 \16\:n1) resistor r=75 c=0
Rz1 (\19\:n0 \18\:n0) resistor r=75 c=0
Ry21 (\2\:VSS \1\:VSS) resistor r=12.4 c=0
Ry22 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry23 (\6\:VSS \1\:VSS) resistor r=15.5 c=0
Ry24 (\8\:VSS \1\:VSS) resistor r=31 c=0
Ry20 (\36\:VDD \35\:VDD) resistor r=62 c=0
Ry2 (\19\:n1 \18\:n1) resistor r=62 c=0
Ry1 (\17\:n0 \16\:n0) resistor r=20.6667 c=0
Rx1 (\2\:BN \4\:BN) resistor r=45 c=0
Rx6 (\16\:D \1\:D) resistor r=45 c=0
Rx5 (\14\:C \1\:C) resistor r=45 c=0
Rx2 (\2\:AN \4\:AN) resistor r=45 c=0
Rx4 (\15\:n1 n1) resistor r=45 c=0
Rx3 (\14\:n0 n0) resistor r=45 c=0
mn1 (\16\:n1 \3\:BN \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=3.64e-14 ps=9.9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn0 (\18\:n0 \3\:AN \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=4.68e-14 ps=9.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.2e-07 sb=1.8e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn2_1__rcx (n2 n0 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.127e-14 ps=8.4e-07 pd=8.375e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.59e-06 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(4)
mn3_1__rcx (\4\:n3 n1 n2 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.127e-14 ad=4.16e-14 ps=8.375e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=7.55e-07 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(4)
mn4_1__rcx (n4 \1\:C n3 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(4)
mn5_1__rcx (\1\:Y \1\:D n4 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(4)
mp0 (\16\:n0 \1\:AN \35\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.63e-14 ps=1.1e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.7e-07 sd=160n sca=13.2347 \
        scb=0.0110279 scc=0.000235823 m=(1)
mp2_1__rcx (\11\:Y n0 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(4)
mp3_1__rcx (\9\:Y n1 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(4)
mp4_1__rcx (\7\:Y \1\:C \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=1.575e-06 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(4)
mp5_1__rcx (\5\:Y \1\:D \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=16.2957 scb=0.0145851 \
        scc=0.00118861 m=(4)
ends NAND4BBX4
// End of subcircuit definition.

// Generated for: spectre (May  9 15:58:40 2012 )
// Library name: gsclib045
// Cell name: NAND4BBXL
// View name: extracted

simulator lang=spectre

subckt NAND4BBXL AN BN C D VDD VSS Y
mp1 (\9\:n1 \1\:BN \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=35.6444 \
        scb=0.0398802 scc=0.00365724 m=(1)
C1 (Y VSS) capacitor c=1.08078e-16
C2 (C VSS) capacitor c=3.28822e-17
C3 (VDD VSS) capacitor c=1.46612e-16
C4 (n1 VSS) capacitor c=6.89928e-17
C5 (n4 VSS) capacitor c=1.62358e-18
C6 (n3 VSS) capacitor c=3.97837e-18
C7 (n2 VSS) capacitor c=3.96821e-18
C8 (n0 VSS) capacitor c=6.30568e-17
C9 (\1\:AN VSS) capacitor c=4.55644e-17
C10 (\1\:C VSS) capacitor c=5.37607e-17
C11 (\3\:D VSS) capacitor c=3.53304e-17
C12 (\1\:BN VSS) capacitor c=3.16234e-17
C13 (\3\:AN VSS) capacitor c=4.67912e-17
C14 (\3\:n0 VSS) capacitor c=2.89855e-17
C15 (\4\:n1 VSS) capacitor c=2.76825e-17
C16 (\3\:C VSS) capacitor c=8.71177e-17
C17 (\1\:D VSS) capacitor c=7.88987e-17
C18 (\4\:BN VSS) capacitor c=3.06178e-17
C19 (\2\:AN VSS) capacitor c=5.6179e-17
C20 (\2\:n0 VSS) capacitor c=6.66006e-17
C21 (\3\:n1 VSS) capacitor c=2.74868e-17
C22 (\2\:C VSS) capacitor c=8.04558e-17
C23 (\2\:D VSS) capacitor c=7.5337e-17
C24 (\3\:BN VSS) capacitor c=1.11021e-17
C25 (\4\:n0 VSS) capacitor c=5.70456e-17
C26 (\9\:VDD VSS) capacitor c=2.34907e-17
C27 (\1\:Y VSS) capacitor c=1.5118e-17
C28 (\11\:VDD VSS) capacitor c=2.79305e-17
C29 (\6\:Y VSS) capacitor c=5.97407e-17
C30 (\13\:VDD VSS) capacitor c=1.87725e-17
C31 (\9\:n1 VSS) capacitor c=7.21058e-17
C32 (\7\:VDD VSS) capacitor c=3.06766e-17
C33 (\1\:VDD VSS) capacitor c=3.00406e-17
C34 (\8\:n0 VSS) capacitor c=3.08759e-17
C35 (\4\:Y VSS) capacitor c=1.10012e-16
C36 (\7\:n1 VSS) capacitor c=2.81907e-17
C37 (\2\:BN VSS) capacitor c=1.7718e-17
C38 (\2\:n1 VSS) capacitor c=4.51941e-17
C39 (\5\:BN VSS) capacitor c=1.06538e-16
C40 (\4\:D VSS) capacitor c=5.53685e-17
C41 (\5\:D VSS) capacitor c=6.52914e-17
C42 (\4\:C VSS) capacitor c=7.5061e-17
C43 (\5\:n1 VSS) capacitor c=8.04694e-17
C44 (\6\:n1 VSS) capacitor c=8.11233e-17
C45 (\3\:Y VSS) capacitor c=3.43855e-17
C46 (\4\:AN VSS) capacitor c=1.0665e-16
C47 (\6\:n0 VSS) capacitor c=5.51705e-17
C48 (\7\:n0 VSS) capacitor c=4.37054e-17
C49 (\3\:VDD VSS) capacitor c=1.00911e-17
C50 (\4\:VDD VSS) capacitor c=1.32834e-17
C51 (\6\:VDD VSS) capacitor c=4.86921e-18
Rk1 (BN \5\:BN) resistor r=0.005134 c=0
Rk3 (\5\:BN \6\:BN) resistor r=0.02321 c=0
Rk2 (\6\:BN \7\:BN) resistor r=0.005134 c=0
Rk28 (\2\:VSS \3\:VSS) resistor r=0.1002 c=0
Rk30 (\4\:VSS VSS) resistor r=0.3011 c=0
Rk29 (\3\:VSS \4\:VSS) resistor r=0.3511 c=0
Rk31 (VSS \6\:VSS) resistor r=0.2196 c=0
Rk32 (\3\:VSS \8\:VSS) resistor r=0.2257 c=0
Rk15 (AN \4\:AN) resistor r=0.01812 c=0
Rk12 (\3\:Y Y) resistor r=0.1133 c=0
Rk11 (\2\:Y \3\:Y) resistor r=0.05606 c=0
Rk13 (Y \5\:Y) resistor r=0.8519 c=0
Rk14 (\3\:Y \7\:Y) resistor r=0.3009 c=0
Rk7 (C \4\:C) resistor r=0.01074 c=0
Rk19 (\2\:VDD \3\:VDD) resistor r=0.1002 c=0
Rk20 (\3\:VDD \4\:VDD) resistor r=0.253 c=0
Rk21 (\4\:VDD \5\:VDD) resistor r=0.09766 c=0
Rk23 (\6\:VDD VDD) resistor r=0.2081 c=0
Rk22 (\5\:VDD \6\:VDD) resistor r=0.09264 c=0
Rk24 (VDD \8\:VDD) resistor r=0.3814 c=0
Rk25 (\3\:VDD \10\:VDD) resistor r=0.175 c=0
Rk26 (\4\:VDD \12\:VDD) resistor r=0.1702 c=0
Rk27 (\6\:VDD \14\:VDD) resistor r=0.175 c=0
Rk4 (D \4\:D) resistor r=0.01414 c=0
Rk6 (\4\:D \5\:D) resistor r=0.0542 c=0
Rk5 (\5\:D \6\:D) resistor r=0.01424 c=0
Rk8 (\5\:n1 \6\:n1) resistor r=0.458 c=0
Rk9 (\6\:n1 \8\:n1) resistor r=0.144 c=0
Rk10 (\6\:n1 \10\:n1) resistor r=0.3449 c=0
Rk16 (\5\:n0 \6\:n0) resistor r=0.5358 c=0
Rk17 (\6\:n0 \7\:n0) resistor r=0.2395 c=0
Rk18 (\6\:n0 \9\:n0) resistor r=0.2002 c=0
Rl1 (\1\:BN \2\:BN) resistor r=105.483 c=0
Rl3 (\2\:BN \4\:BN) resistor r=95.868 c=0
Rl2 (\2\:BN \3\:BN) resistor r=1.2666 c=0
Rl13 (\1\:AN \2\:AN) resistor r=148.769 c=0
Rl14 (\2\:AN \3\:AN) resistor r=139.153 c=0
Rl6 (\1\:C \2\:C) resistor r=127.615 c=0
Rl7 (\2\:C \3\:C) resistor r=160.307 c=0
Rl5 (\2\:D \3\:D) resistor r=57.8815 c=0
Rl4 (\1\:D \2\:D) resistor r=232.258 c=0
Rl8 (n1 \2\:n1) resistor r=266.187 c=0
Rl10 (\2\:n1 \4\:n1) resistor r=37.3411 c=0
Rl9 (\2\:n1 \3\:n1) resistor r=3.1183 c=0
Rl11 (n0 \2\:n0) resistor r=251.156 c=0
Rl12 (\2\:n0 \3\:n0) resistor r=33.8482 c=0
Rz6 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz7 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz2 (\4\:Y \5\:Y) resistor r=75 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VDD \5\:VDD) resistor r=10.7143 c=0
Rz1 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz3 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry9 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry10 (\1\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry2 (\1\:Y \2\:Y) resistor r=62 c=0
Ry3 (\6\:Y \7\:Y) resistor r=62 c=0
Ry5 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry6 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry7 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry8 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry1 (\9\:n1 \10\:n1) resistor r=62 c=0
Ry4 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx1 (\3\:BN \7\:BN) resistor r=45 c=0
Rx5 (\2\:AN \4\:AN) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\2\:D \6\:D) resistor r=45 c=0
Rx4 (\3\:n1 \5\:n1) resistor r=45 c=0
Rx6 (\2\:n0 \7\:n0) resistor r=45 c=0
mn1 (\7\:n1 \4\:BN \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.05e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn5 (\4\:Y \1\:D n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=9.25e-07 sd=160n sca=8.0352 scb=0.00565402 \
        scc=8.19771e-05 m=(1)
mn4 (n4 \3\:C n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=8.2e-07 sd=160n sca=8.0352 scb=0.00565402 \
        scc=8.19771e-05 m=(1)
mn3 (n3 \4\:n1 n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=3.263e-14 \
        ad=2.32e-14 ps=7.4e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=6.15e-07 sd=160n sca=8.0352 scb=0.00565402 \
        scc=8.19771e-05 m=(1)
mn2 (n2 \3\:n0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.263e-14 ps=6.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=3.45e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn0 (\8\:n0 \3\:AN \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.4e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mp5 (\6\:Y \3\:D \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.115e-06 sd=160n sca=11.5997 \
        scb=0.00852753 scc=9.93622e-05 m=(1)
mp4 (\6\:Y \1\:C \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.1e-07 sd=160n sca=10.7035 \
        scb=0.00787982 scc=9.84727e-05 m=(1)
mp3 (\1\:Y n1 \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.837e-14 ps=7.5e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.05e-07 sd=160n sca=10.8626 \
        scb=0.00795231 scc=9.85034e-05 m=(1)
mp2 (\1\:Y n0 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.837e-14 ps=7.5e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=4.35e-07 sd=160n sca=12.5842 \
        scb=0.00978897 scc=0.000105974 m=(1)
mp0 (\4\:n0 \1\:AN \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.945e-14 ps=7.5e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=2.3e-07 sd=160n sca=17.2741 \
        scb=0.017802 scc=0.000385905 m=(1)
ends NAND4BBXL
// End of subcircuit definition.

// Generated for: spectre (May  9 15:59:18 2012 )
// Library name: gsclib045
// Cell name: NAND4BX1
// View name: extracted

simulator lang=spectre

subckt NAND4BX1 AN B C D VDD VSS Y
mp4 (\4\:Y \3\:D \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.05577e-07 sd=160n sca=18.7456 \
        scb=0.0202985 scc=0.000573036 m=(1)
mp1 (\1\:Y net118 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=6.24e-14 ps=1.16e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.80577e-07 sd=160n sca=13.8723 \
        scb=0.0118284 scc=0.000241736 m=(1)
C1 (C VSS) capacitor c=1.27852e-16
C2 (VDD VSS) capacitor c=1.04524e-16
C3 (Y VSS) capacitor c=7.92476e-17
C4 (AN VSS) capacitor c=7.62219e-17
C5 (net122 VSS) capacitor c=1.12121e-18
C6 (net126 VSS) capacitor c=4.06786e-18
C7 (net118 VSS) capacitor c=6.07953e-17
C8 (\1\:AN VSS) capacitor c=3.73531e-17
C9 (\1\:B VSS) capacitor c=5.30222e-17
C10 (\1\:C VSS) capacitor c=5.24178e-17
C11 (\3\:D VSS) capacitor c=4.12388e-17
C12 (\3\:AN VSS) capacitor c=3.36987e-17
C13 (\3\:net118 VSS) capacitor c=5.33889e-17
C14 (\3\:B VSS) capacitor c=5.22137e-17
C15 (\3\:C VSS) capacitor c=4.80064e-17
C16 (\1\:D VSS) capacitor c=4.23486e-17
C17 (\2\:AN VSS) capacitor c=4.1272e-17
C18 (\2\:net118 VSS) capacitor c=4.94984e-17
C19 (\2\:B VSS) capacitor c=4.97369e-17
C20 (\2\:C VSS) capacitor c=4.873e-17
C21 (\2\:D VSS) capacitor c=3.85312e-17
C22 (\4\:net118 VSS) capacitor c=5.64625e-17
C23 (\9\:VDD VSS) capacitor c=2.28181e-17
C24 (\1\:Y VSS) capacitor c=6.14286e-17
C25 (\11\:VDD VSS) capacitor c=4.19673e-17
C26 (\4\:Y VSS) capacitor c=3.17845e-17
C27 (\13\:VDD VSS) capacitor c=3.14619e-17
C28 (\1\:VDD VSS) capacitor c=5.06287e-17
C29 (\6\:net118 VSS) capacitor c=6.29931e-17
C30 (\6\:Y VSS) capacitor c=6.20576e-17
C31 (\4\:D VSS) capacitor c=1.31242e-16
C32 (\4\:B VSS) capacitor c=1.19721e-16
C33 (\3\:Y VSS) capacitor c=6.13836e-17
C34 (\4\:AN VSS) capacitor c=3.29324e-17
C35 (\8\:net118 VSS) capacitor c=5.94562e-17
C36 (\3\:VDD VSS) capacitor c=1.54129e-18
C37 (\5\:VDD VSS) capacitor c=2.0441e-18
C38 (\7\:VDD VSS) capacitor c=1.53631e-18
Rk3 (B \4\:B) resistor r=0.002506 c=0
Rk24 (\4\:VSS VSS) resistor r=0.3005 c=0
Rk23 (\2\:VSS \4\:VSS) resistor r=0.3945 c=0
Rk2 (C \4\:C) resistor r=0.002814 c=0
Rk13 (\2\:VDD \3\:VDD) resistor r=0.09253 c=0
Rk14 (\3\:VDD \4\:VDD) resistor r=0.1076 c=0
Rk15 (\4\:VDD \5\:VDD) resistor r=0.1026 c=0
Rk16 (\5\:VDD \6\:VDD) resistor r=0.09754 c=0
Rk18 (\7\:VDD VDD) resistor r=0.04216 c=0
Rk17 (\6\:VDD \7\:VDD) resistor r=0.1076 c=0
Rk20 (\3\:VDD \10\:VDD) resistor r=0.1776 c=0
Rk21 (\5\:VDD \12\:VDD) resistor r=0.1831 c=0
Rk22 (\7\:VDD \14\:VDD) resistor r=0.1776 c=0
Rk1 (\4\:D D) resistor r=0.002995 c=0
Rk5 (\3\:Y Y) resistor r=0.3173 c=0
Rk4 (\2\:Y \3\:Y) resistor r=0.3736 c=0
Rk6 (\3\:Y \5\:Y) resistor r=0.05755 c=0
Rk7 (Y \7\:Y) resistor r=0.4874 c=0
Rk10 (\4\:AN AN) resistor r=0.02096 c=0
Rk11 (\5\:net118 \7\:net118) resistor r=0.4299 c=0
Rk12 (\7\:net118 \8\:net118) resistor r=0.2576 c=0
Rl5 (\1\:B \2\:B) resistor r=79.5379 c=0
Rl6 (\2\:B \3\:B) resistor r=67.9995 c=0
Rl3 (\1\:C \2\:C) resistor r=75.6918 c=0
Rl4 (\2\:C \3\:C) resistor r=71.8456 c=0
Rl2 (\2\:D \3\:D) resistor r=79.0354 c=0
Rl1 (\1\:D \2\:D) resistor r=69.2308 c=0
Rl9 (\1\:AN \2\:AN) resistor r=92.3077 c=0
Rl10 (\2\:AN \3\:AN) resistor r=57.1429 c=0
Rl7 (net118 \2\:net118) resistor r=103.378 c=0
Rl8 (\2\:net118 \3\:net118) resistor r=43.7671 c=0
Rz7 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\1\:VDD VDD) resistor r=75 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VDD \6\:VDD) resistor r=37.5 c=0
Rz1 (\6\:Y \7\:Y) resistor r=75 c=0
Rz2 (\6\:net118 \7\:net118) resistor r=75 c=0
Ry4 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry5 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry6 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry2 (\4\:Y \5\:Y) resistor r=31 c=0
Ry3 (\4\:net118 \5\:net118) resistor r=62 c=0
Rx3 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:AN \4\:AN) resistor r=45 c=0
Rx5 (\2\:net118 \8\:net118) resistor r=45 c=0
mn4 (\6\:Y \1\:D net122 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.86e-14 ad=3.64e-14 ps=7.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.71058e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn3 (net122 \3\:C net126 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=2.86e-14 ps=8.6e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.95e-07 sb=6.16058e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn2 (net126 \3\:B net130 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.21e-14 ad=4.42e-14 ps=6.9e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=4.01058e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn1 (net130 \3\:net118 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.21e-14 ps=9e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=2.71058e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn0 (\6\:net118 \3\:AN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=1.4e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mp3 (\4\:Y \1\:C \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=6.24e-14 ps=1.12e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.00577e-07 sd=160n sca=13.8229 \
        scb=0.0117387 scc=0.000240879 m=(1)
mp2 (\1\:Y \1\:B \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=6.24e-14 ps=1.12e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=4.85577e-07 sd=160n sca=12.9393 \
        scb=0.0102305 scc=0.000232248 m=(1)
mp0 (\4\:net118 \1\:AN \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.44e-14 ps=1.16e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=1.6e-07 sd=160n sca=21.4608 scb=0.0245314 \
        scc=0.000949294 m=(1)
ends NAND4BX1
// End of subcircuit definition.

// Generated for: spectre (May  9 15:59:56 2012 )
// Library name: gsclib045
// Cell name: NAND4BX2
// View name: extracted

simulator lang=spectre

subckt NAND4BX2 AN B C D VDD VSS Y
mp0 (\12\:net118 \1\:AN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=5.15e-14 ps=7.1e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.39535e-07 sd=160n sca=56.1973 \
        scb=0.0435219 scc=0.00667686 m=(1)
C1 (VDD VSS) capacitor c=1.2377e-16
C2 (B VSS) capacitor c=5.40993e-17
C3 (D VSS) capacitor c=5.65352e-17
C4 (AN VSS) capacitor c=4.41809e-17
C5 (net118 VSS) capacitor c=7.74697e-17
C6 (net130 VSS) capacitor c=1.91232e-16
C7 (net126 VSS) capacitor c=1.19044e-16
C8 (net122 VSS) capacitor c=1.71544e-16
C9 (\1\:B VSS) capacitor c=1.0003e-16
C10 (\1\:AN VSS) capacitor c=2.57826e-17
C11 (\1\:D VSS) capacitor c=7.41074e-17
C12 (\1\:C VSS) capacitor c=8.85052e-17
C13 (\3\:AN VSS) capacitor c=1.84885e-17
C14 (\3\:D VSS) capacitor c=8.93601e-17
C15 (\3\:C VSS) capacitor c=1.04206e-16
C16 (\3\:net118 VSS) capacitor c=1.27099e-17
C17 (\2\:AN VSS) capacitor c=1.67416e-17
C18 (\1\:Y VSS) capacitor c=8.26265e-17
C19 (\8\:Y VSS) capacitor c=3.60335e-17
C20 (\10\:Y VSS) capacitor c=4.04177e-17
C21 (\6\:Y VSS) capacitor c=5.30495e-17
C22 (\12\:net118 VSS) capacitor c=1.07254e-17
C23 (\20\:VDD VSS) capacitor c=2.2359e-17
C24 (\1\:VDD VSS) capacitor c=1.63947e-17
C25 (\12\:Y VSS) capacitor c=1.91616e-16
C26 (\3\:net126 VSS) capacitor c=1.16268e-16
C27 (\10\:net118 VSS) capacitor c=4.88938e-17
C28 (\5\:net118 VSS) capacitor c=6.9053e-17
C29 (\3\:B VSS) capacitor c=8.56823e-17
C30 (\4\:AN VSS) capacitor c=3.97256e-17
C31 (\8\:net118 VSS) capacitor c=2.06215e-17
C32 (\9\:net118 VSS) capacitor c=2.71483e-17
C33 (\7\:B VSS) capacitor c=5.12125e-17
C34 (\7\:C VSS) capacitor c=6.43373e-17
C35 (\9\:C VSS) capacitor c=6.72035e-17
C36 (\3\:Y VSS) capacitor c=6.84797e-17
C37 (\4\:Y VSS) capacitor c=3.27025e-17
C38 (\5\:Y VSS) capacitor c=1.55849e-16
C39 (\7\:D VSS) capacitor c=3.63146e-17
C40 (\3\:VDD VSS) capacitor c=2.79008e-16
C41 (\9\:VDD VSS) capacitor c=8.79826e-18
Rk9 (\7\:C \8\:C) resistor r=0.002116 c=0
Rk10 (C \9\:C) resistor r=0.002116 c=0
Rk11 (\7\:C \9\:C) resistor r=0.04922 c=0
Rk23 (\2\:VDD \3\:VDD) resistor r=0.07506 c=0
Rk30 (\9\:VDD VDD) resistor r=0.01711 c=0
Rk29 (\3\:VDD \9\:VDD) resistor r=0.2881 c=0
Rk36 (\9\:VDD \21\:VDD) resistor r=0.4193 c=0
Rk12 (\2\:Y \3\:Y) resistor r=0.3759 c=0
Rk17 (\4\:Y Y) resistor r=0.03368 c=0
Rk13 (\3\:Y \4\:Y) resistor r=0.338 c=0
Rk14 (\4\:Y \5\:Y) resistor r=0.09266 c=0
Rk15 (\5\:Y \7\:Y) resistor r=0.2859 c=0
Rk16 (\3\:Y \9\:Y) resistor r=0.05819 c=0
Rk18 (Y \11\:Y) resistor r=0.01112 c=0
Rk19 (\5\:Y \13\:Y) resistor r=1.2418 c=0
Rk7 (\7\:B B) resistor r=0.03181 c=0
Rk22 (\7\:D D) resistor r=0.02957 c=0
Rk37 (\2\:VSS \3\:VSS) resistor r=0.4438 c=0
Rk38 (\3\:VSS \4\:VSS) resistor r=0.1579 c=0
Rk40 (\5\:VSS VSS) resistor r=0.03718 c=0
Rk39 (\4\:VSS \5\:VSS) resistor r=0.1629 c=0
Rk42 (\3\:VSS \8\:VSS) resistor r=0.1952 c=0
Rk43 (\5\:VSS \10\:VSS) resistor r=0.07416 c=0
Rk1 (AN \4\:AN) resistor r=0.09243 c=0
Rk2 (\8\:net118 \9\:net118) resistor r=0.08653 c=0
Rk3 (\9\:net118 \11\:net118) resistor r=0.2283 c=0
Rk4 (\9\:net118 \13\:net118) resistor r=0.06384 c=0
Rk8 (\2\:net126 \4\:net126) resistor r=0.395 c=0
Rl15 (\3\:C \1\:C) resistor r=75.3894 c=0
Rl10 (\3\:B \1\:B) resistor r=81.1008 c=0
Rl20 (\3\:D \1\:D) resistor r=27.8457 c=0
Rl1 (\1\:AN \2\:AN) resistor r=39.6174 c=0
Rl2 (\2\:AN \3\:AN) resistor r=24.2328 c=0
Rl4 (net118 \3\:net118) resistor r=15.8314 c=0
Rl6 (\5\:net118 \3\:net118) resistor r=36.6223 c=0
Rz11 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz12 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz7 (\13\:Y \12\:Y) resistor r=75 c=0
Rz13 (\8\:VSS \7\:VSS) resistor r=75 c=0
Rz14 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz1 (\11\:net118 \10\:net118) resistor r=75 c=0
Rz5 (\2\:net126 net126) resistor r=75 c=0
Rz6 (\4\:net126 \3\:net126) resistor r=75 c=0
Ry11 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry2 (\2\:Y \1\:Y) resistor r=31 c=0
Ry3 (\7\:Y \6\:Y) resistor r=31 c=0
Ry4 (\9\:Y \8\:Y) resistor r=31 c=0
Ry5 (\11\:Y \10\:Y) resistor r=31 c=0
Ry14 (VSS \1\:VSS) resistor r=62 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=6.8889 c=0
Ry13 (\4\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry1 (\13\:net118 \12\:net118) resistor r=62 c=0
Rx4 (\8\:C \3\:C) resistor r=45 c=0
Rx3 (\7\:B \1\:B) resistor r=45 c=0
Rx5 (\7\:D \3\:D) resistor r=45 c=0
Rx1 (\2\:AN \4\:AN) resistor r=45 c=0
Rx2 (\8\:net118 \3\:net118) resistor r=45 c=0
mn0 (\10\:net118 \3\:AN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.465e-14 ad=2.755e-14 ps=1.5e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn1 (net130 \5\:net118 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(2)
mn2 (\3\:net126 \3\:B net130 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.55e-14 ps=8.2e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.6e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(2)
mn3 (net122 \1\:C net126 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.095e-14 ps=8.4e-07 pd=8.35e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=7.55e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mn4 (\12\:Y \1\:D net122 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=3.45e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(2)
mp1 (\6\:Y net118 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.31e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=1.575e-06 sd=160n sca=14.4586 \
        scb=0.0128281 scc=0.000754439 m=(2)
mp2 (\10\:Y \1\:B \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.22308e-07 sb=1.165e-06 sd=160n sca=14.1011 \
        scb=0.0127228 scc=0.000754417 m=(2)
mp3 (\8\:Y \3\:C \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.32308e-07 sb=7.55e-07 sd=160n sca=14.1011 \
        scb=0.0127228 scc=0.000754417 m=(2)
mp4 (\1\:Y \3\:D \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.34231e-06 sb=3.45e-07 sd=160n sca=15.7702 \
        scb=0.0139777 scc=0.000757166 m=(2)
ends NAND4BX2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:00:35 2012 )
// Library name: gsclib045
// Cell name: NAND4BX4
// View name: extracted

simulator lang=spectre

subckt NAND4BX4 AN B C D VDD VSS Y
mp0 (\20\:net118 \1\:AN \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=43.6185 \
        scb=0.0386349 scc=0.00465805 m=(1)
C1 (C VSS) capacitor c=5.37441e-16
C2 (Y VSS) capacitor c=1.39991e-16
C3 (B VSS) capacitor c=9.66768e-17
C4 (VDD VSS) capacitor c=1.53141e-16
C5 (D VSS) capacitor c=5.83285e-17
C6 (AN VSS) capacitor c=2.02171e-17
C7 (net118 VSS) capacitor c=3.32081e-16
C8 (net130 VSS) capacitor c=3.8596e-16
C9 (net126 VSS) capacitor c=2.35347e-16
C10 (net122 VSS) capacitor c=4.15483e-16
C11 (\1\:D VSS) capacitor c=3.06759e-16
C12 (\1\:B VSS) capacitor c=2.99903e-16
C13 (\1\:AN VSS) capacitor c=2.98741e-17
C14 (\4\:AN VSS) capacitor c=2.62361e-17
C15 (\3\:AN VSS) capacitor c=1.05263e-17
C16 (\1\:VDD VSS) capacitor c=5.37119e-16
C17 (\20\:net118 VSS) capacitor c=8.2992e-17
C18 (\16\:VDD VSS) capacitor c=3.23461e-17
C19 (\1\:Y VSS) capacitor c=3.66297e-16
C20 (\5\:net126 VSS) capacitor c=2.05947e-16
C21 (\18\:net118 VSS) capacitor c=2.15102e-17
C22 (\2\:AN VSS) capacitor c=1.07561e-17
C23 (\5\:AN VSS) capacitor c=8.20183e-17
C24 (\17\:net118 VSS) capacitor c=5.48608e-17
C25 (\5\:Y VSS) capacitor c=2.58862e-16
C26 (\6\:Y VSS) capacitor c=1.55562e-16
C27 (\17\:Y VSS) capacitor c=1.82388e-16
C28 (\23\:Y VSS) capacitor c=1.98276e-16
Rk68 (\2\:VSS \3\:VSS) resistor r=1.1038 c=0
Rk71 (\4\:VSS VSS) resistor r=0.3085 c=0
Rk69 (\3\:VSS \4\:VSS) resistor r=0.03743 c=0
Rk72 (VSS \7\:VSS) resistor r=0.2823 c=0
Rk26 (\5\:Y Y) resistor r=0.02031 c=0
Rk23 (\1\:Y \5\:Y) resistor r=1.9032 c=0
Rk24 (\5\:Y \6\:Y) resistor r=0.2682 c=0
Rk32 (Y \17\:Y) resistor r=0.3091 c=0
Rk36 (\17\:Y \23\:Y) resistor r=0.4323 c=0
Rk6 (B \1\:B) resistor r=0.01834 c=0
Rk58 (\1\:VDD VDD) resistor r=0.2056 c=0
Rk59 (VDD \17\:VDD) resistor r=0.3173 c=0
Rk20 (\1\:D D) resistor r=0.006306 c=0
Rk1 (\5\:AN AN) resistor r=0.01142 c=0
Rk3 (net118 \17\:net118) resistor r=0.3292 c=0
Rk4 (\17\:net118 \19\:net118) resistor r=0.1043 c=0
Rk5 (\17\:net118 \21\:net118) resistor r=0.3004 c=0
Rk14 (net126 \5\:net126) resistor r=0.4888 c=0
Rl1 (\1\:AN \2\:AN) resistor r=57.4064 c=0
Rl3 (\2\:AN \4\:AN) resistor r=34.3295 c=0
Rl2 (\2\:AN \3\:AN) resistor r=1.2666 c=0
Rz22 (\7\:VSS \6\:VSS) resistor r=75 c=0
Rz1 (\19\:net118 \18\:net118) resistor r=75 c=0
Ry20 (\2\:VSS \1\:VSS) resistor r=6.2 c=0
Ry21 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry11 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry1 (\21\:net118 \20\:net118) resistor r=20.6667 c=0
Rx1 (\3\:AN \5\:AN) resistor r=45 c=0
mn0 (\18\:net118 \4\:AN \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mn1 (net130 net118 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn2 (\5\:net126 \1\:B net130 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn3 (net122 C net126 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=6.24e-14 ps=8.4e-07 pd=1e-06 nrd=1.16667 nrs=1.16667 sa=1.4e-07 \
        sb=1.77e-06 sd=160n sca=9.50447 scb=0.0081528 scc=0.00025289 m=(4)
mn4 (\1\:Y \1\:D net122 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=4.16e-14 ps=8.55e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13e-06 sb=7.8e-07 sd=160n sca=9.50447 \
        scb=0.0081528 scc=0.00025289 m=(4)
mp1 (\6\:Y net118 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.191e-14 ad=6.24e-14 ps=1.0975e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.4951 scb=0.0160444 \
        scc=0.00137992 m=(4)
mp2 (Y \1\:B \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.386e-14 ad=6.24e-14 ps=1.1075e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=2e-06 sd=160n sca=17.2385 scb=0.0152696 \
        scc=0.00137893 m=(4)
mp3 (\17\:Y C \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.654e-14 ad=6.24e-14 ps=1.1725e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.795e-06 sb=1.72e-06 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(4)
mp4 (\23\:Y \1\:D \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.459e-14 ad=6.24e-14 ps=1.1625e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=17.2385 scb=0.0152696 \
        scc=0.00137893 m=(4)
ends NAND4BX4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:01:17 2012 )
// Library name: gsclib045
// Cell name: NAND4BXL
// View name: extracted

simulator lang=spectre

subckt NAND4BXL AN B C D VDD VSS Y
mp4 (\4\:Y \3\:D \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.035e-06 sd=160n sca=18.0123 \
        scb=0.019139 scc=0.000475418 m=(1)
C1 (Y VSS) capacitor c=7.02388e-17
C2 (B VSS) capacitor c=3.09419e-17
C3 (C VSS) capacitor c=1.23178e-16
C4 (VDD VSS) capacitor c=1.1511e-16
C5 (D VSS) capacitor c=7.59504e-17
C6 (net122 VSS) capacitor c=9.49579e-19
C7 (net126 VSS) capacitor c=5.24897e-19
C8 (net130 VSS) capacitor c=4.42068e-19
C9 (net118 VSS) capacitor c=6.68484e-17
C10 (\1\:AN VSS) capacitor c=3.5693e-17
C11 (\1\:B VSS) capacitor c=7.47104e-17
C12 (\1\:C VSS) capacitor c=6.23847e-17
C13 (\3\:D VSS) capacitor c=4.89074e-17
C14 (\3\:AN VSS) capacitor c=4.98936e-17
C15 (\3\:net118 VSS) capacitor c=2.92599e-17
C16 (\3\:B VSS) capacitor c=3.14463e-17
C17 (\3\:C VSS) capacitor c=5.01523e-17
C18 (\1\:D VSS) capacitor c=3.28176e-17
C19 (\2\:AN VSS) capacitor c=4.97606e-17
C20 (\2\:net118 VSS) capacitor c=6.36388e-17
C21 (\2\:B VSS) capacitor c=6.64668e-17
C22 (\2\:C VSS) capacitor c=6.36758e-17
C23 (\2\:D VSS) capacitor c=5.40387e-17
C24 (\4\:net118 VSS) capacitor c=5.40561e-17
C25 (\9\:VDD VSS) capacitor c=8.38147e-18
C26 (\1\:Y VSS) capacitor c=2.98854e-17
C27 (\11\:VDD VSS) capacitor c=9.32306e-18
C28 (\4\:Y VSS) capacitor c=8.00536e-18
C29 (\13\:VDD VSS) capacitor c=2.53432e-17
C30 (\1\:VDD VSS) capacitor c=3.5916e-17
C31 (\8\:net118 VSS) capacitor c=3.23332e-17
C32 (\6\:Y VSS) capacitor c=4.37218e-17
C33 (\4\:D VSS) capacitor c=4.2741e-17
C34 (\4\:B VSS) capacitor c=7.49785e-17
C35 (\3\:Y VSS) capacitor c=1.01995e-16
C36 (\4\:AN VSS) capacitor c=9.19893e-17
C37 (\6\:net118 VSS) capacitor c=5.01038e-17
C38 (\7\:net118 VSS) capacitor c=4.22495e-17
Rk5 (\3\:Y Y) resistor r=0.661 c=0
Rk4 (\2\:Y \3\:Y) resistor r=0.351 c=0
Rk6 (\3\:Y \5\:Y) resistor r=0.03284 c=0
Rk7 (Y \7\:Y) resistor r=0.1702 c=0
Rk3 (B \4\:B) resistor r=0.1018 c=0
Rk2 (C \4\:C) resistor r=0.003963 c=0
Rk12 (\2\:VDD \3\:VDD) resistor r=0.08249 c=0
Rk13 (\3\:VDD \4\:VDD) resistor r=0.1176 c=0
Rk14 (\4\:VDD \5\:VDD) resistor r=0.1176 c=0
Rk15 (\5\:VDD \6\:VDD) resistor r=0.08249 c=0
Rk17 (\7\:VDD VDD) resistor r=0.04716 c=0
Rk16 (\6\:VDD \7\:VDD) resistor r=0.1025 c=0
Rk19 (\3\:VDD \10\:VDD) resistor r=0.07334 c=0
Rk20 (\5\:VDD \12\:VDD) resistor r=0.07334 c=0
Rk21 (\7\:VDD \14\:VDD) resistor r=0.2658 c=0
Rk1 (D \4\:D) resistor r=0.08679 c=0
Rk22 (\2\:VSS \3\:VSS) resistor r=0.105 c=0
Rk24 (\4\:VSS VSS) resistor r=0.2002 c=0
Rk23 (\3\:VSS \4\:VSS) resistor r=0.2454 c=0
Rk25 (\3\:VSS \6\:VSS) resistor r=0.1821 c=0
Rk8 (AN \4\:AN) resistor r=0.01485 c=0
Rk9 (\5\:net118 \6\:net118) resistor r=0.4822 c=0
Rk10 (\6\:net118 \7\:net118) resistor r=0.2454 c=0
Rk11 (\6\:net118 \9\:net118) resistor r=0.1824 c=0
Rl5 (\1\:B \2\:B) resistor r=226.098 c=0
Rl6 (\2\:B \3\:B) resistor r=26.098 c=0
Rl3 (\1\:C \2\:C) resistor r=166.076 c=0
Rl4 (\2\:C \3\:C) resistor r=92.9995 c=0
Rl2 (\2\:D \3\:D) resistor r=220.212 c=0
Rl1 (\1\:D \2\:D) resistor r=40.3846 c=0
Rl9 (\1\:AN \2\:AN) resistor r=100 c=0
Rl10 (\2\:AN \3\:AN) resistor r=160.989 c=0
Rl7 (net118 \2\:net118) resistor r=216.483 c=0
Rl8 (\2\:net118 \3\:net118) resistor r=35.7134 c=0
Rz1 (\6\:Y \7\:Y) resistor r=75 c=0
Rz6 (\1\:VDD VDD) resistor r=75 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VDD \6\:VDD) resistor r=37.5 c=0
Rz7 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz2 (\8\:net118 \9\:net118) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry2 (\4\:Y \5\:Y) resistor r=62 c=0
Ry4 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry5 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry6 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry7 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry8 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry3 (\4\:net118 \5\:net118) resistor r=62 c=0
Rx3 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:AN \4\:AN) resistor r=45 c=0
Rx5 (\2\:net118 \7\:net118) resistor r=45 c=0
mn4 (\6\:Y \1\:D net122 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=2.03e-14 ps=5.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.85e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn3 (net122 \3\:C net126 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.667e-14 ad=1.595e-14 ps=5.2e-07 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.95e-07 sb=7.3e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn2 (net126 \3\:B net130 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=1.668e-14 ps=6.5e-07 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=5.7e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn1 (net130 \3\:net118 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.61e-14 ps=6.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=3.45e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mn0 (\8\:net118 \3\:AN \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=1.4e-07 sd=160n sca=6.75077 \
        scb=0.00344229 scc=2.58723e-05 m=(1)
mp3 (\4\:Y \1\:C \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.3e-07 sd=160n sca=13.4568 \
        scb=0.0111557 scc=0.000195491 m=(1)
mp2 (\1\:Y \1\:B \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=6.35e-07 sd=160n sca=12.6657 \
        scb=0.00981458 scc=0.000188357 m=(1)
mp1 (\1\:Y net118 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=4.3e-07 sd=160n sca=13.5027 \
        scb=0.0112382 scc=0.000196207 m=(1)
mp0 (\4\:net118 \1\:AN \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=3.548e-14 ps=1.45e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=1.65e-07 sd=160n sca=21.9147 \
        scb=0.024825 scc=0.00104914 m=(1)
ends NAND4BXL
// End of subcircuit definition.

// Generated for: spectre (May  9 16:02:21 2012 )
// Library name: gsclib045
// Cell name: NAND4X1
// View name: extracted

simulator lang=spectre

subckt NAND4X1 A B C D VDD VSS Y
mp0 (\4\:Y \3\:A \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=34.1345 scb=0.02948 \
        scc=0.00325161 m=(1)
C1 (B VSS) capacitor c=5.67767e-17
C2 (D VSS) capacitor c=4.99007e-17
C3 (A VSS) capacitor c=5.15335e-17
C4 (VDD VSS) capacitor c=5.86847e-17
C5 (Y VSS) capacitor c=5.58812e-17
C6 (C VSS) capacitor c=6.53074e-17
C7 (n0 VSS) capacitor c=4.43225e-18
C8 (n1 VSS) capacitor c=5.91565e-18
C9 (n2 VSS) capacitor c=3.68605e-19
C10 (\1\:D VSS) capacitor c=3.58921e-17
C11 (\1\:C VSS) capacitor c=4.65116e-17
C12 (\1\:B VSS) capacitor c=4.81345e-17
C13 (\3\:A VSS) capacitor c=3.50832e-17
C14 (\3\:D VSS) capacitor c=3.72404e-17
C15 (\3\:C VSS) capacitor c=4.42303e-17
C16 (\3\:B VSS) capacitor c=5.4632e-17
C17 (\1\:A VSS) capacitor c=5.22727e-17
C18 (\2\:D VSS) capacitor c=2.8735e-17
C19 (\2\:C VSS) capacitor c=3.43166e-17
C20 (\2\:B VSS) capacitor c=3.75205e-17
C21 (\2\:A VSS) capacitor c=3.35886e-17
C22 (\9\:VDD VSS) capacitor c=3.47418e-17
C23 (\6\:Y VSS) capacitor c=3.30328e-17
C24 (\11\:VDD VSS) capacitor c=4.74682e-17
C25 (\4\:Y VSS) capacitor c=7.15435e-17
C26 (\13\:VDD VSS) capacitor c=4.91439e-17
C27 (\1\:VDD VSS) capacitor c=3.03017e-17
C28 (\1\:Y VSS) capacitor c=4.65289e-17
C29 (\4\:A VSS) capacitor c=3.62666e-17
C30 (\4\:B VSS) capacitor c=7.08105e-17
C31 (\4\:C VSS) capacitor c=7.97035e-17
C32 (\4\:D VSS) capacitor c=7.73516e-17
C33 (\3\:Y VSS) capacitor c=4.70003e-17
C34 (\7\:VDD VSS) capacitor c=4.37835e-20
Rk20 (\3\:VSS VSS) resistor r=0.09734 c=0
Rk21 (\3\:VSS \5\:VSS) resistor r=0.2911 c=0
Rk2 (\4\:B B) resistor r=0.1759 c=0
Rk4 (D \4\:D) resistor r=0.171 c=0
Rk1 (\4\:A A) resistor r=0.03899 c=0
Rk9 (\2\:VDD \3\:VDD) resistor r=0.03491 c=0
Rk10 (\3\:VDD \4\:VDD) resistor r=0.1151 c=0
Rk11 (\4\:VDD \5\:VDD) resistor r=0.09759 c=0
Rk12 (\5\:VDD \6\:VDD) resistor r=0.1026 c=0
Rk14 (\7\:VDD VDD) resistor r=0.04719 c=0
Rk13 (\6\:VDD \7\:VDD) resistor r=0.1026 c=0
Rk16 (\3\:VDD \10\:VDD) resistor r=0.2985 c=0
Rk17 (\5\:VDD \12\:VDD) resistor r=0.304 c=0
Rk18 (\7\:VDD \14\:VDD) resistor r=0.3578 c=0
Rk5 (\2\:Y Y) resistor r=0.1859 c=0
Rk6 (Y \3\:Y) resistor r=0.2953 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.38 c=0
Rk8 (\3\:Y \7\:Y) resistor r=0.05786 c=0
Rk3 (C \4\:C) resistor r=0.291 c=0
Rl3 (\1\:B \2\:B) resistor r=41.0764 c=0
Rl4 (\2\:B \3\:B) resistor r=29.5379 c=0
Rl7 (\1\:D \2\:D) resistor r=46.1538 c=0
Rl8 (\2\:D \3\:D) resistor r=26.3736 c=0
Rl2 (\2\:A \3\:A) resistor r=33.8482 c=0
Rl1 (\1\:A \2\:A) resistor r=64.9387 c=0
Rl5 (\1\:C \2\:C) resistor r=41.0764 c=0
Rl6 (\2\:C \3\:C) resistor r=29.5379 c=0
Rz6 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz5 (\1\:VDD VDD) resistor r=75 c=0
Rz2 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz3 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \6\:VDD) resistor r=37.5 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Ry3 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry4 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry5 (\13\:VDD \14\:VDD) resistor r=31 c=0
Ry1 (\4\:Y \5\:Y) resistor r=31 c=0
Ry2 (\6\:Y \7\:Y) resistor r=31 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
mn0 (n0 \1\:A \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.1e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn1 (n1 \3\:B n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.42e-14 ps=6.4e-07 pd=8.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.05e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn2 (n2 \3\:C n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.42e-14 \
        ad=2.34e-14 ps=8.6e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 sa=4.6e-07 \
        sb=3.9e-07 sd=160n sca=17.5885 scb=0.0172826 scc=0.00162584 m=(1)
mn3 (\1\:Y \3\:D n2 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.63e-14 ps=7e-07 pd=1.03e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.95e-07 sb=2.55e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mp1 (\4\:Y \1\:B \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=6.24e-14 ps=1.12e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.65e-07 sd=160n sca=30.1089 \
        scb=0.0217941 scc=0.00297188 m=(1)
mp2 (\6\:Y \1\:C \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=6.435e-14 ps=1.12e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=3.5e-07 sd=160n sca=30.2583 \
        scb=0.0220944 scc=0.00297511 m=(1)
mp3 (\6\:Y \1\:D \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.435e-14 ps=1.06e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=1.4e-07 sd=160n sca=35.3118 \
        scb=0.0314154 scc=0.00340463 m=(1)
ends NAND4X1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:03:04 2012 )
// Library name: gsclib045
// Cell name: NAND4X2
// View name: extracted

simulator lang=spectre

subckt NAND4X2 A B C D VDD VSS Y
mp0 (\1\:Y A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=7.688e-14 \
        ad=7.312e-14 ps=1.33e-06 pd=1.155e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.55e-07 sb=1.84e-06 sd=160n sca=23.2428 scb=0.0263908 \
        scc=0.00131858 m=(2)
C1 (Y VSS) capacitor c=1.37529e-16
C2 (C VSS) capacitor c=9.584e-17
C3 (D VSS) capacitor c=2.60621e-17
C4 (A VSS) capacitor c=6.21396e-16
C5 (VDD VSS) capacitor c=3.60034e-16
C6 (10 VSS) capacitor c=7.24277e-18
C7 (11 VSS) capacitor c=3.04429e-18
C8 (12 VSS) capacitor c=7.40397e-18
C9 (13 VSS) capacitor c=7.39589e-18
C10 (\1\:C VSS) capacitor c=3.09061e-16
C11 (\1\:B VSS) capacitor c=5.02138e-16
C12 (\6\:A VSS) capacitor c=3.75457e-17
C13 (\6\:B VSS) capacitor c=5.07242e-17
C14 (\6\:C VSS) capacitor c=4.3207e-17
C15 (\1\:D VSS) capacitor c=4.84101e-17
C16 (\5\:D VSS) capacitor c=1.76904e-17
C17 (\3\:C VSS) capacitor c=4.02736e-17
C18 (\3\:B VSS) capacitor c=5.97794e-17
C19 (\1\:A VSS) capacitor c=5.26258e-17
C20 (\2\:D VSS) capacitor c=2.65979e-17
C21 (\1\:Y VSS) capacitor c=3.48358e-16
C22 (\10\:VDD VSS) capacitor c=2.79389e-17
C23 (\9\:Y VSS) capacitor c=1.29757e-16
C24 (\3\:D VSS) capacitor c=1.15777e-16
C25 (\7\:D VSS) capacitor c=6.9874e-17
Rk8 (Y \1\:Y) resistor r=0.2772 c=0
Rk12 (Y \10\:Y) resistor r=1.1724 c=0
Rk2 (C \1\:C) resistor r=0.04063 c=0
Rk1 (\7\:D D) resistor r=0.1538 c=0
Rk18 (VDD \11\:VDD) resistor r=0.1021 c=0
Rk26 (\3\:VSS VSS) resistor r=0.0572 c=0
Rk25 (\2\:VSS \3\:VSS) resistor r=0.203 c=0
Rk28 (\3\:VSS \6\:VSS) resistor r=0.4935 c=0
Rk29 (\6\:VSS \8\:VSS) resistor r=0.5746 c=0
Rk5 (\1\:B B) resistor r=0.005628 c=0
Rl13 (\1\:C \6\:C) resistor r=44.9225 c=0
Rl6 (\1\:C \3\:C) resistor r=102.615 c=0
Rl7 (\2\:D \1\:D) resistor r=105.323 c=0
Rl10 (\2\:D \5\:D) resistor r=31.9251 c=0
Rl8 (\3\:D \2\:D) resistor r=79.6836 c=0
Rl17 (A \6\:A) resistor r=120.33 c=0
Rl1 (A \1\:A) resistor r=115.18 c=0
Rl15 (\1\:B \6\:B) resistor r=129.538 c=0
Rl4 (\1\:B \3\:B) resistor r=114.153 c=0
Rz1 (\10\:Y \9\:Y) resistor r=75 c=0
Rz6 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz7 (\7\:VSS \8\:VSS) resistor r=75 c=0
Ry7 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry10 (\4\:VSS VSS) resistor r=62 c=0
Ry11 (\4\:VSS \6\:VSS) resistor r=6.2 c=0
Rx1 (\7\:D \2\:D) resistor r=45 c=0
mn0 (8 \1\:A \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.34e-14 ps=8e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.685e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn1 (9 \3\:B 8 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=5.72e-14 ps=7e-07 pd=9.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.75e-07 sb=1.55e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn2 (9 \3\:C 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=6.89e-14 \
        ad=5.72e-14 ps=1.05e-06 pd=9.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.4e-07 sb=1.285e-06 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn3 (\9\:Y \5\:D 10 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=6.89e-14 \
        ad=4.16e-14 ps=1.05e-06 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.5e-07 sb=9.75e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn3_1__rcx (\9\:Y \1\:D 11 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.16e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.055e-06 sb=7.7e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn2_1__rcx (11 \6\:C 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.72e-14 ad=2.99e-14 ps=9.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.215e-06 sb=6.1e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn1_1__rcx (13 \6\:B 12 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.72e-14 ad=4.16e-14 ps=9.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48e-06 sb=3.45e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0_1__rcx (13 \6\:A \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.685e-06 sb=1.4e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mp1 (\1\:Y \1\:B VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.128e-13 ad=7.312e-14 ps=1.67e-06 pd=1.155e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.635e-06 sd=160n sca=16.4248 \
        scb=0.0152088 scc=0.000666128 m=(2)
mp2 (\1\:Y \1\:C VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.128e-13 ad=6.24e-14 ps=1.67e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=1.37e-06 sd=160n sca=14.2658 \
        scb=0.0124744 scc=0.000647653 m=(2)
mp3 (\1\:Y \3\:D \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.128e-13 ad=6.24e-14 ps=1.67e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.165e-06 sd=160n sca=13.6466 \
        scb=0.0121992 scc=0.000647514 m=(2)
ends NAND4X2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:03:42 2012 )
// Library name: gsclib045
// Cell name: NAND4X4
// View name: extracted

simulator lang=spectre

subckt NAND4X4 A B C D VDD VSS Y
mp0 (\6\:Y A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.484e-14 \
        ad=6.24e-14 ps=1.1125e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=29.9299 scb=0.0335958 \
        scc=0.00259498 m=(4)
C1 (B VSS) capacitor c=9.24342e-17
C2 (D VSS) capacitor c=3.47469e-16
C3 (A VSS) capacitor c=3.4675e-16
C4 (VDD VSS) capacitor c=6.45473e-16
C5 (Y VSS) capacitor c=3.98373e-16
C6 (C VSS) capacitor c=5.11482e-16
C7 (n0 VSS) capacitor c=3.50945e-16
C8 (n1 VSS) capacitor c=2.48744e-16
C9 (n2 VSS) capacitor c=4.18195e-16
C10 (\1\:B VSS) capacitor c=3.08591e-16
C11 (\1\:Y VSS) capacitor c=3.58886e-16
C12 (\5\:n1 VSS) capacitor c=1.99479e-16
C13 (\6\:Y VSS) capacitor c=1.57827e-16
C14 (\16\:Y VSS) capacitor c=1.85547e-16
C15 (\22\:Y VSS) capacitor c=1.8774e-16
Rk64 (\2\:VSS \3\:VSS) resistor r=1.0035 c=0
Rk67 (\4\:VSS VSS) resistor r=0.1175 c=0
Rk65 (\3\:VSS \4\:VSS) resistor r=0.2281 c=0
Rk3 (B \1\:B) resistor r=0.006313 c=0
Rk20 (\1\:Y Y) resistor r=1.9594 c=0
Rk21 (Y \6\:Y) resistor r=0.3131 c=0
Rk28 (Y \16\:Y) resistor r=0.3303 c=0
Rk32 (\16\:Y \22\:Y) resistor r=0.445 c=0
Rk10 (n1 \5\:n1) resistor r=0.5145 c=0
Ry18 (\2\:VSS \1\:VSS) resistor r=7.75 c=0
Ry19 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
mn0 (n0 A \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=4.03e-14 ps=8.4e-07 pd=8.3e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.575e-06 sd=160n sca=8.22858 scb=0.00610564 \
        scc=0.00012768 m=(4)
mn1 (\5\:n1 \1\:B n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.03e-14 \
        ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.6e-07 sb=7.55e-07 sd=160n sca=8.22858 scb=0.00610564 \
        scc=0.00012768 m=(4)
mn2 (n2 C n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=6.565e-14 ps=8.4e-07 pd=1.025e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.79e-06 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(4)
mn3 (\1\:Y D n2 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.29e-14 \
        ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.155e-06 sb=7.75e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(4)
mp1 (Y \1\:B VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.825e-14 \
        ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=9.95e-07 sb=2e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(4)
mp2 (\16\:Y C VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=8.19e-14 \
        ad=6.24e-14 ps=1.2e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.85e-06 sb=1.8e-06 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(4)
mp3 (\22\:Y D VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=8.239e-14 \
        ad=6.24e-14 ps=1.2025e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=8.15e-07 sd=160n sca=16.2669 scb=0.0145797 \
        scc=0.00118861 m=(4)
ends NAND4X4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:04:20 2012 )
// Library name: gsclib045
// Cell name: NAND4X6
// View name: extracted

simulator lang=spectre

subckt NAND4X6 A B C D VDD VSS Y
mp0 (\16\:Y \1\:A \26\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.332e-14 ad=8.836e-14 ps=1.252e-06 pd=1.316e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=31.7755 scb=0.0243055 \
        scc=0.00289785 m=(5)
C1 (B VSS) capacitor c=1.90505e-17
C2 (D VSS) capacitor c=2.14303e-17
C3 (A VSS) capacitor c=3.21282e-17
C4 (VDD VSS) capacitor c=1.23398e-16
C5 (Y VSS) capacitor c=2.98397e-17
C6 (C VSS) capacitor c=2.5439e-17
C7 (n0 VSS) capacitor c=3.95811e-16
C8 (n1 VSS) capacitor c=3.54657e-16
C9 (n2 VSS) capacitor c=3.30836e-16
C10 (\1\:D VSS) capacitor c=3.22878e-16
C11 (\1\:B VSS) capacitor c=3.20469e-16
C12 (\1\:A VSS) capacitor c=2.95386e-16
C13 (\1\:C VSS) capacitor c=3.30005e-16
C14 (\1\:VDD VSS) capacitor c=1.60818e-16
C15 (\4\:VDD VSS) capacitor c=3.98922e-17
C16 (\1\:Y VSS) capacitor c=1.83119e-16
C17 (\5\:Y VSS) capacitor c=4.20502e-16
C18 (\16\:Y VSS) capacitor c=4.52617e-16
C19 (\7\:VDD VSS) capacitor c=2.72782e-16
C20 (\26\:VDD VSS) capacitor c=1.71968e-16
Rk65 (\2\:VSS \3\:VSS) resistor r=0.6515 c=0
Rk66 (\3\:VSS \4\:VSS) resistor r=1.2028 c=0
Rk70 (\5\:VSS VSS) resistor r=0.07723 c=0
Rk67 (\4\:VSS \5\:VSS) resistor r=0.06245 c=0
Rk4 (\1\:B B) resistor r=0.03625 c=0
Rk18 (\1\:D D) resistor r=0.02337 c=0
Rk1 (A \1\:A) resistor r=0.03292 c=0
Rk45 (\1\:VDD \7\:VDD) resistor r=0.2276 c=0
Rk64 (\26\:VDD VDD) resistor r=0.07723 c=0
Rk57 (\7\:VDD \26\:VDD) resistor r=0.2752 c=0
Rk25 (\1\:Y Y) resistor r=0.1993 c=0
Rk26 (Y \5\:Y) resistor r=0.117 c=0
Rk33 (\5\:Y \16\:Y) resistor r=0.3276 c=0
Rk12 (\1\:C C) resistor r=0.01297 c=0
Rz19 (\1\:VDD \4\:VDD) resistor r=9.375 c=0
Rz20 (\7\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz21 (\26\:VDD \4\:VDD) resistor r=9.375 c=0
Ry23 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry24 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry25 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
mn0 (n0 \1\:A \5\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.836e-14 ad=5.828e-14 ps=9.32e-07 pd=9.96e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
mn1 (n1 \1\:B n0 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=5.828e-14 \
        ad=5.425e-14 ps=9.96e-07 pd=9.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.305e-06 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
mn2 (n2 \1\:C n1 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=6.107e-14 \
        ad=5.301e-14 ps=1.014e-06 pd=9.62e-07 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=2e-06 sd=160n sca=15.9751 scb=0.0153507 scc=0.00137372 \
        m=(5)
mn3 (\1\:Y \1\:D n2 VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=5.549e-14 \
        ad=4.96e-14 ps=9.78e-07 pd=9.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=9.95e-07 sd=160n sca=15.9751 scb=0.0153507 \
        scc=0.00137372 m=(5)
mp1 (\16\:Y \1\:B \7\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.52e-14 ad=1.0246e-13 ps=1.26e-06 pd=1.376e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.305e-06 sb=2e-06 sd=160n sca=26.9787 \
        scb=0.0178954 scc=0.0027966 m=(5)
mp2 (\5\:Y \1\:C \7\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=8.648e-14 ad=7.943e-14 ps=1.308e-06 pd=1.278e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=26.9787 scb=0.0178954 \
        scc=0.0027966 m=(5)
mp3 (\5\:Y \1\:D \1\:VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.332e-14 ad=8.601e-14 ps=1.252e-06 pd=1.306e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.95e-07 sd=160n sca=26.9787 scb=0.0178954 \
        scc=0.0027966 m=(5)
ends NAND4X6
// End of subcircuit definition.

// Generated for: spectre (May  9 16:04:58 2012 )
// Library name: gsclib045
// Cell name: NAND4X8
// View name: extracted

simulator lang=spectre

subckt NAND4X8 A B C D VDD VSS Y
mp0 (\16\:Y A VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 as=6.993e-14 \
        ad=7.12e-14 ps=1.20429e-06 pd=1.21e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=30.632 scb=0.0328204 \
        scc=0.00272371 m=(7)
C1 (B VSS) capacitor c=4.70838e-16
C2 (D VSS) capacitor c=4.54171e-16
C3 (A VSS) capacitor c=4.25428e-16
C4 (VDD VSS) capacitor c=4.10382e-16
C5 (Y VSS) capacitor c=1.49852e-17
C6 (C VSS) capacitor c=2.10901e-17
C7 (n0 VSS) capacitor c=4.46459e-16
C8 (n1 VSS) capacitor c=4.99291e-16
C9 (n2 VSS) capacitor c=4.305e-16
C10 (\1\:C VSS) capacitor c=4.46691e-16
C11 (\1\:VDD VSS) capacitor c=1.85928e-16
C12 (\3\:VDD VSS) capacitor c=4.64043e-16
C13 (\1\:Y VSS) capacitor c=2.20221e-16
C14 (\9\:Y VSS) capacitor c=6.06619e-16
C15 (\16\:Y VSS) capacitor c=6.08903e-16
Rk98 (\3\:VSS VSS) resistor r=1.1301 c=0
Rk97 (\2\:VSS \3\:VSS) resistor r=0.9022 c=0
Rk88 (\3\:VDD VDD) resistor r=0.1991 c=0
Rk34 (\1\:Y Y) resistor r=0.04342 c=0
Rk35 (Y \9\:Y) resistor r=0.227 c=0
Rk42 (\9\:Y \16\:Y) resistor r=0.3333 c=0
Rk15 (\1\:C C) resistor r=0.04316 c=0
Rz27 (\1\:VDD \3\:VDD) resistor r=0.1114 c=0
Ry32 (VSS \1\:VSS) resistor r=5.1667 c=0
Ry30 (\2\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry31 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
mn0 (n0 A VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 as=4.636e-14 \
        ad=4.72e-14 ps=9.0429e-07 pd=9.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(7)
mn1 (n1 B n0 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 as=4.72e-14 \
        ad=4.72e-14 ps=9.1e-07 pd=9.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.575e-06 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(7)
mn2 (n2 \1\:C n1 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 as=4.72e-14 \
        ad=4.72e-14 ps=9.1e-07 pd=9.1e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 scc=0.0014413 m=(7)
mn3 (\1\:Y D n2 VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 as=4.72e-14 \
        ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=1.37e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(7)
mp1 (\16\:Y B \3\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=7.12e-14 ps=1.21e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=2e-06 sd=160n sca=18.517 scb=0.0155152 \
        scc=0.00162155 m=(7)
mp2 (\9\:Y \1\:C \3\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=7.12e-14 ps=1.21e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=18.517 scb=0.0155152 \
        scc=0.00162155 m=(7)
mp3 (\9\:Y D \1\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=7.12e-14 ps=1.20429e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.37e-06 sd=160n sca=18.517 scb=0.0155152 \
        scc=0.00162155 m=(7)
ends NAND4X8
// End of subcircuit definition.

// Generated for: spectre (May  9 16:05:37 2012 )
// Library name: gsclib045
// Cell name: NAND4XL
// View name: extracted

simulator lang=spectre

subckt NAND4XL A B C D VDD VSS Y
mp0 (\5\:Y \3\:A \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.44e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.05e-07 sd=160n sca=65.5272 scb=0.0524355 \
        scc=0.00853103 m=(1)
C1 (Y VSS) capacitor c=4.46866e-17
C2 (B VSS) capacitor c=3.5537e-17
C3 (D VSS) capacitor c=3.72611e-17
C4 (A VSS) capacitor c=3.96106e-17
C5 (VDD VSS) capacitor c=5.59454e-17
C6 (C VSS) capacitor c=2.32126e-17
C7 (n1 VSS) capacitor c=2.55518e-18
C8 (\1\:D VSS) capacitor c=2.58426e-17
C9 (\1\:C VSS) capacitor c=4.28721e-17
C10 (\1\:B VSS) capacitor c=4.19053e-17
C11 (\3\:A VSS) capacitor c=2.82225e-17
C12 (\3\:D VSS) capacitor c=3.66818e-17
C13 (\3\:C VSS) capacitor c=3.60789e-17
C14 (\3\:B VSS) capacitor c=3.34387e-17
C15 (\1\:A VSS) capacitor c=2.94315e-17
C16 (\2\:D VSS) capacitor c=2.95299e-17
C17 (\2\:C VSS) capacitor c=3.53458e-17
C18 (\2\:B VSS) capacitor c=3.54132e-17
C19 (\2\:A VSS) capacitor c=2.56462e-17
C20 (\9\:VDD VSS) capacitor c=9.89945e-18
C21 (\3\:Y VSS) capacitor c=4.87602e-17
C22 (\11\:VDD VSS) capacitor c=1.56647e-17
C23 (\5\:Y VSS) capacitor c=3.2275e-17
C24 (\7\:VDD VSS) capacitor c=4.01324e-18
C25 (\1\:VDD VSS) capacitor c=1.94038e-17
C26 (\1\:Y VSS) capacitor c=6.16615e-17
C27 (\4\:A VSS) capacitor c=4.36262e-17
C28 (\4\:B VSS) capacitor c=5.53032e-17
C29 (\4\:C VSS) capacitor c=5.44344e-17
C30 (\5\:D VSS) capacitor c=5.98221e-17
C31 (\5\:VDD VSS) capacitor c=1.97296e-18
Rk7 (\2\:Y Y) resistor r=0.2741 c=0
Rk8 (Y \4\:Y) resistor r=0.1629 c=0
Rk9 (\4\:Y \6\:Y) resistor r=0.2769 c=0
Rk2 (B \4\:B) resistor r=0.1283 c=0
Rk4 (\4\:D \5\:D) resistor r=0.001151 c=0
Rk5 (\6\:D D) resistor r=0.001266 c=0
Rk6 (\5\:D \6\:D) resistor r=0.04773 c=0
Rk1 (A \4\:A) resistor r=0.2237 c=0
Rk10 (\2\:VDD \3\:VDD) resistor r=0.03475 c=0
Rk11 (\3\:VDD \4\:VDD) resistor r=0.1146 c=0
Rk12 (\4\:VDD \5\:VDD) resistor r=0.08467 c=0
Rk14 (\6\:VDD VDD) resistor r=0.04997 c=0
Rk13 (\5\:VDD \6\:VDD) resistor r=0.1146 c=0
Rk15 (VDD \8\:VDD) resistor r=0.2299 c=0
Rk16 (\3\:VDD \10\:VDD) resistor r=0.221 c=0
Rk17 (\5\:VDD \12\:VDD) resistor r=0.221 c=0
Rk18 (\2\:VSS VSS) resistor r=0.2498 c=0
Rk20 (VSS \5\:VSS) resistor r=0.1008 c=0
Rk3 (C \4\:C) resistor r=0.03282 c=0
Rl3 (\1\:B \2\:B) resistor r=38.4615 c=0
Rl4 (\2\:B \3\:B) resistor r=29.9451 c=0
Rl7 (\1\:D \2\:D) resistor r=28.8462 c=0
Rl8 (\2\:D \3\:D) resistor r=39.8352 c=0
Rl2 (\2\:A \3\:A) resistor r=33.7903 c=0
Rl1 (\1\:A \2\:A) resistor r=26.098 c=0
Rl5 (\1\:C \2\:C) resistor r=37.2302 c=0
Rl6 (\2\:C \3\:C) resistor r=29.5379 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz3 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \6\:VDD) resistor r=37.5 c=0
Rz5 (\4\:VSS \5\:VSS) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry2 (\5\:Y \6\:Y) resistor r=62 c=0
Ry3 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry4 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry5 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry7 (\1\:VSS VSS) resistor r=62 c=0
Ry6 (\1\:VSS \2\:VSS) resistor r=15.5 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
mn0 (n0 \1\:A \4\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=1.305e-14 ps=1.5e-06 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.35e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn1 (n1 \3\:B n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=1.305e-14 \
        ad=2.973e-14 ps=4.7e-07 pd=7e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.35e-07 sb=6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn2 (n2 \3\:C n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.973e-14 \
        ad=1.233e-14 ps=7e-07 pd=4.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.85e-07 sb=3.5e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn3 (\1\:Y \3\:D n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.233e-14 ad=3.19e-14 ps=4.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=2.2e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp1 (\5\:Y \1\:B \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=5e-07 sd=160n sca=51.4512 scb=0.0349149 \
        scc=0.00596975 m=(1)
mp2 (\3\:Y \1\:C \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=3.05e-07 sd=160n sca=50.5093 scb=0.0329496 \
        scc=0.00591106 m=(1)
mp3 (\3\:Y \1\:D \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.44e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=1e-07 sd=160n sca=57.096 scb=0.0442069 \
        scc=0.00674539 m=(1)
ends NAND4XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:15:47 2012 )
// Library name: gsclib045
// Cell name: NOR2BX1
// View name: extracted

simulator lang=spectre

subckt NOR2BX1 AN B VDD VSS Y
mp2 (\3\:Y \1\:B net59 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.74551e-07 sd=160n sca=22.6423 \
        scb=0.024839 scc=0.000882584 m=(1)
C1 (Y VSS) capacitor c=6.22187e-17
C2 (B VSS) capacitor c=3.7587e-17
C3 (VDD VSS) capacitor c=9.78699e-17
C4 (net76 VSS) capacitor c=5.53967e-17
C5 (\1\:AN VSS) capacitor c=3.73396e-17
C6 (\3\:net76 VSS) capacitor c=7.73674e-17
C7 (\1\:B VSS) capacitor c=7.64588e-17
C8 (\3\:AN VSS) capacitor c=3.95621e-17
C9 (\3\:B VSS) capacitor c=2.86245e-17
C10 (\2\:AN VSS) capacitor c=3.79163e-17
C11 (\2\:net76 VSS) capacitor c=5.0375e-17
C12 (\2\:B VSS) capacitor c=4.59562e-17
C13 (\4\:net76 VSS) capacitor c=4.21052e-17
C14 (\1\:VDD VSS) capacitor c=3.68118e-17
C15 (\3\:Y VSS) capacitor c=5.03603e-17
C16 (\8\:net76 VSS) capacitor c=6.2457e-17
C17 (\1\:Y VSS) capacitor c=9.13509e-17
C18 (\4\:B VSS) capacitor c=8.24576e-17
C19 (\6\:net76 VSS) capacitor c=9.46014e-17
C20 (\7\:net76 VSS) capacitor c=2.0248e-17
C21 (\4\:AN VSS) capacitor c=5.35764e-17
C22 (\6\:AN VSS) capacitor c=4.35814e-17
C23 (\4\:VDD VSS) capacitor c=2.05496e-17
Rk1 (\2\:Y Y) resistor r=0.6199 c=0
Rk2 (Y \4\:Y) resistor r=0.1582 c=0
Rk7 (\4\:AN \5\:AN) resistor r=0.005473 c=0
Rk8 (AN \6\:AN) resistor r=0.005473 c=0
Rk9 (\4\:AN \6\:AN) resistor r=0.02665 c=0
Rk3 (B \4\:B) resistor r=0.07664 c=0
Rk15 (\4\:VDD VDD) resistor r=0.1503 c=0
Rk14 (\2\:VDD \4\:VDD) resistor r=0.2673 c=0
Rk11 (\4\:VSS VSS) resistor r=0.2014 c=0
Rk10 (\2\:VSS \4\:VSS) resistor r=0.399 c=0
Rk13 (VSS \7\:VSS) resistor r=0.1029 c=0
Rk4 (\5\:net76 \6\:net76) resistor r=0.2842 c=0
Rk5 (\6\:net76 \7\:net76) resistor r=0.04832 c=0
Rk6 (\6\:net76 \9\:net76) resistor r=0.4595 c=0
Rl5 (\1\:AN \2\:AN) resistor r=53.0211 c=0
Rl6 (\2\:AN \3\:AN) resistor r=87.6365 c=0
Rl1 (\1\:B \2\:B) resistor r=92.3077 c=0
Rl2 (\2\:B \3\:B) resistor r=56.8681 c=0
Rl3 (net76 \2\:net76) resistor r=115.365 c=0
Rl4 (\2\:net76 \3\:net76) resistor r=29.5379 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (\8\:net76 \9\:net76) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry4 (\3\:VSS VSS) resistor r=62 c=0
Ry3 (\3\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry2 (\4\:net76 \5\:net76) resistor r=62 c=0
Rx3 (\2\:AN \5\:AN) resistor r=45 c=0
Rx1 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:net76 \7\:net76) resistor r=45 c=0
mn2 (\1\:Y \3\:B \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.85e-14 ad=4.16e-14 ps=1.41e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=4.41635e-07 sd=160n sca=13.198 \
        scb=0.0131159 scc=0.000803647 m=(1)
mn1 (\1\:Y net76 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=2.36635e-07 sd=160n sca=13.198 \
        scb=0.0131159 scc=0.000803647 m=(1)
mn0 (\8\:net76 \3\:AN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.4e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mp1 (net59 \3\:net76 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.34e-14 ps=1.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.69551e-07 sd=160n sca=19.5802 \
        scb=0.0197242 scc=0.000428585 m=(1)
mp0 (\4\:net76 \1\:AN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.4e-07 sd=160n sca=28.1856 \
        scb=0.0322489 scc=0.00190885 m=(1)
ends NOR2BX1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:06:52 2012 )
// Library name: gsclib045
// Cell name: NOR2BX2
// View name: extracted

simulator lang=spectre

subckt NOR2BX2 AN B VDD VSS Y
mp1 (2 net76 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.14872e-07 sd=160n sca=18.7282 \
        scb=0.0166129 scc=0.00128578 m=(1)
C1 (Y VSS) capacitor c=7.57832e-17
C2 (AN VSS) capacitor c=7.64736e-17
C3 (VDD VSS) capacitor c=8.33003e-17
C4 (B VSS) capacitor c=6.16332e-17
C5 (net76 VSS) capacitor c=8.23528e-17
C6 (4 VSS) capacitor c=5.48783e-18
C7 (\1\:AN VSS) capacitor c=3.00283e-17
C8 (\6\:net76 VSS) capacitor c=6.96153e-17
C9 (\6\:B VSS) capacitor c=3.24685e-17
C10 (\4\:B VSS) capacitor c=7.96792e-17
C11 (\3\:AN VSS) capacitor c=4.23603e-17
C12 (\1\:B VSS) capacitor c=8.45133e-17
C13 (\2\:AN VSS) capacitor c=3.53933e-17
C14 (\3\:B VSS) capacitor c=3.65243e-17
C15 (\2\:net76 VSS) capacitor c=3.04443e-16
C16 (\7\:net76 VSS) capacitor c=3.79662e-17
C17 (\1\:VDD VSS) capacitor c=4.13274e-17
C18 (\1\:Y VSS) capacitor c=1.24186e-16
C19 (\7\:VDD VSS) capacitor c=3.98357e-17
C20 (\3\:VDD VSS) capacitor c=2.83918e-17
C21 (\12\:net76 VSS) capacitor c=1.82239e-17
C22 (\3\:Y VSS) capacitor c=1.67729e-16
C23 (\7\:B VSS) capacitor c=5.77755e-17
C24 (\4\:AN VSS) capacitor c=4.32221e-17
C25 (\9\:net76 VSS) capacitor c=3.51351e-17
C26 (\5\:VDD VSS) capacitor c=9.82332e-18
Rk14 (\3\:VSS VSS) resistor r=0.09957 c=0
Rk10 (\2\:VSS \3\:VSS) resistor r=0.1023 c=0
Rk16 (\3\:VSS \10\:VSS) resistor r=0.2072 c=0
Rk3 (Y \3\:Y) resistor r=0.5321 c=0
Rk2 (\2\:Y Y) resistor r=0.6537 c=0
Rk5 (\4\:AN AN) resistor r=0.175 c=0
Rk18 (\2\:VDD \4\:VDD) resistor r=0.3226 c=0
Rk19 (\4\:VDD \5\:VDD) resistor r=0.2898 c=0
Rk21 (\6\:VDD VDD) resistor r=0.04976 c=0
Rk20 (\5\:VDD \6\:VDD) resistor r=0.1098 c=0
Rk22 (\5\:VDD \8\:VDD) resistor r=0.2514 c=0
Rk23 (\8\:VDD \9\:VDD) resistor r=0.1454 c=0
Rk1 (B \7\:B) resistor r=0.224 c=0
Rk7 (\9\:net76 \2\:net76) resistor r=0.236 c=0
Rk6 (\8\:net76 \9\:net76) resistor r=0.2654 c=0
Rk9 (\9\:net76 \13\:net76) resistor r=0.1308 c=0
Rl10 (\1\:AN \2\:AN) resistor r=28.079 c=0
Rl11 (\2\:AN \3\:AN) resistor r=105.002 c=0
Rl7 (\3\:B \6\:B) resistor r=25.7292 c=0
Rl5 (\3\:B \4\:B) resistor r=115.362 c=0
Rl4 (\1\:B \3\:B) resistor r=51.2569 c=0
Rl1 (\2\:net76 net76) resistor r=103.846 c=0
Rl9 (\2\:net76 \6\:net76) resistor r=103.022 c=0
Rz5 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz7 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz8 (\3\:VDD \6\:VDD) resistor r=37.5 c=0
Rz3 (\13\:net76 \12\:net76) resistor r=75 c=0
Ry3 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry4 (\3\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry1 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry6 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry7 (\7\:VDD \9\:VDD) resistor r=62 c=0
Ry2 (\8\:net76 \7\:net76) resistor r=62 c=0
Rx2 (\2\:AN \4\:AN) resistor r=45 c=0
Rx1 (\7\:B \3\:B) resistor r=45 c=0
mn1 (\3\:Y \2\:net76 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.75e-14 ad=4.55e-14 ps=8.35e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=8.98365e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(2)
mn2 (\3\:Y \1\:B \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.55e-14 ps=8.4e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=6.78365e-07 sd=160n sca=9.69565 \
        scb=0.00844644 scc=0.000275168 m=(2)
mn0 (\12\:net76 \3\:AN \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.465e-14 ps=8.4e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=1.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp2 (\1\:Y \4\:B 2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=7.41e-14 ps=9e-07 pd=1.16e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=7.09872e-07 sd=160n sca=17.8946 scb=0.015598 \
        scc=0.00128132 m=(1)
mp2_1__rcx (\1\:Y \6\:B 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=7.41e-14 ps=1.04e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=4.74872e-07 sd=160n sca=17.569 \
        scb=0.0152136 scc=0.00128067 m=(1)
mp1_1__rcx (4 \6\:net76 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=5.07e-14 ps=1.21e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=2.99872e-07 sd=160n sca=18.3606 \
        scb=0.0161225 scc=0.00128307 m=(1)
mp0 (\7\:net76 \1\:AN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=3.655e-14 ps=1.21e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=1.7e-07 sd=160n sca=28.664 \
        scb=0.0305236 scc=0.00251465 m=(1)
ends NOR2BX2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:07:29 2012 )
// Library name: gsclib045
// Cell name: NOR2BX4
// View name: extracted

simulator lang=spectre

subckt NOR2BX4 AN B VDD VSS Y
mp1_1__rcx (3 net76 \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.485e-14 ps=1.06e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.52058e-06 sd=160n sca=23.4161 \
        scb=0.0245802 scc=0.00154433 m=(1)
C1 (AN VSS) capacitor c=4.0357e-17
C2 (Y VSS) capacitor c=7.19159e-18
C3 (B VSS) capacitor c=4.31058e-16
C4 (VDD VSS) capacitor c=1.05134e-16
C5 (net76 VSS) capacitor c=5.44164e-17
C6 (3 VSS) capacitor c=4.48317e-18
C7 (5 VSS) capacitor c=1.94645e-18
C8 (6 VSS) capacitor c=1.92372e-18
C9 (7 VSS) capacitor c=3.77711e-18
C10 (\3\:AN VSS) capacitor c=3.14321e-17
C11 (\12\:net76 VSS) capacitor c=6.33622e-17
C12 (\12\:B VSS) capacitor c=2.70266e-17
C13 (\10\:B VSS) capacitor c=6.15819e-17
C14 (\9\:net76 VSS) capacitor c=7.4206e-17
C15 (\8\:net76 VSS) capacitor c=6.74881e-17
C16 (\1\:B VSS) capacitor c=5.89907e-17
C17 (\5\:B VSS) capacitor c=4.84217e-17
C18 (\1\:AN VSS) capacitor c=5.12601e-17
C19 (\2\:AN VSS) capacitor c=3.48096e-17
C20 (\2\:net76 VSS) capacitor c=5.42821e-16
C21 (\13\:net76 VSS) capacitor c=3.69222e-17
C22 (\1\:VDD VSS) capacitor c=3.52145e-17
C23 (\13\:Y VSS) capacitor c=8.55989e-17
C24 (\8\:VDD VSS) capacitor c=3.81357e-17
C25 (\11\:Y VSS) capacitor c=2.89466e-17
C26 (\10\:VDD VSS) capacitor c=2.51447e-17
C27 (\3\:VDD VSS) capacitor c=2.41103e-17
C28 (\16\:net76 VSS) capacitor c=2.66855e-17
C29 (\1\:Y VSS) capacitor c=3.25057e-16
C30 (\7\:net76 VSS) capacitor c=3.89679e-17
C31 (\9\:Y VSS) capacitor c=6.44055e-17
C32 (\10\:Y VSS) capacitor c=9.43672e-17
C33 (\4\:AN VSS) capacitor c=6.18842e-17
C34 (\15\:net76 VSS) capacitor c=3.57085e-17
C35 (\5\:VDD VSS) capacitor c=1.73797e-17
C36 (\6\:VDD VSS) capacitor c=1.22134e-17
Rk11 (\4\:AN AN) resistor r=0.2087 c=0
Rk7 (\9\:Y Y) resistor r=0.003666 c=0
Rk6 (\1\:Y \9\:Y) resistor r=0.4045 c=0
Rk8 (\9\:Y \10\:Y) resistor r=0.4753 c=0
Rk9 (\10\:Y \12\:Y) resistor r=0.08564 c=0
Rk10 (\10\:Y \14\:Y) resistor r=0.5644 c=0
Rk26 (\2\:VDD \4\:VDD) resistor r=0.4769 c=0
Rk27 (\4\:VDD \5\:VDD) resistor r=0.1627 c=0
Rk29 (\6\:VDD VDD) resistor r=0.04967 c=0
Rk28 (\5\:VDD \6\:VDD) resistor r=0.3379 c=0
Rk31 (\5\:VDD \9\:VDD) resistor r=0.2525 c=0
Rk32 (\6\:VDD \11\:VDD) resistor r=0.2525 c=0
Rk14 (\15\:net76 \2\:net76) resistor r=0.2148 c=0
Rk12 (\14\:net76 \15\:net76) resistor r=0.2592 c=0
Rk13 (\15\:net76 \17\:net76) resistor r=0.1285 c=0
Rl21 (\2\:AN \3\:AN) resistor r=24.2328 c=0
Rl20 (\1\:AN \2\:AN) resistor r=112.26 c=0
Rl17 (B \12\:B) resistor r=49.5541 c=0
Rl15 (B \10\:B) resistor r=52.4625 c=0
Rl3 (B \1\:B) resistor r=30.5643 c=0
Rl6 (B \5\:B) resistor r=82.6695 c=0
Rl1 (\2\:net76 net76) resistor r=97.3098 c=0
Rl19 (\2\:net76 \12\:net76) resistor r=94.0258 c=0
Rl12 (\7\:net76 \9\:net76) resistor r=117.766 c=0
Rl11 (\7\:net76 \8\:net76) resistor r=94.6893 c=0
Rl10 (\7\:net76 \2\:net76) resistor r=4.0691 c=0
Rz12 (\3\:VDD VDD) resistor r=75 c=0
Rz11 (\3\:VDD \4\:VDD) resistor r=7.5 c=0
Rz5 (\17\:net76 \16\:net76) resistor r=75 c=0
Ry1 (\12\:Y \11\:Y) resistor r=20.6667 c=0
Ry2 (\14\:Y \13\:Y) resistor r=20.6667 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry6 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry7 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry3 (\14\:net76 \13\:net76) resistor r=62 c=0
Rx3 (\2\:AN \4\:AN) resistor r=45 c=0
mn1 (\1\:Y \2\:net76 VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.858e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.67163e-06 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(4)
mn2 (\1\:Y B VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=1.46663e-06 sd=160n sca=10.104 scb=0.00906063 \
        scc=0.000325539 m=(4)
mn0 (\16\:net76 \1\:AN VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mp2_1__rcx (\11\:Y \5\:B 3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=1.36058e-06 sd=160n sca=19.4464 \
        scb=0.0177092 scc=0.0012961 m=(1)
mp2_2__rcx (\11\:Y \1\:B 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=1.15558e-06 sd=160n sca=17.6679 \
        scb=0.0153903 scc=0.00128092 m=(1)
mp1_3__rcx (7 \12\:net76 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=8.19e-14 ps=1.16e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=2.80577e-07 sd=160n sca=17.721 \
        scb=0.0154359 scc=0.00128099 m=(1)
mp1_2__rcx (5 \8\:net76 \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.05058e-06 sd=160n sca=17.2206 \
        scb=0.0150864 scc=0.00128061 m=(1)
mp1 (6 \9\:net76 \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=8.45577e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp2 (\13\:Y \10\:B 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 sa=9.2e-07 \
        sb=7.40577e-07 sd=160n sca=16.7336 scb=0.0149207 scc=0.00128056 \
        m=(1)
mp2_3__rcx (\13\:Y \12\:B 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.19e-14 ad=6.24e-14 ps=1.2e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=5.35577e-07 sd=160n sca=16.8346 \
        scb=0.0149419 scc=0.00128056 m=(1)
mp0 (\13\:net76 \3\:AN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.44e-14 ps=1.16e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.615e-06 sb=1.6e-07 sd=160n sca=25.3293 \
        scb=0.0247188 scc=0.0022828 m=(1)
ends NOR2BX4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:08:07 2012 )
// Library name: gsclib045
// Cell name: NOR2BXL
// View name: extracted

simulator lang=spectre

subckt NOR2BXL AN B VDD VSS Y
mp2 (\3\:Y \1\:B net59 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=16.4797 \
        scb=0.0152074 scc=0.000231472 m=(1)
C1 (AN VSS) capacitor c=6.72358e-17
C2 (VDD VSS) capacitor c=1.15491e-16
C3 (Y VSS) capacitor c=8.07861e-17
C4 (B VSS) capacitor c=8.50283e-17
C5 (net76 VSS) capacitor c=2.12622e-17
C6 (\1\:AN VSS) capacitor c=3.96545e-17
C7 (\4\:net76 VSS) capacitor c=9.88831e-17
C8 (\1\:B VSS) capacitor c=7.40638e-17
C9 (\4\:AN VSS) capacitor c=4.67493e-17
C10 (\3\:net76 VSS) capacitor c=3.11584e-17
C11 (\3\:B VSS) capacitor c=3.3945e-17
C12 (\3\:AN VSS) capacitor c=2.29026e-17
C13 (\2\:B VSS) capacitor c=6.84119e-17
C14 (\5\:net76 VSS) capacitor c=5.38838e-17
C15 (\5\:VDD VSS) capacitor c=3.02696e-17
C16 (\3\:Y VSS) capacitor c=2.71219e-17
C17 (\1\:VDD VSS) capacitor c=9.29519e-18
C18 (\9\:net76 VSS) capacitor c=2.52655e-17
C19 (\1\:Y VSS) capacitor c=1.21235e-16
C20 (\2\:net76 VSS) capacitor c=7.31446e-17
C21 (\2\:AN VSS) capacitor c=4.19854e-17
C22 (\4\:B VSS) capacitor c=3.76246e-17
C23 (\5\:AN VSS) capacitor c=4.69069e-17
C24 (\7\:net76 VSS) capacitor c=5.16487e-17
C25 (\8\:net76 VSS) capacitor c=4.21658e-17
Rk4 (\5\:AN AN) resistor r=0.1908 c=0
Rk8 (\2\:VDD \3\:VDD) resistor r=0.1151 c=0
Rk10 (\4\:VDD VDD) resistor r=0.09998 c=0
Rk9 (\3\:VDD \4\:VDD) resistor r=0.1351 c=0
Rk11 (\3\:VDD \6\:VDD) resistor r=0.2525 c=0
Rk2 (\2\:Y Y) resistor r=0.8073 c=0
Rk3 (Y \4\:Y) resistor r=0.1143 c=0
Rk1 (B \4\:B) resistor r=0.09278 c=0
Rk12 (\2\:VSS \3\:VSS) resistor r=0.1151 c=0
Rk13 (\3\:VSS \4\:VSS) resistor r=0.085 c=0
Rk15 (\5\:VSS VSS) resistor r=0.02962 c=0
Rk14 (\4\:VSS \5\:VSS) resistor r=0.1201 c=0
Rk17 (\3\:VSS \8\:VSS) resistor r=0.1986 c=0
Rk18 (\5\:VSS \10\:VSS) resistor r=0.1954 c=0
Rk5 (\6\:net76 \7\:net76) resistor r=0.4575 c=0
Rk6 (\7\:net76 \8\:net76) resistor r=0.1556 c=0
Rk7 (\7\:net76 \10\:net76) resistor r=0.1626 c=0
Rl6 (\1\:AN \2\:AN) resistor r=138.176 c=0
Rl8 (\2\:AN \4\:AN) resistor r=138.176 c=0
Rl7 (\2\:AN \3\:AN) resistor r=1.2666 c=0
Rl1 (\1\:B \2\:B) resistor r=161.516 c=0
Rl2 (\2\:B \3\:B) resistor r=95.9489 c=0
Rl3 (net76 \2\:net76) resistor r=1.2334 c=0
Rl5 (\2\:net76 \4\:net76) resistor r=227.726 c=0
Rl4 (\2\:net76 \3\:net76) resistor r=46.9565 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \4\:VDD) resistor r=25 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz5 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz6 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz2 (\9\:net76 \10\:net76) resistor r=75 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry6 (\1\:VSS VSS) resistor r=62 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry5 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry2 (\5\:net76 \6\:net76) resistor r=62 c=0
Rx2 (\3\:AN \5\:AN) resistor r=45 c=0
Rx1 (\2\:B \4\:B) resistor r=45 c=0
Rx3 (net76 \8\:net76) resistor r=45 c=0
mn2 (\1\:Y \3\:B \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn1 (\1\:Y \3\:net76 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mn0 (\9\:net76 \4\:AN \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mp1 (net59 \4\:net76 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=15.2571 \
        scb=0.0126505 scc=0.000156674 m=(1)
mp0 (\5\:net76 \1\:AN \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=17.3518 \
        scb=0.0169054 scc=0.000309574 m=(1)
ends NOR2BXL
// End of subcircuit definition.

// Generated for: spectre (May  9 16:08:44 2012 )
// Library name: gsclib045
// Cell name: NOR2X1
// View name: extracted

simulator lang=spectre

subckt NOR2X1 A B VDD VSS Y
mp0 (net41 \1\:A \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3e-07 sd=160n sca=47.793 scb=0.0435602 \
        scc=0.00480908 m=(1)
C1 (A VSS) capacitor c=6.69831e-17
C2 (Y VSS) capacitor c=3.8945e-17
C3 (B VSS) capacitor c=5.76359e-17
C4 (VDD VSS) capacitor c=3.95981e-17
C5 (net41 VSS) capacitor c=1.01113e-18
C6 (\3\:B VSS) capacitor c=6.41479e-17
C7 (\1\:A VSS) capacitor c=6.44359e-17
C8 (\1\:B VSS) capacitor c=3.39511e-17
C9 (\4\:A VSS) capacitor c=3.20534e-17
C10 (\2\:B VSS) capacitor c=3.5179e-17
C11 (\3\:A VSS) capacitor c=1.24782e-17
C12 (\1\:Y VSS) capacitor c=7.47342e-17
C13 (\3\:VDD VSS) capacitor c=5.49823e-17
C14 (\3\:Y VSS) capacitor c=5.12758e-17
C15 (\2\:A VSS) capacitor c=2.64309e-17
C16 (\4\:B VSS) capacitor c=6.30685e-17
Rk1 (\5\:A A) resistor r=0.01003 c=0
Rk3 (\2\:Y Y) resistor r=0.2872 c=0
Rk4 (Y \4\:Y) resistor r=0.2283 c=0
Rk6 (\4\:VSS VSS) resistor r=0.1004 c=0
Rk5 (\2\:VSS \4\:VSS) resistor r=0.1357 c=0
Rk7 (VSS \6\:VSS) resistor r=0.3123 c=0
Rk2 (\4\:B B) resistor r=0.1667 c=0
Rk9 (VDD \4\:VDD) resistor r=0.3954 c=0
Rl1 (\1\:A \2\:A) resistor r=37.3411 c=0
Rl3 (\2\:A \4\:A) resistor r=64.2642 c=0
Rl2 (\2\:A \3\:A) resistor r=3.7301 c=0
Rl5 (\2\:B \3\:B) resistor r=28.079 c=0
Rl4 (\1\:B \2\:B) resistor r=72.7926 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz3 (\5\:VSS \6\:VSS) resistor r=37.5 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry3 (\3\:VDD \4\:VDD) resistor r=20.6667 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
mn0 (\3\:Y \4\:A \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.15e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn1 (\3\:Y \1\:B \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=4.16e-14 ps=1.4e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.1e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mp1 (\1\:Y \3\:B net41 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.605e-14 ps=9e-07 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.95e-07 sd=160n sca=43.6586 \
        scb=0.0391745 scc=0.00386673 m=(1)
ends NOR2X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:16:34 2012 )
// Library name: gsclib045
// Cell name: NOR2X2
// View name: extracted

simulator lang=spectre

subckt NOR2X2 A B VDD VSS Y
mp0 (3 \1\:A \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.55e-07 sd=160n sca=20.7977 \
        scb=0.0219422 scc=0.000863938 m=(1)
C1 (A VSS) capacitor c=3.63183e-17
C2 (Y VSS) capacitor c=7.90092e-17
C3 (B VSS) capacitor c=6.27214e-17
C4 (VDD VSS) capacitor c=6.72911e-17
C5 (3 VSS) capacitor c=9.37954e-19
C6 (5 VSS) capacitor c=3.74697e-18
C7 (\6\:A VSS) capacitor c=7.24671e-17
C8 (\1\:B VSS) capacitor c=6.16799e-17
C9 (\6\:B VSS) capacitor c=5.66349e-17
C10 (\1\:A VSS) capacitor c=7.41277e-17
C11 (\2\:A VSS) capacitor c=3.26289e-16
C12 (\7\:VDD VSS) capacitor c=5.47717e-17
C13 (\6\:Y VSS) capacitor c=1.39813e-16
C14 (\9\:VDD VSS) capacitor c=4.41863e-17
C15 (\1\:VDD VSS) capacitor c=3.05433e-17
C16 (\1\:Y VSS) capacitor c=1.81065e-16
C17 (\2\:B VSS) capacitor c=1.38037e-16
C18 (\7\:B VSS) capacitor c=3.58604e-17
C19 (\3\:VDD VSS) capacitor c=1.01282e-18
C20 (\5\:VDD VSS) capacitor c=1.01282e-18
Rk3 (\2\:A A) resistor r=0.1014 c=0
Rk6 (\1\:Y Y) resistor r=0.09399 c=0
Rk7 (Y \7\:Y) resistor r=0.7537 c=0
Rk10 (VSS \6\:VSS) resistor r=0.3274 c=0
Rk1 (\7\:B B) resistor r=0.05499 c=0
Rk12 (\2\:VDD \3\:VDD) resistor r=0.03998 c=0
Rk13 (\3\:VDD \4\:VDD) resistor r=0.1605 c=0
Rk15 (\5\:VDD VDD) resistor r=0.04977 c=0
Rk14 (\4\:VDD \5\:VDD) resistor r=0.1504 c=0
Rk17 (\3\:VDD \8\:VDD) resistor r=0.3043 c=0
Rk18 (\5\:VDD \10\:VDD) resistor r=0.3144 c=0
Rl9 (\2\:A \6\:A) resistor r=72.5275 c=0
Rl1 (\2\:A \1\:A) resistor r=75.1972 c=0
Rl3 (\2\:B \1\:B) resistor r=47.3105 c=0
Rl7 (\2\:B \6\:B) resistor r=24.2328 c=0
Rz4 (\6\:VSS \5\:VSS) resistor r=75 c=0
Rz8 (\1\:VDD VDD) resistor r=75 c=0
Rz6 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz7 (\1\:VDD \4\:VDD) resistor r=25 c=0
Ry1 (\7\:Y \6\:Y) resistor r=31 c=0
Ry3 (\7\:VDD \8\:VDD) resistor r=20.6667 c=0
Ry4 (\9\:VDD \10\:VDD) resistor r=20.6667 c=0
Rx1 (\7\:B \2\:B) resistor r=45 c=0
mn0 (\1\:Y \2\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.265e-14 ad=4.16e-14 ps=1.12e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.15e-07 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(2)
mn1 (\1\:Y \2\:B \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.1e-07 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(2)
mp1 (\6\:Y \6\:B 3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=4.5e-07 sd=160n sca=18.3517 scb=0.0171974 \
        scc=0.00064315 m=(1)
mp1_1__rcx (\6\:Y \1\:B 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2.45e-07 sd=160n sca=18.6339 \
        scb=0.0177874 scc=0.000660551 m=(1)
mp0_1__rcx (5 \6\:A \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.4e-07 sd=160n sca=21.6313 \
        scb=0.0233702 scc=0.000971691 m=(1)
ends NOR2X2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:09:59 2012 )
// Library name: gsclib045
// Cell name: NOR2X4
// View name: extracted

simulator lang=spectre

subckt NOR2X4 A B VDD VSS Y
mp0 (3 \1\:A \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.275e-06 sd=160n sca=17.191 \
        scb=0.0171908 scc=0.000536617 m=(1)
C1 (B VSS) capacitor c=4.90507e-16
C2 (Y VSS) capacitor c=7.76953e-17
C3 (A VSS) capacitor c=6.79263e-16
C4 (VDD VSS) capacitor c=1.06437e-16
C5 (5 VSS) capacitor c=1.85973e-18
C6 (6 VSS) capacitor c=3.10844e-18
C7 (7 VSS) capacitor c=4.12639e-18
C8 (\13\:A VSS) capacitor c=5.02185e-17
C9 (\12\:B VSS) capacitor c=3.9323e-17
C10 (\10\:B VSS) capacitor c=3.98924e-17
C11 (\4\:A VSS) capacitor c=4.59148e-17
C12 (\10\:A VSS) capacitor c=6.65597e-17
C13 (\1\:B VSS) capacitor c=5.91799e-17
C14 (\5\:B VSS) capacitor c=7.34376e-17
C15 (\1\:A VSS) capacitor c=7.86499e-17
C16 (\7\:VDD VSS) capacitor c=4.59167e-17
C17 (\15\:Y VSS) capacitor c=3.60214e-17
C18 (\9\:VDD VSS) capacitor c=5.30044e-17
C19 (\9\:Y VSS) capacitor c=1.08745e-16
C20 (\11\:VDD VSS) capacitor c=3.98699e-17
C21 (\1\:VDD VSS) capacitor c=2.09188e-17
C22 (\1\:Y VSS) capacitor c=5.05554e-16
C23 (\8\:Y VSS) capacitor c=1.39797e-16
C24 (\3\:VDD VSS) capacitor c=1.62656e-17
C25 (\4\:VDD VSS) capacitor c=1.66134e-17
C26 (\6\:VDD VSS) capacitor c=9.98001e-18
Rk10 (\1\:Y Y) resistor r=0.3389 c=0
Rk11 (Y \8\:Y) resistor r=0.3891 c=0
Rk12 (\8\:Y \10\:Y) resistor r=0.5878 c=0
Rk15 (\8\:Y \16\:Y) resistor r=0.09058 c=0
Rk24 (\2\:VDD \3\:VDD) resistor r=0.04999 c=0
Rk25 (\3\:VDD \4\:VDD) resistor r=0.361 c=0
Rk26 (\4\:VDD \5\:VDD) resistor r=0.03996 c=0
Rk28 (\6\:VDD VDD) resistor r=0.07986 c=0
Rk27 (\5\:VDD \6\:VDD) resistor r=0.2708 c=0
Rk29 (\3\:VDD \8\:VDD) resistor r=0.2895 c=0
Rk30 (\4\:VDD \10\:VDD) resistor r=0.2491 c=0
Rk31 (\6\:VDD \12\:VDD) resistor r=0.2895 c=0
Rl18 (B \12\:B) resistor r=43.4713 c=0
Rl16 (B \10\:B) resistor r=37.3423 c=0
Rl3 (B \1\:B) resistor r=34.766 c=0
Rl6 (B \5\:B) resistor r=57.3425 c=0
Rl20 (A \13\:A) resistor r=72.2527 c=0
Rl8 (A \4\:A) resistor r=77.7258 c=0
Rl13 (A \10\:A) resistor r=77.7258 c=0
Rl1 (A \1\:A) resistor r=100.988 c=0
Rz10 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz11 (\1\:VDD \5\:VDD) resistor r=9.375 c=0
Ry1 (\10\:Y \9\:Y) resistor r=20.6667 c=0
Ry2 (\16\:Y \15\:Y) resistor r=20.6667 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=20.6667 c=0
Ry5 (\9\:VDD \10\:VDD) resistor r=31 c=0
Ry6 (\11\:VDD \12\:VDD) resistor r=20.6667 c=0
mn0 (\1\:Y A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.213e-14 \
        ad=4.16e-14 ps=9.8e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 sa=1e-07 \
        sb=1.575e-06 sd=160n sca=14.4034 scb=0.0144248 scc=0.00102063 \
        m=(4)
mn1 (\1\:Y B VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.16e-14 \
        ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.05e-07 sb=1.37e-06 sd=160n sca=14.4034 scb=0.0144248 \
        scc=0.00102063 m=(4)
mp1 (\9\:Y \5\:B 3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.17e-06 sd=160n sca=15.1734 scb=0.013698 \
        scc=0.000458097 m=(1)
mp1_1__rcx (\9\:Y \1\:B 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=9.65e-07 sd=160n sca=13.4386 \
        scb=0.0114697 scc=0.000444227 m=(1)
mp0_1__rcx (5 \10\:A \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=8.6e-07 sd=160n sca=12.9998 \
        scb=0.0111784 scc=0.000443945 m=(1)
mp0_2__rcx (6 \4\:A \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.095e-14 ps=1.1e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=6.55e-07 sd=160n sca=12.8726 \
        scb=0.0111206 scc=0.000443921 m=(1)
mp1_2__rcx (\15\:Y \10\:B 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.095e-14 ad=6.24e-14 ps=9.9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=5.05e-07 sd=160n sca=13.4643 \
        scb=0.0114911 scc=0.000444259 m=(1)
mp1_3__rcx (\15\:Y \12\:B 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=3e-07 sd=160n sca=15.2428 scb=0.01381 \
        scc=0.000459441 m=(1)
mp0_3__rcx (7 \13\:A \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.485e-14 ps=1.06e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.275e-06 sb=1.4e-07 sd=160n sca=19.2125 \
        scb=0.0206809 scc=0.000707669 m=(1)
ends NOR2X4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:10:37 2012 )
// Library name: gsclib045
// Cell name: NOR2X6
// View name: extracted

simulator lang=spectre

subckt NOR2X6 A B VDD VSS Y
mp0_1__rcx (2 \1\:A \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.82e-06 sd=160n sca=17.8302 \
        scb=0.0172414 scc=0.000800052 m=(1)
C1 (Y VSS) capacitor c=6.89033e-17
C2 (A VSS) capacitor c=8.46121e-16
C3 (VDD VSS) capacitor c=1.20989e-16
C4 (B VSS) capacitor c=7.85781e-16
C5 (2 VSS) capacitor c=1.86356e-18
C6 (4 VSS) capacitor c=1.9638e-18
C7 (5 VSS) capacitor c=1.87598e-18
C8 (6 VSS) capacitor c=1.9638e-18
C9 (7 VSS) capacitor c=1.9638e-18
C10 (\17\:A VSS) capacitor c=6.81265e-17
C11 (\17\:B VSS) capacitor c=6.03974e-17
C12 (\16\:B VSS) capacitor c=6.11911e-17
C13 (\16\:A VSS) capacitor c=6.80376e-17
C14 (\14\:A VSS) capacitor c=7.21656e-17
C15 (\12\:B VSS) capacitor c=6.37073e-17
C16 (\11\:B VSS) capacitor c=6.05585e-17
C17 (\4\:A VSS) capacitor c=6.75586e-17
C18 (\10\:A VSS) capacitor c=6.7827e-17
C19 (\1\:B VSS) capacitor c=6.06119e-17
C20 (\5\:B VSS) capacitor c=6.44156e-17
C21 (\1\:A VSS) capacitor c=7.88815e-17
C22 (\18\:A VSS) capacitor c=4.69927e-17
C23 (\8\:VDD VSS) capacitor c=3.45862e-17
C24 (\21\:Y VSS) capacitor c=3.78627e-17
C25 (\10\:VDD VSS) capacitor c=5.04309e-17
C26 (\19\:Y VSS) capacitor c=3.77191e-17
C27 (\12\:VDD VSS) capacitor c=5.04708e-17
C28 (\16\:Y VSS) capacitor c=3.77247e-17
C29 (\14\:VDD VSS) capacitor c=5.46199e-17
C30 (\1\:VDD VSS) capacitor c=1.80035e-17
C31 (\1\:Y VSS) capacitor c=7.12103e-16
C32 (\15\:Y VSS) capacitor c=1.51685e-16
C33 (\18\:Y VSS) capacitor c=9.70707e-17
C34 (\19\:A VSS) capacitor c=7.33607e-17
C35 (\3\:VDD VSS) capacitor c=1.54505e-17
C36 (\4\:VDD VSS) capacitor c=2.09072e-17
C37 (\6\:VDD VSS) capacitor c=1.38541e-17
C38 (\7\:VDD VSS) capacitor c=1.34285e-17
Rk12 (\1\:Y \15\:Y) resistor r=0.8098 c=0
Rk13 (\15\:Y \17\:Y) resistor r=0.09073 c=0
Rk16 (\18\:Y Y) resistor r=0.4478 c=0
Rk14 (\15\:Y \18\:Y) resistor r=0.46 c=0
Rk15 (\18\:Y \20\:Y) resistor r=0.09073 c=0
Rk17 (Y \22\:Y) resistor r=0.1144 c=0
Rk18 (\19\:A A) resistor r=0.5677 c=0
Rk22 (\2\:VDD \3\:VDD) resistor r=0.06757 c=0
Rk23 (\3\:VDD \4\:VDD) resistor r=0.3108 c=0
Rk24 (\4\:VDD \5\:VDD) resistor r=0.2232 c=0
Rk25 (\5\:VDD \6\:VDD) resistor r=0.09016 c=0
Rk27 (\7\:VDD VDD) resistor r=0.09995 c=0
Rk26 (\6\:VDD \7\:VDD) resistor r=0.3108 c=0
Rk28 (\3\:VDD \9\:VDD) resistor r=0.3168 c=0
Rk29 (\4\:VDD \11\:VDD) resistor r=0.2731 c=0
Rk30 (\6\:VDD \13\:VDD) resistor r=0.2731 c=0
Rk31 (\7\:VDD \15\:VDD) resistor r=0.3135 c=0
Rl23 (A \16\:A) resistor r=93.9956 c=0
Rl21 (A \14\:A) resistor r=109.535 c=0
Rl8 (A \4\:A) resistor r=89.2642 c=0
Rl13 (A \10\:A) resistor r=89.2642 c=0
Rl1 (A \1\:A) resistor r=107.281 c=0
Rl28 (\18\:A \17\:A) resistor r=51.098 c=0
Rl27 (B \17\:B) resistor r=45.1626 c=0
Rl26 (B \16\:B) resistor r=48.0781 c=0
Rl18 (B \12\:B) resistor r=52.5659 c=0
Rl17 (B \11\:B) resistor r=46.2322 c=0
Rl3 (B \1\:B) resistor r=45.369 c=0
Rl6 (B \5\:B) resistor r=52.5659 c=0
Rz6 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz7 (\1\:VDD \5\:VDD) resistor r=6.8182 c=0
Ry1 (\17\:Y \16\:Y) resistor r=20.6667 c=0
Ry2 (\20\:Y \19\:Y) resistor r=20.6667 c=0
Ry3 (\22\:Y \21\:Y) resistor r=20.6667 c=0
Ry4 (\8\:VDD \9\:VDD) resistor r=20.6667 c=0
Ry5 (\10\:VDD \11\:VDD) resistor r=31 c=0
Ry6 (\12\:VDD \13\:VDD) resistor r=31 c=0
Ry7 (\14\:VDD \15\:VDD) resistor r=20.6667 c=0
Rx4 (\19\:A \18\:A) resistor r=45 c=0
mn0 (\1\:Y A VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=4.898e-14 \
        ad=4.96e-14 ps=9.36e-07 pd=9.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=11.8347 scb=0.0112322 \
        scc=0.000626052 m=(5)
mn1 (\1\:Y B VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=4.96e-14 \
        ad=4.96e-14 ps=9.4e-07 pd=9.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=1.805e-06 sd=160n sca=11.8347 scb=0.0112322 \
        scc=0.000626052 m=(5)
mp1_1__rcx (\16\:Y \5\:B 2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.715e-06 sd=160n sca=16.2541 \
        scb=0.014643 scc=0.000761282 m=(1)
mp1 (\16\:Y \1\:B 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 sa=4.5e-07 \
        sb=1.51e-06 sd=160n sca=14.8213 scb=0.0130288 scc=0.000754571 \
        m=(1)
mp0 (4 \10\:A \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.405e-06 sd=160n sca=14.4437 \
        scb=0.0128219 scc=0.000754437 m=(1)
mp0_2__rcx (5 \4\:A \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.2e-06 sd=160n sca=14.1011 \
        scb=0.0127228 scc=0.000754417 m=(1)
mp0_4__rcx (7 \16\:A \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=2.34e-14 ps=1.11e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=5.75e-07 sd=160n sca=14.6601 \
        scb=0.0129275 scc=0.000754489 m=(1)
mp1_2__rcx (\19\:Y \11\:B 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.095e-06 sd=160n sca=14.1011 \
        scb=0.0127228 scc=0.000754417 m=(1)
mp1_4__rcx (\21\:Y \16\:B 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.49e-06 sb=4.7e-07 sd=160n sca=15.1439 \
        scb=0.0132876 scc=0.000754937 m=(1)
mp1_3__rcx (\19\:Y \12\:B 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=8.9e-07 sd=160n sca=14.1011 \
        scb=0.0127228 scc=0.000754417 m=(1)
mp1_5__rcx (\21\:Y \17\:B 8 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.695e-06 sb=2.65e-07 sd=160n sca=17.1124 \
        scb=0.0160045 scc=0.000776708 m=(1)
mp0_3__rcx (6 \14\:A \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=2.34e-14 ps=1.11e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=7.85e-07 sd=160n sca=14.1011 \
        scb=0.0127228 scc=0.000754417 m=(1)
mp0_5__rcx (8 \17\:A \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-06 sb=1.6e-07 sd=160n sca=19.4933 \
        scb=0.0201815 scc=0.000898164 m=(1)
ends NOR2X6
// End of subcircuit definition.

// Generated for: spectre (May  9 10:05:15 2012 )
// Library name: gsclib045
// Cell name: NOR2X8
// View name: extracted

simulator lang=spectre

subckt NOR2X8 A B VDD VSS Y
mp0_1__rcx (2 \1\:A \14\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.23e-14 ad=2.67e-14 ps=1.17e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.537 scb=0.0176846 \
        scc=0.000953219 m=(1)
C1 (A VSS) capacitor c=1.1863e-15
C2 (Y VSS) capacitor c=4.02979e-17
C3 (VDD VSS) capacitor c=1.62353e-16
C4 (B VSS) capacitor c=1.05671e-15
C5 (2 VSS) capacitor c=3.0278e-18
C6 (4 VSS) capacitor c=2.01655e-18
C7 (5 VSS) capacitor c=1.8715e-18
C8 (6 VSS) capacitor c=2.01655e-18
C9 (7 VSS) capacitor c=2.01655e-18
C10 (8 VSS) capacitor c=2.0385e-18
C11 (9 VSS) capacitor c=2.01655e-18
C12 (\22\:B VSS) capacitor c=9.53584e-17
C13 (\23\:A VSS) capacitor c=7.21774e-17
C14 (\22\:A VSS) capacitor c=8.30955e-17
C15 (\19\:B VSS) capacitor c=6.33113e-17
C16 (\17\:B VSS) capacitor c=6.43905e-17
C17 (\16\:A VSS) capacitor c=7.22305e-17
C18 (\14\:A VSS) capacitor c=7.56934e-17
C19 (\12\:B VSS) capacitor c=8.052e-17
C20 (\11\:B VSS) capacitor c=6.37914e-17
C21 (\4\:A VSS) capacitor c=7.13019e-17
C22 (\10\:A VSS) capacitor c=7.17956e-17
C23 (\1\:B VSS) capacitor c=6.42803e-17
C24 (\5\:B VSS) capacitor c=8.10503e-17
C25 (\1\:A VSS) capacitor c=8.33517e-17
C26 (\32\:Y VSS) capacitor c=2.46809e-17
C27 (\8\:VDD VSS) capacitor c=5.02466e-17
C28 (\29\:Y VSS) capacitor c=3.85794e-17
C29 (\10\:VDD VSS) capacitor c=4.9988e-17
C30 (\26\:Y VSS) capacitor c=3.84973e-17
C31 (\12\:VDD VSS) capacitor c=4.99257e-17
C32 (\23\:Y VSS) capacitor c=3.84955e-17
C33 (\14\:VDD VSS) capacitor c=4.73711e-17
C34 (\1\:VDD VSS) capacitor c=5.35936e-17
C35 (\1\:Y VSS) capacitor c=9.76442e-16
C36 (\21\:A VSS) capacitor c=5.48518e-17
C37 (\34\:Y VSS) capacitor c=4.83786e-17
C38 (\22\:Y VSS) capacitor c=1.48894e-16
C39 (\25\:Y VSS) capacitor c=8.49541e-17
C40 (\28\:Y VSS) capacitor c=8.51082e-17
C41 (\31\:Y VSS) capacitor c=7.28489e-17
C42 (\3\:VDD VSS) capacitor c=1.57591e-17
C43 (\4\:VDD VSS) capacitor c=2.29513e-17
C44 (\6\:VDD VSS) capacitor c=1.55319e-17
C45 (\7\:VDD VSS) capacitor c=1.48165e-17
Rk31 (Y \34\:Y) resistor r=0.3651 c=0
Rk32 (\34\:Y \1\:Y) resistor r=0.07606 c=0
Rk22 (\1\:Y \22\:Y) resistor r=0.8362 c=0
Rk23 (\22\:Y \24\:Y) resistor r=0.09088 c=0
Rk24 (\22\:Y \25\:Y) resistor r=0.4605 c=0
Rk25 (\25\:Y \27\:Y) resistor r=0.09088 c=0
Rk26 (\25\:Y \28\:Y) resistor r=0.4641 c=0
Rk27 (\28\:Y \30\:Y) resistor r=0.08751 c=0
Rk30 (\31\:Y Y) resistor r=0.3427 c=0
Rk28 (\28\:Y \31\:Y) resistor r=0.4605 c=0
Rk29 (\31\:Y \33\:Y) resistor r=0.08751 c=0
Rk52 (\2\:VDD \3\:VDD) resistor r=0.2684 c=0
Rk53 (\3\:VDD \4\:VDD) resistor r=0.3109 c=0
Rk54 (\4\:VDD \5\:VDD) resistor r=0.2232 c=0
Rk55 (\5\:VDD \6\:VDD) resistor r=0.09018 c=0
Rk57 (\7\:VDD VDD) resistor r=0.09997 c=0
Rk56 (\6\:VDD \7\:VDD) resistor r=0.3109 c=0
Rk58 (\3\:VDD \9\:VDD) resistor r=0.2499 c=0
Rk59 (\4\:VDD \11\:VDD) resistor r=0.2499 c=0
Rk60 (\6\:VDD \13\:VDD) resistor r=0.2499 c=0
Rk61 (\7\:VDD \15\:VDD) resistor r=0.2903 c=0
Rl23 (A \16\:A) resistor r=86.3033 c=0
Rl21 (A \14\:A) resistor r=101.842 c=0
Rl8 (A \4\:A) resistor r=81.5719 c=0
Rl13 (A \10\:A) resistor r=81.5719 c=0
Rl1 (A \1\:A) resistor r=99.5886 c=0
Rl33 (\21\:A A) resistor r=41.0733 c=0
Rl35 (\21\:A \23\:A) resistor r=65.6027 c=0
Rl34 (\21\:A \22\:A) resistor r=132.813 c=0
Rl37 (B \22\:B) resistor r=113.107 c=0
Rl29 (B \19\:B) resistor r=37.4703 c=0
Rl27 (B \17\:B) resistor r=40.3857 c=0
Rl18 (B \12\:B) resistor r=44.8736 c=0
Rl17 (B \11\:B) resistor r=38.5399 c=0
Rl3 (B \1\:B) resistor r=37.6767 c=0
Rl6 (B \5\:B) resistor r=44.8736 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=15 c=0
Rz17 (\1\:VDD \5\:VDD) resistor r=6.8182 c=0
Ry1 (\24\:Y \23\:Y) resistor r=20.6667 c=0
Ry2 (\27\:Y \26\:Y) resistor r=20.6667 c=0
Ry3 (\30\:Y \29\:Y) resistor r=20.6667 c=0
Ry4 (\33\:Y \32\:Y) resistor r=20.6667 c=0
Ry9 (\8\:VDD \9\:VDD) resistor r=31 c=0
Ry10 (\10\:VDD \11\:VDD) resistor r=31 c=0
Ry11 (\12\:VDD \13\:VDD) resistor r=31 c=0
Ry12 (\14\:VDD \15\:VDD) resistor r=20.6667 c=0
mn0 (\1\:Y A VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 as=4.678e-14 \
        ad=4.72e-14 ps=9.0714e-07 pd=9.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=11.2331 scb=0.0105428 \
        scc=0.000514855 m=(7)
mn1 (\1\:Y B VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 as=4.72e-14 \
        ad=4.72e-14 ps=9.1e-07 pd=9.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=2e-06 sd=160n sca=11.2331 scb=0.0105428 \
        scc=0.000514855 m=(7)
mp1_1__rcx (\23\:Y \5\:B 2 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=16.9609 scb=0.0150862 \
        scc=0.00091445 m=(1)
mp1 (\23\:Y \1\:B 4 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 as=2.67e-14 \
        ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=1.8e-06 sd=160n sca=15.5281 scb=0.013472 \
        scc=0.000907738 m=(1)
mp0 (4 \10\:A \12\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.67e-14 ps=1.21e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.695e-06 sd=160n sca=15.1505 \
        scb=0.0132652 scc=0.000907605 m=(1)
mp0_2__rcx (5 \4\:A \12\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.67e-14 ps=1.21e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.49e-06 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp0_4__rcx (7 \16\:A \10\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.342e-14 ad=2.67e-14 ps=1.22e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=8.65e-07 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp1_2__rcx (\26\:Y \11\:B 5 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.385e-06 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp1_4__rcx (\29\:Y \17\:B 7 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.49e-06 sb=7.6e-07 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp1_3__rcx (\26\:Y \12\:B 6 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.18e-06 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp1_5__rcx (\29\:Y \19\:B 8 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.695e-06 sb=5.55e-07 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp0_3__rcx (6 \14\:A \10\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.342e-14 ad=2.67e-14 ps=1.22e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.075e-06 sd=160n sca=14.8079 \
        scb=0.013166 scc=0.000907585 m=(1)
mp0_5__rcx (8 \22\:A \8\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.67e-14 ps=1.21e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-06 sb=4.5e-07 sd=160n sca=14.8079 scb=0.013166 \
        scc=0.000907585 m=(1)
mp0_6__rcx (9 \23\:A \8\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.67e-14 ps=1.21e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=14.8666 scb=0.0131776 \
        scc=0.000907586 m=(1)
mp1_6__rcx (\32\:Y \22\:B 9 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=6.23e-14 ps=1.01e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.1213 scb=0.0132536 \
        scc=0.000907601 m=(1)
ends NOR2X8
// End of subcircuit definition.

// Generated for: spectre (May  9 16:11:54 2012 )
// Library name: gsclib045
// Cell name: NOR2XL
// View name: extracted

simulator lang=spectre

subckt NOR2XL A B VDD VSS Y
mp0 (net41 \1\:A \4\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=29.8819 \
        scb=0.0359119 scc=0.00165852 m=(1)
C1 (A VSS) capacitor c=6.46923e-17
C2 (B VSS) capacitor c=1.37646e-17
C3 (VDD VSS) capacitor c=3.87607e-17
C4 (\3\:B VSS) capacitor c=5.53994e-17
C5 (\1\:A VSS) capacitor c=6.90534e-17
C6 (\1\:B VSS) capacitor c=2.46075e-17
C7 (\4\:A VSS) capacitor c=2.31296e-17
C8 (\2\:B VSS) capacitor c=3.50273e-17
C9 (\3\:A VSS) capacitor c=1.18213e-17
C10 (\1\:Y VSS) capacitor c=5.97898e-17
C11 (\4\:VDD VSS) capacitor c=2.06849e-17
C12 (\3\:Y VSS) capacitor c=7.95842e-17
C13 (\2\:A VSS) capacitor c=2.45067e-17
C14 (\4\:B VSS) capacitor c=6.80433e-17
C15 (\3\:VDD VSS) capacitor c=1.21179e-17
Rk1 (\5\:A A) resistor r=0.01612 c=0
Rk3 (Y \2\:Y) resistor r=0.003074 c=0
Rk4 (\2\:Y \4\:Y) resistor r=0.4895 c=0
Rk5 (\2\:VSS \4\:VSS) resistor r=0.1633 c=0
Rk7 (\5\:VSS VSS) resistor r=0.1002 c=0
Rk6 (\4\:VSS \5\:VSS) resistor r=0.09985 c=0
Rk9 (VSS \8\:VSS) resistor r=0.1912 c=0
Rk2 (\4\:B B) resistor r=0.07915 c=0
Rk11 (\3\:VDD VDD) resistor r=0.02701 c=0
Rk12 (\3\:VDD \5\:VDD) resistor r=0.3297 c=0
Rl1 (\1\:A \2\:A) resistor r=106.972 c=0
Rl3 (\2\:A \4\:A) resistor r=34.3295 c=0
Rl2 (\2\:A \3\:A) resistor r=1.2666 c=0
Rl5 (\2\:B \3\:B) resistor r=72.8068 c=0
Rl4 (\1\:B \2\:B) resistor r=41.6242 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz3 (\7\:VSS \8\:VSS) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry4 (\3\:VSS VSS) resistor r=62 c=0
Ry2 (\3\:VSS \4\:VSS) resistor r=62 c=0
Ry3 (\3\:VSS \5\:VSS) resistor r=62 c=0
Ry5 (\4\:VDD \5\:VDD) resistor r=62 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
mn0 (\3\:Y \4\:A \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.36e-14 ad=2.32e-14 ps=1.48e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.05e-07 sd=160n sca=21.4614 scb=0.0218523 \
        scc=0.00230065 m=(1)
mn1 (\3\:Y \1\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.36e-14 ad=2.32e-14 ps=1.48e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1e-07 sd=160n sca=21.4614 scb=0.0218523 \
        scc=0.00230065 m=(1)
mp1 (\1\:Y \3\:B net41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=30.7015 \
        scb=0.0368156 scc=0.00184473 m=(1)
ends NOR2XL
// End of subcircuit definition.

// Generated for: spectre (May  9 16:12:32 2012 )
// Library name: gsclib045
// Cell name: NOR3BX1
// View name: extracted

simulator lang=spectre

subckt NOR3BX1 AN B C VDD VSS Y
mp3 (\6\:Y \1\:C net86 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.84167e-07 sd=160n sca=25.1103 \
        scb=0.022702 scc=0.00204888 m=(1)
C1 (C VSS) capacitor c=4.43922e-17
C2 (AN VSS) capacitor c=7.24417e-17
C3 (VDD VSS) capacitor c=7.00298e-17
C4 (Y VSS) capacitor c=7.5963e-17
C5 (B VSS) capacitor c=5.46692e-17
C6 (net91 VSS) capacitor c=4.61236e-17
C7 (net90 VSS) capacitor c=1.7867e-18
C8 (\3\:AN VSS) capacitor c=3.23606e-17
C9 (\3\:net91 VSS) capacitor c=6.50483e-17
C10 (\3\:B VSS) capacitor c=9.82699e-17
C11 (\1\:C VSS) capacitor c=7.60929e-17
C12 (\1\:AN VSS) capacitor c=4.56777e-17
C13 (\1\:B VSS) capacitor c=3.88273e-17
C14 (\4\:C VSS) capacitor c=4.21628e-17
C15 (\2\:AN VSS) capacitor c=4.39874e-17
C16 (\2\:net91 VSS) capacitor c=5.39199e-17
C17 (\2\:B VSS) capacitor c=5.96923e-17
C18 (\3\:C VSS) capacitor c=4.80249e-17
C19 (\4\:net91 VSS) capacitor c=3.29417e-17
C20 (\1\:VDD VSS) capacitor c=5.05335e-17
C21 (\6\:Y VSS) capacitor c=5.55158e-17
C22 (\8\:net91 VSS) capacitor c=2.8941e-17
C23 (\1\:Y VSS) capacitor c=7.20208e-17
C24 (\4\:Y VSS) capacitor c=3.49708e-17
C25 (\7\:C VSS) capacitor c=7.14438e-17
C26 (\4\:B VSS) capacitor c=6.74908e-17
C27 (\3\:Y VSS) capacitor c=4.25707e-17
C28 (\6\:net91 VSS) capacitor c=4.87483e-17
C29 (\7\:net91 VSS) capacitor c=5.38995e-17
C30 (\4\:VDD VSS) capacitor c=2.43721e-17
Rk13 (\2\:VSS \4\:VSS) resistor r=0.3149 c=0
Rk15 (\5\:VSS VSS) resistor r=0.1775 c=0
Rk14 (\4\:VSS \5\:VSS) resistor r=0.07247 c=0
Rk16 (\5\:VSS \7\:VSS) resistor r=0.1812 c=0
Rk1 (\5\:C C) resistor r=0.001113 c=0
Rk3 (\5\:C \7\:C) resistor r=0.0315 c=0
Rk2 (\6\:C \7\:C) resistor r=0.001011 c=0
Rk9 (\4\:AN AN) resistor r=0.03051 c=0
Rk18 (\4\:VDD VDD) resistor r=0.2503 c=0
Rk17 (\2\:VDD \4\:VDD) resistor r=0.4258 c=0
Rk6 (\3\:Y Y) resistor r=0.1445 c=0
Rk5 (\2\:Y \3\:Y) resistor r=0.3587 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.03868 c=0
Rk8 (Y \7\:Y) resistor r=0.3946 c=0
Rk4 (B \4\:B) resistor r=0.2604 c=0
Rk10 (\5\:net91 \6\:net91) resistor r=0.2618 c=0
Rk11 (\6\:net91 \7\:net91) resistor r=0.2325 c=0
Rk12 (\6\:net91 \9\:net91) resistor r=0.229 c=0
Rl1 (\1\:C \2\:C) resistor r=91.8973 c=0
Rl3 (\2\:C \4\:C) resistor r=75.5064 c=0
Rl2 (\2\:C \3\:C) resistor r=2.257 c=0
Rl9 (\2\:AN \3\:AN) resistor r=39.8352 c=0
Rl8 (\1\:AN \2\:AN) resistor r=155.966 c=0
Rl5 (\2\:B \3\:B) resistor r=114.56 c=0
Rl4 (\1\:B \2\:B) resistor r=34.6154 c=0
Rl6 (net91 \2\:net91) resistor r=46.1538 c=0
Rl7 (\2\:net91 \3\:net91) resistor r=106.296 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz2 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz3 (\8\:net91 \9\:net91) resistor r=75 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry1 (\6\:Y \7\:Y) resistor r=20.6667 c=0
Ry2 (\4\:net91 \5\:net91) resistor r=62 c=0
Rx1 (\3\:C \6\:C) resistor r=45 c=0
Rx3 (\2\:AN \4\:AN) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\2\:net91 \7\:net91) resistor r=45 c=0
mn3 (\4\:Y \4\:C \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.46635e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\1\:Y \1\:B \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=4.41635e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\1\:Y net91 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2.36635e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn0 (\8\:net91 \1\:AN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mp2 (net90 \3\:B net86 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=4.485e-14 ps=9e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.79167e-07 sd=160n sca=23.6464 \
        scb=0.01977 scc=0.00198868 m=(1)
mp1 (net90 \3\:net91 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=4.485e-14 ps=1.16e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.19167e-07 sd=160n sca=23.2415 \
        scb=0.0189596 scc=0.00198104 m=(1)
mp0 (\4\:net91 \3\:AN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=4.945e-14 ps=1.16e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=2.3e-07 sd=160n sca=34.5374 \
        scb=0.0325399 scc=0.0036632 m=(1)
ends NOR3BX1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:13:09 2012 )
// Library name: gsclib045
// Cell name: NOR3BX2
// View name: extracted

simulator lang=spectre

subckt NOR3BX2 AN B C VDD VSS Y
mp1 (3 net91 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23109e-06 sd=160n sca=24.5401 \
        scb=0.0199717 scc=0.00228059 m=(1)
C1 (AN VSS) capacitor c=6.10093e-17
C2 (B VSS) capacitor c=2.94007e-17
C3 (VDD VSS) capacitor c=1.03569e-16
C4 (Y VSS) capacitor c=8.70998e-17
C5 (C VSS) capacitor c=4.61462e-17
C6 (net91 VSS) capacitor c=7.91569e-17
C7 (6 VSS) capacitor c=8.08846e-18
C8 (\3\:AN VSS) capacitor c=3.66047e-17
C9 (\6\:net91 VSS) capacitor c=9.13061e-17
C10 (\4\:B VSS) capacitor c=7.57032e-17
C11 (\6\:C VSS) capacitor c=1.84566e-17
C12 (\4\:C VSS) capacitor c=5.91673e-17
C13 (\1\:B VSS) capacitor c=9.62908e-17
C14 (\1\:AN VSS) capacitor c=4.11015e-17
C15 (\1\:C VSS) capacitor c=9.54509e-17
C16 (\2\:AN VSS) capacitor c=4.21977e-17
C17 (\3\:C VSS) capacitor c=2.9242e-17
C18 (\2\:B VSS) capacitor c=3.77998e-16
C19 (\2\:net91 VSS) capacitor c=4.92154e-16
C20 (\12\:net91 VSS) capacitor c=6.22783e-17
C21 (\1\:VDD VSS) capacitor c=2.20127e-17
C22 (\7\:Y VSS) capacitor c=1.08079e-16
C23 (\7\:VDD VSS) capacitor c=3.76886e-17
C24 (\3\:VDD VSS) capacitor c=3.48876e-17
C25 (\7\:net91 VSS) capacitor c=1.98016e-17
C26 (\1\:Y VSS) capacitor c=1.92379e-16
C27 (\3\:Y VSS) capacitor c=9.8724e-17
C28 (\7\:C VSS) capacitor c=5.14133e-17
C29 (\4\:AN VSS) capacitor c=4.61739e-17
C30 (\9\:net91 VSS) capacitor c=5.23198e-17
C31 (\5\:VDD VSS) capacitor c=1.26338e-17
Rk8 (\4\:AN AN) resistor r=0.06634 c=0
Rk2 (B \2\:B) resistor r=0.09278 c=0
Rk25 (\2\:VDD \4\:VDD) resistor r=0.4597 c=0
Rk26 (\4\:VDD \5\:VDD) resistor r=0.4032 c=0
Rk28 (\6\:VDD VDD) resistor r=0.04986 c=0
Rk27 (\5\:VDD \6\:VDD) resistor r=0.09753 c=0
Rk29 (\5\:VDD \8\:VDD) resistor r=0.3388 c=0
Rk6 (\1\:Y Y) resistor r=0.6077 c=0
Rk7 (Y \8\:Y) resistor r=0.7132 c=0
Rk20 (\1\:VSS VSS) resistor r=0.06714 c=0
Rk18 (\5\:VSS \1\:VSS) resistor r=0.06904 c=0
Rk1 (C \7\:C) resistor r=0.1267 c=0
Rk10 (\9\:net91 \2\:net91) resistor r=0.2764 c=0
Rk9 (\8\:net91 \9\:net91) resistor r=0.1224 c=0
Rk12 (\9\:net91 \13\:net91) resistor r=0.4315 c=0
Rl15 (\2\:AN \3\:AN) resistor r=75.8439 c=0
Rl14 (\1\:AN \2\:AN) resistor r=101.923 c=0
Rl10 (\2\:B \4\:B) resistor r=75.6918 c=0
Rl3 (\2\:B \1\:B) resistor r=87.2302 c=0
Rl9 (\3\:C \6\:C) resistor r=24.2328 c=0
Rl7 (\3\:C \4\:C) resistor r=124.554 c=0
Rl6 (\1\:C \3\:C) resistor r=60.4528 c=0
Rl1 (\2\:net91 net91) resistor r=110.61 c=0
Rl13 (\2\:net91 \6\:net91) resistor r=103.022 c=0
Rz9 (\3\:VDD \4\:VDD) resistor r=9.375 c=0
Rz10 (\3\:VDD \6\:VDD) resistor r=37.5 c=0
Rz2 (\1\:Y \3\:Y) resistor r=75 c=0
Rz4 (\8\:net91 \7\:net91) resistor r=75 c=0
Ry7 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry8 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry1 (\8\:Y \7\:Y) resistor r=20.6667 c=0
Ry2 (\13\:net91 \12\:net91) resistor r=62 c=0
Rx4 (\2\:AN \4\:AN) resistor r=45 c=0
Rx1 (\7\:C \3\:C) resistor r=45 c=0
mn1 (\1\:Y \2\:net91 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.025e-14 ad=4.16e-14 ps=1.03e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.39279e-06 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(2)
mn2 (\1\:Y \2\:B \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.88e-14 ad=4.16e-14 ps=1.32e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.18779e-06 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(2)
mn3 (\3\:Y \1\:C \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.88e-14 ad=4.16e-14 ps=1.32e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=9.22788e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(2)
mn0 (\7\:net91 \1\:AN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52e-06 sb=1.6e-07 sd=160n sca=7.09016 \
        scb=0.00401586 scc=3.69756e-05 m=(1)
mp2 (3 \1\:B 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=2.34e-14 ps=1.01e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.12609e-06 sd=160n sca=23.5984 scb=0.0187307 \
        scc=0.00227355 m=(1)
mp3 (\7\:Y \4\:C 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=8.19e-14 ps=1.01e-06 pd=1.2e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.05e-07 sb=9.6609e-07 sd=160n sca=22.7967 scb=0.0180682 \
        scc=0.00227241 m=(1)
mp3_1__rcx (\7\:Y \6\:C 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0725e-13 ad=8.19e-14 ps=1.33e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=7.1109e-07 sd=160n sca=22.2743 \
        scb=0.0178838 scc=0.00227235 m=(1)
mp2_1__rcx (6 \4\:B 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=1.0725e-13 ps=9e-07 pd=1.33e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=3.9109e-07 sd=160n sca=23.235 \
        scb=0.0183758 scc=0.00227275 m=(1)
mp1_1__rcx (7 \6\:net91 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.34e-14 ps=1.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.085e-06 sb=2.8609e-07 sd=160n sca=23.9435 \
        scb=0.0191387 scc=0.0022751 m=(1)
mp0 (\12\:net91 \3\:AN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.655e-14 ps=1.16e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32e-06 sb=1.7e-07 sd=160n sca=37.4097 \
        scb=0.0335942 scc=0.00417864 m=(1)
ends NOR3BX2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:13:47 2012 )
// Library name: gsclib045
// Cell name: NOR3BX4
// View name: extracted

simulator lang=spectre

subckt NOR3BX4 AN B C VDD VSS Y
mp1_1__rcx (3 net91 \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=17.8816 scb=0.0162884 \
        scc=0.00103352 m=(1)
C1 (C VSS) capacitor c=5.0636e-16
C2 (AN VSS) capacitor c=4.65231e-17
C3 (Y VSS) capacitor c=2.6559e-17
C4 (B VSS) capacitor c=8.96256e-17
C5 (VDD VSS) capacitor c=1.72497e-16
C6 (net91 VSS) capacitor c=6.24751e-17
C7 (3 VSS) capacitor c=2.46256e-18
C8 (4 VSS) capacitor c=1.02059e-17
C9 (6 VSS) capacitor c=1.08605e-17
C10 (7 VSS) capacitor c=4.61209e-18
C11 (8 VSS) capacitor c=1.21524e-17
C12 (9 VSS) capacitor c=2.46256e-18
C13 (10 VSS) capacitor c=1.01798e-17
C14 (11 VSS) capacitor c=1.69929e-18
C15 (\3\:AN VSS) capacitor c=4.93742e-17
C16 (\12\:net91 VSS) capacitor c=7.10107e-17
C17 (\11\:B VSS) capacitor c=7.81385e-17
C18 (\12\:C VSS) capacitor c=2.17198e-17
C19 (\10\:C VSS) capacitor c=7.80026e-17
C20 (\8\:B VSS) capacitor c=7.80784e-17
C21 (\9\:net91 VSS) capacitor c=2.17072e-17
C22 (\7\:net91 VSS) capacitor c=5.59352e-17
C23 (\5\:B VSS) capacitor c=5.25326e-17
C24 (\1\:C VSS) capacitor c=2.67159e-17
C25 (\5\:C VSS) capacitor c=3.70921e-17
C26 (\4\:B VSS) capacitor c=8.65075e-17
C27 (\1\:AN VSS) capacitor c=3.09904e-17
C28 (\2\:AN VSS) capacitor c=4.7314e-17
C29 (\1\:B VSS) capacitor c=7.50245e-16
C30 (\2\:net91 VSS) capacitor c=8.96123e-16
C31 (\13\:net91 VSS) capacitor c=3.84595e-17
C32 (\1\:VDD VSS) capacitor c=6.24675e-17
C33 (\17\:Y VSS) capacitor c=1.38699e-16
C34 (\6\:VDD VSS) capacitor c=4.40772e-17
C35 (\15\:Y VSS) capacitor c=1.98399e-17
C36 (\10\:VDD VSS) capacitor c=3.77161e-17
C37 (\3\:VDD VSS) capacitor c=6.06452e-17
C38 (\19\:net91 VSS) capacitor c=4.04913e-17
C39 (\1\:Y VSS) capacitor c=4.0185e-16
C40 (\2\:C VSS) capacitor c=1.75607e-17
C41 (\9\:C VSS) capacitor c=2.05816e-17
C42 (\13\:Y VSS) capacitor c=9.81107e-17
C43 (\14\:Y VSS) capacitor c=2.3244e-16
C44 (\4\:AN VSS) capacitor c=7.13117e-17
C45 (\15\:net91 VSS) capacitor c=4.7886e-17
C46 (\5\:VDD VSS) capacitor c=2.80647e-17
C47 (\9\:VDD VSS) capacitor c=1.62718e-17
Rk40 (\1\:VSS VSS) resistor r=0.05965 c=0
Rk17 (AN \4\:AN) resistor r=0.1022 c=0
Rk13 (\13\:Y Y) resistor r=0.1217 c=0
Rk12 (\1\:Y \13\:Y) resistor r=0.1956 c=0
Rk14 (\13\:Y \14\:Y) resistor r=1.0042 c=0
Rk15 (\14\:Y \16\:Y) resistor r=0.04767 c=0
Rk16 (\14\:Y \18\:Y) resistor r=1.0031 c=0
Rk3 (B \1\:B) resistor r=0.01199 c=0
Rk44 (\2\:VDD \4\:VDD) resistor r=0.3818 c=0
Rk45 (\4\:VDD \5\:VDD) resistor r=0.6741 c=0
Rk46 (\5\:VDD \7\:VDD) resistor r=0.2386 c=0
Rk47 (\5\:VDD \8\:VDD) resistor r=0.1778 c=0
Rk50 (\9\:VDD VDD) resistor r=0.1249 c=0
Rk48 (\8\:VDD \9\:VDD) resistor r=0.4259 c=0
Rk49 (\9\:VDD \11\:VDD) resistor r=0.2386 c=0
Rk19 (\15\:net91 \2\:net91) resistor r=0.2116 c=0
Rk18 (\14\:net91 \15\:net91) resistor r=0.1671 c=0
Rk22 (\15\:net91 \20\:net91) resistor r=0.3714 c=0
Rl7 (\2\:C C) resistor r=65.7741 c=0
Rl6 (\2\:C \1\:C) resistor r=35.772 c=0
Rl9 (\2\:C \5\:C) resistor r=100.426 c=0
Rl21 (\9\:C C) resistor r=60.4528 c=0
Rl24 (\9\:C \12\:C) resistor r=44.2087 c=0
Rl22 (\9\:C \10\:C) resistor r=88.4394 c=0
Rl31 (\2\:AN \3\:AN) resistor r=82.1429 c=0
Rl30 (\1\:AN \2\:AN) resistor r=55.6391 c=0
Rl25 (\1\:B \11\:B) resistor r=98.8796 c=0
Rl18 (\1\:B \8\:B) resistor r=75.6918 c=0
Rl11 (\1\:B \5\:B) resistor r=44.9225 c=0
Rl5 (\1\:B \4\:B) resistor r=110.418 c=0
Rl1 (\2\:net91 net91) resistor r=24.2328 c=0
Rl29 (\2\:net91 \12\:net91) resistor r=24.7951 c=0
Rl17 (\2\:net91 \9\:net91) resistor r=24.2328 c=0
Rl15 (\2\:net91 \7\:net91) resistor r=105.323 c=0
Rz15 (\3\:VDD \4\:VDD) resistor r=15 c=0
Rz16 (\3\:VDD \8\:VDD) resistor r=6.25 c=0
Rz7 (\20\:net91 \19\:net91) resistor r=75 c=0
Ry1 (\16\:Y \15\:Y) resistor r=31 c=0
Ry2 (\18\:Y \17\:Y) resistor r=31 c=0
Ry11 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry12 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry13 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry3 (\14\:net91 \13\:net91) resistor r=20.6667 c=0
Rx7 (\2\:AN \4\:AN) resistor r=45 c=0
mn1 (\1\:Y \2\:net91 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=4.16e-14 ps=1.2575e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn2 (\1\:Y \1\:B \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn3 (\1\:Y C \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.54e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=2e-06 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(4)
mn0 (\19\:net91 \1\:AN \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.07e-14 ps=8.4e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.95e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mp2_1__rcx (3 \4\:B 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=2.34e-14 ps=1.22e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=16.866 scb=0.0148899 \
        scc=0.00102429 m=(1)
mp3_1__rcx (\15\:Y \5\:C 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=2e-06 sd=160n sca=15.6796 scb=0.013986 \
        scc=0.00102272 m=(1)
mp3 (\15\:Y \1\:C 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=8.58e-14 \
        ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=7.15e-07 sb=2e-06 sd=160n sca=15.4348 scb=0.0139233 \
        scc=0.00102271 m=(1)
mp2 (6 \5\:B 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=8.58e-14 ps=1.01e-06 pd=1.22e-06 nrd=1.16667 nrs=1.16667 \
        sa=9.8e-07 sb=1.86e-06 sd=160n sca=15.4348 scb=0.0139233 \
        scc=0.00102271 m=(1)
mp1 (7 \7\:net91 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=4.485e-14 ps=1.1e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.14e-06 sb=1.7e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp2_3__rcx (10 \11\:B 11 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=1.482e-13 ps=9e-07 pd=1.54e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.5e-07 sd=160n sca=16.3692 scb=0.0143929 \
        scc=0.00102306 m=(1)
mp1_2__rcx (8 \9\:net91 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=1.0335e-13 ps=1.1e-06 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.345e-06 sb=1.495e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp2_2__rcx (8 \8\:B 9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=1.0335e-13 ps=9e-07 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=1.185e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp3_2__rcx (\17\:Y \10\:C 9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.76e-06 sb=1.08e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp3_3__rcx (\17\:Y \12\:C 10 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.482e-13 ad=6.24e-14 ps=1.54e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.965e-06 sb=8.75e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp1_3__rcx (11 \12\:net91 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=17.0619 scb=0.0151251 \
        scc=0.00102521 m=(1)
mp0 (\13\:net91 \3\:AN \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=20.2316 scb=0.0203333 \
        scc=0.00112395 m=(1)
ends NOR3BX4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:14:24 2012 )
// Library name: gsclib045
// Cell name: NOR3BXL
// View name: extracted

simulator lang=spectre

subckt NOR3BXL AN B C VDD VSS Y
mp3 (\6\:Y \1\:C net86 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.828e-14 ad=3.01e-14 ps=6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.65e-07 sd=160n sca=16.2296 \
        scb=0.0157286 scc=0.000281388 m=(1)
C1 (C VSS) capacitor c=8.08434e-17
C2 (Y VSS) capacitor c=6.59991e-17
C3 (VDD VSS) capacitor c=1.40803e-16
C4 (net91 VSS) capacitor c=3.23825e-17
C5 (\3\:AN VSS) capacitor c=3.7677e-17
C6 (\3\:net91 VSS) capacitor c=7.17614e-17
C7 (\1\:B VSS) capacitor c=4.6286e-17
C8 (\1\:C VSS) capacitor c=6.29474e-17
C9 (\1\:AN VSS) capacitor c=4.69492e-17
C10 (\3\:B VSS) capacitor c=6.62772e-17
C11 (\3\:C VSS) capacitor c=3.74029e-17
C12 (\2\:AN VSS) capacitor c=5.10894e-17
C13 (\2\:net91 VSS) capacitor c=6.10203e-17
C14 (\2\:B VSS) capacitor c=7.54627e-17
C15 (\2\:C VSS) capacitor c=6.23904e-17
C16 (\8\:net91 VSS) capacitor c=5.7299e-17
C17 (\5\:VDD VSS) capacitor c=3.18561e-17
C18 (\6\:Y VSS) capacitor c=5.72708e-17
C19 (\1\:VDD VSS) capacitor c=1.33968e-17
C20 (\4\:net91 VSS) capacitor c=3.44594e-17
C21 (\4\:Y VSS) capacitor c=7.44268e-17
C22 (\1\:Y VSS) capacitor c=2.08412e-17
C23 (\4\:C VSS) capacitor c=4.5274e-17
C24 (\4\:B VSS) capacitor c=9.91405e-17
C25 (\3\:Y VSS) capacitor c=4.54886e-17
C26 (\4\:AN VSS) capacitor c=9.44244e-17
C27 (\6\:net91 VSS) capacitor c=4.84044e-17
C28 (\7\:net91 VSS) capacitor c=4.58397e-17
Rk11 (\2\:VSS \3\:VSS) resistor r=0.1076 c=0
Rk12 (\3\:VSS \4\:VSS) resistor r=0.09256 c=0
Rk13 (\4\:VSS \5\:VSS) resistor r=0.1126 c=0
Rk15 (\6\:VSS VSS) resistor r=0.04989 c=0
Rk14 (\5\:VSS \6\:VSS) resistor r=0.08755 c=0
Rk16 (\3\:VSS \8\:VSS) resistor r=0.19 c=0
Rk17 (\5\:VSS \10\:VSS) resistor r=0.19 c=0
Rk1 (C \4\:C) resistor r=0.09895 c=0
Rk4 (\3\:Y Y) resistor r=0.1536 c=0
Rk3 (\2\:Y \3\:Y) resistor r=0.097 c=0
Rk5 (\3\:Y \5\:Y) resistor r=0.3711 c=0
Rk6 (Y \7\:Y) resistor r=0.5063 c=0
Rk7 (AN \4\:AN) resistor r=0.02603 c=0
Rk18 (\2\:VDD \3\:VDD) resistor r=0.1151 c=0
Rk20 (\4\:VDD VDD) resistor r=0.1502 c=0
Rk19 (\3\:VDD \4\:VDD) resistor r=0.1853 c=0
Rk21 (\3\:VDD \6\:VDD) resistor r=0.2603 c=0
Rk2 (\4\:B B) resistor r=0.01199 c=0
Rk8 (\5\:net91 \6\:net91) resistor r=0.1853 c=0
Rk9 (\6\:net91 \7\:net91) resistor r=0.2586 c=0
Rk10 (\6\:net91 \9\:net91) resistor r=0.5225 c=0
Rl1 (\1\:C \2\:C) resistor r=159.615 c=0
Rl2 (\2\:C \3\:C) resistor r=101.374 c=0
Rl8 (\2\:AN \3\:AN) resistor r=101.156 c=0
Rl7 (\1\:AN \2\:AN) resistor r=155.002 c=0
Rl3 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl4 (\2\:B \3\:B) resistor r=229.538 c=0
Rl5 (net91 \2\:net91) resistor r=45.3288 c=0
Rl6 (\2\:net91 \3\:net91) resistor r=206.867 c=0
Rz4 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz5 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\4\:Y \5\:Y) resistor r=75 c=0
Rz6 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz7 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz3 (\4\:net91 \5\:net91) resistor r=75 c=0
Ry3 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry4 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry5 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry1 (\6\:Y \7\:Y) resistor r=62 c=0
Ry6 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry2 (\8\:net91 \9\:net91) resistor r=62 c=0
Rx1 (\2\:C \4\:C) resistor r=45 c=0
Rx3 (\2\:AN \4\:AN) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\2\:net91 \7\:net91) resistor r=45 c=0
mn3 (\1\:Y \3\:C \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=6.91521 \
        scb=0.00371851 scc=3.09367e-05 m=(1)
mn2 (\4\:Y \3\:B \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.5e-07 sd=160n sca=6.91521 \
        scb=0.00371851 scc=3.09367e-05 m=(1)
mn1 (\4\:Y net91 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.45e-07 sd=160n sca=6.91521 \
        scb=0.00371851 scc=3.09367e-05 m=(1)
mn0 (\4\:net91 \1\:AN \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.4e-07 sd=160n sca=6.91521 \
        scb=0.00371851 scc=3.09367e-05 m=(1)
mp2 (net90 \1\:B net86 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.828e-14 ad=3.118e-14 ps=6e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.7e-07 sb=5.35e-07 sd=160n sca=14.0893 \
        scb=0.0114914 scc=0.000172675 m=(1)
mp1 (net90 \3\:net91 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.118e-14 ps=7.5e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=3.45e-07 sd=160n sca=13.7313 \
        scb=0.0107733 scc=0.000165409 m=(1)
mp0 (\8\:net91 \3\:AN \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=1.4e-07 sd=160n sca=16.8204 \
        scb=0.0168333 scc=0.000331828 m=(1)
ends NOR3BXL
// End of subcircuit definition.

// Generated for: spectre (May  9 16:15:03 2012 )
// Library name: gsclib045
// Cell name: NOR3X1
// View name: extracted

simulator lang=spectre

subckt NOR3X1 A B C VDD VSS Y
mp0 (n1 \1\:A \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.485e-14 ps=1.06e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.15e-07 sd=160n sca=25.2042 \
        scb=0.0229374 scc=0.00191469 m=(1)
C1 (C VSS) capacitor c=6.66338e-17
C2 (B VSS) capacitor c=5.34125e-17
C3 (VDD VSS) capacitor c=4.32517e-17
C4 (A VSS) capacitor c=9.22903e-18
C5 (n1 VSS) capacitor c=3.75124e-18
C6 (n0 VSS) capacitor c=1.21388e-18
C7 (\3\:C VSS) capacitor c=4.21609e-17
C8 (\3\:B VSS) capacitor c=5.87117e-17
C9 (\1\:A VSS) capacitor c=4.86914e-17
C10 (\1\:C VSS) capacitor c=3.96887e-17
C11 (\1\:B VSS) capacitor c=4.57758e-17
C12 (\4\:A VSS) capacitor c=3.35331e-17
C13 (\2\:C VSS) capacitor c=3.88097e-17
C14 (\2\:B VSS) capacitor c=5.44231e-17
C15 (\3\:A VSS) capacitor c=1.33356e-17
C16 (\1\:Y VSS) capacitor c=6.25458e-17
C17 (\4\:VDD VSS) capacitor c=4.63863e-17
C18 (\6\:Y VSS) capacitor c=2.58334e-17
C19 (\4\:Y VSS) capacitor c=1.00897e-16
C20 (\2\:A VSS) capacitor c=2.63708e-17
C21 (\5\:A VSS) capacitor c=7.4211e-17
C22 (\4\:B VSS) capacitor c=3.99772e-17
C23 (\4\:C VSS) capacitor c=6.9258e-17
C24 (\3\:Y VSS) capacitor c=9.33625e-17
C25 (\3\:VDD VSS) capacitor c=2.68352e-17
Rk5 (C \4\:C) resistor r=0.1298 c=0
Rk8 (\3\:Y Y) resistor r=0.09231 c=0
Rk6 (\2\:Y \3\:Y) resistor r=0.3386 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.4415 c=0
Rk9 (Y \7\:Y) resistor r=0.09364 c=0
Rk4 (\4\:B B) resistor r=0.03883 c=0
Rk2 (\4\:B \5\:B) resistor r=0.001025 c=0
Rk15 (\3\:VDD VDD) resistor r=0.08707 c=0
Rk16 (\3\:VDD \5\:VDD) resistor r=0.3472 c=0
Rk1 (A \5\:A) resistor r=0.0202 c=0
Rk10 (\2\:VSS \4\:VSS) resistor r=0.4057 c=0
Rk12 (\5\:VSS VSS) resistor r=0.08707 c=0
Rk11 (\4\:VSS \5\:VSS) resistor r=0.1123 c=0
Rk13 (\5\:VSS \7\:VSS) resistor r=0.2998 c=0
Rl7 (\2\:C \3\:C) resistor r=26.2482 c=0
Rl6 (\1\:C \2\:C) resistor r=77.4844 c=0
Rl5 (\2\:B \3\:B) resistor r=24.7951 c=0
Rl4 (\1\:B \2\:B) resistor r=76.9003 c=0
Rl1 (\1\:A \2\:A) resistor r=64.2642 c=0
Rl3 (\2\:A \4\:A) resistor r=54.6488 c=0
Rl2 (\2\:A \3\:A) resistor r=2.4801 c=0
Rz1 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz2 (\6\:Y \7\:Y) resistor r=37.5 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=37.5 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry3 (\4\:VDD \5\:VDD) resistor r=20.6667 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\2\:B \5\:B) resistor r=45 c=0
Rx1 (\3\:A \5\:A) resistor r=45 c=0
mn0 (\4\:Y \4\:A \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn1 (\4\:Y \1\:B \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn2 (\6\:Y \1\:C \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mp1 (n1 \3\:B n0 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=4.29e-14 \
        ad=4.485e-14 ps=1e-06 pd=1.01e-06 nrd=1.16667 nrs=1.16667 sa=3e-07 \
        sb=3.55e-07 sd=160n sca=24.2915 scb=0.021012 scc=0.00186223 m=(1)
mp2 (\1\:Y \3\:C n0 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=4.29e-14 \
        ad=7.8e-14 ps=1e-06 pd=1.18e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.55e-07 sb=2e-07 sd=160n sca=27.0164 scb=0.0264192 \
        scc=0.00208493 m=(1)
ends NOR3X1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:15:43 2012 )
// Library name: gsclib045
// Cell name: NOR3X2
// View name: extracted

simulator lang=spectre

subckt NOR3X2 A B C VDD VSS Y
mp0 (3 \1\:A \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.8e-07 sd=160n sca=25.9035 \
        scb=0.0222272 scc=0.0023141 m=(1)
C1 (B VSS) capacitor c=3.00448e-17
C2 (C VSS) capacitor c=4.99478e-17
C3 (A VSS) capacitor c=1.30642e-17
C4 (Y VSS) capacitor c=1.02041e-16
C5 (VDD VSS) capacitor c=5.93575e-17
C6 (6 VSS) capacitor c=3.66078e-18
C7 (7 VSS) capacitor c=2.41617e-18
C8 (\7\:A VSS) capacitor c=7.48436e-17
C9 (\4\:B VSS) capacitor c=9.26747e-17
C10 (\1\:C VSS) capacitor c=5.30758e-17
C11 (\5\:C VSS) capacitor c=2.25529e-17
C12 (\1\:B VSS) capacitor c=8.12404e-17
C13 (\1\:A VSS) capacitor c=9.79722e-17
C14 (\2\:C VSS) capacitor c=2.17839e-17
C15 (\2\:B VSS) capacitor c=3.88322e-16
C16 (\6\:VDD VSS) capacitor c=3.1418e-17
C17 (\7\:Y VSS) capacitor c=8.66385e-17
C18 (\1\:VDD VSS) capacitor c=2.55108e-17
C19 (\1\:Y VSS) capacitor c=1.46422e-16
C20 (\3\:Y VSS) capacitor c=9.88056e-17
C21 (\2\:A VSS) capacitor c=4.42809e-16
C22 (\3\:C VSS) capacitor c=1.02542e-16
C23 (\7\:C VSS) capacitor c=5.16595e-17
C24 (\3\:VDD VSS) capacitor c=9.64726e-18
C25 (\5\:VDD VSS) capacitor c=2.53974e-17
Rk2 (B \2\:B) resistor r=0.09157 c=0
Rk12 (VSS \5\:VSS) resistor r=0.06328 c=0
Rk1 (\7\:C C) resistor r=0.1869 c=0
Rk5 (\2\:A A) resistor r=0.02692 c=0
Rk8 (\1\:Y Y) resistor r=0.2446 c=0
Rk9 (Y \8\:Y) resistor r=0.8071 c=0
Rk20 (\3\:VDD VDD) resistor r=0.1022 c=0
Rk19 (\2\:VDD \3\:VDD) resistor r=0.3681 c=0
Rk21 (\3\:VDD \5\:VDD) resistor r=0.2477 c=0
Rk22 (\5\:VDD \7\:VDD) resistor r=0.5432 c=0
Rl11 (\2\:B \4\:B) resistor r=75.6918 c=0
Rl4 (\2\:B \1\:B) resistor r=82.4874 c=0
Rl6 (\2\:C \1\:C) resistor r=53.0601 c=0
Rl9 (\2\:C \5\:C) resistor r=24.2328 c=0
Rl7 (\3\:C \2\:C) resistor r=60.4528 c=0
Rl14 (\2\:A \7\:A) resistor r=95.3867 c=0
Rl1 (\2\:A \1\:A) resistor r=176.203 c=0
Rz2 (\1\:Y \3\:Y) resistor r=75 c=0
Ry1 (\8\:Y \7\:Y) resistor r=62 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry6 (\6\:VDD \7\:VDD) resistor r=62 c=0
Rx1 (\7\:C \2\:C) resistor r=45 c=0
mn0 (\1\:Y \2\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=4.16e-14 ps=1.01e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.315e-06 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(2)
mn1 (\1\:Y \2\:B \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.88e-14 ad=4.16e-14 ps=1.32e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.11e-06 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(2)
mn2 (\3\:Y \3\:C \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.88e-14 ad=4.16e-14 ps=1.32e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=8.45e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(2)
mp1 (3 \1\:B 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=8.58e-14 \
        ad=2.34e-14 ps=1.22e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=8.75e-07 sd=160n sca=24.3732 scb=0.019725 \
        scc=0.00227862 m=(1)
mp2 (\7\:Y \5\:C 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=8.58e-14 \
        ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.1e-07 sb=6.1e-07 sd=160n sca=23.0721 scb=0.0181341 \
        scc=0.00227242 m=(1)
mp2_1__rcx (\7\:Y \1\:C 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.485e-14 ad=6.24e-14 ps=1.01e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=4.05e-07 sd=160n sca=23.4984 \
        scb=0.0186248 scc=0.00227326 m=(1)
mp1_1__rcx (6 \4\:B 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=4.485e-14 ps=9e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=2.45e-07 sd=160n sca=25.0585 \
        scb=0.0207887 scc=0.00228936 m=(1)
mp0_1__rcx (7 \7\:A \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=1.4e-07 sd=160n sca=27.2119 \
        scb=0.0245429 scc=0.0023829 m=(1)
ends NOR3X2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:16:20 2012 )
// Library name: gsclib045
// Cell name: NOR3X4
// View name: extracted

simulator lang=spectre

subckt NOR3X4 A B C VDD VSS Y
mp0_1__rcx (3 \1\:A \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.8735 scb=0.0179349 \
        scc=0.00105762 m=(1)
C1 (A VSS) capacitor c=8.38166e-16
C2 (B VSS) capacitor c=2.0527e-17
C3 (Y VSS) capacitor c=9.27969e-17
C4 (C VSS) capacitor c=1.50772e-16
C5 (VDD VSS) capacitor c=1.72706e-16
C6 (3 VSS) capacitor c=1.33669e-18
C7 (4 VSS) capacitor c=7.31454e-18
C8 (6 VSS) capacitor c=2.46256e-18
C9 (7 VSS) capacitor c=1.08311e-17
C10 (8 VSS) capacitor c=7.47822e-18
C11 (9 VSS) capacitor c=1.08489e-17
C12 (10 VSS) capacitor c=8.65856e-18
C13 (11 VSS) capacitor c=2.46256e-18
C14 (\13\:A VSS) capacitor c=6.38661e-17
C15 (\12\:B VSS) capacitor c=8.52518e-17
C16 (\7\:C VSS) capacitor c=3.9173e-17
C17 (\10\:C VSS) capacitor c=2.68361e-17
C18 (\7\:B VSS) capacitor c=4.92756e-17
C19 (\5\:A VSS) capacitor c=2.7925e-17
C20 (\9\:A VSS) capacitor c=3.19776e-17
C21 (\4\:B VSS) capacitor c=7.30267e-17
C22 (\1\:C VSS) capacitor c=7.96422e-17
C23 (\5\:C VSS) capacitor c=2.32928e-17
C24 (\1\:B VSS) capacitor c=6.95174e-17
C25 (\1\:A VSS) capacitor c=8.47985e-17
C26 (\3\:C VSS) capacitor c=3.57278e-16
C27 (\2\:B VSS) capacitor c=7.9499e-16
C28 (\8\:VDD VSS) capacitor c=3.79975e-17
C29 (\16\:Y VSS) capacitor c=1.98102e-17
C30 (\10\:VDD VSS) capacitor c=4.40492e-17
C31 (\14\:Y VSS) capacitor c=1.42064e-16
C32 (\12\:VDD VSS) capacitor c=3.42397e-17
C33 (\1\:VDD VSS) capacitor c=5.84032e-17
C34 (\1\:Y VSS) capacitor c=3.99081e-16
C35 (\2\:C VSS) capacitor c=2.13945e-17
C36 (\8\:C VSS) capacitor c=2.13412e-17
C37 (\13\:Y VSS) capacitor c=2.28021e-16
C38 (\3\:VDD VSS) capacitor c=1.62864e-19
C39 (\5\:VDD VSS) capacitor c=1.94843e-17
C40 (\7\:VDD VSS) capacitor c=1.18943e-17
Rk3 (B \2\:B) resistor r=0.04292 c=0
Rk16 (\1\:Y Y) resistor r=0.2261 c=0
Rk17 (Y \13\:Y) resistor r=0.9688 c=0
Rk18 (\13\:Y \15\:Y) resistor r=1.0016 c=0
Rk19 (\13\:Y \17\:Y) resistor r=0.04758 c=0
Rk1 (C \3\:C) resistor r=0.004022 c=0
Rk37 (\2\:VDD \3\:VDD) resistor r=0.09754 c=0
Rk38 (\3\:VDD \4\:VDD) resistor r=0.05243 c=0
Rk39 (\4\:VDD \5\:VDD) resistor r=0.5562 c=0
Rk40 (\5\:VDD \6\:VDD) resistor r=0.1452 c=0
Rk42 (\7\:VDD VDD) resistor r=0.1073 c=0
Rk41 (\6\:VDD \7\:VDD) resistor r=0.4434 c=0
Rk43 (\3\:VDD \9\:VDD) resistor r=0.2383 c=0
Rk44 (\5\:VDD \11\:VDD) resistor r=0.2383 c=0
Rk45 (\7\:VDD \13\:VDD) resistor r=0.2911 c=0
Rl28 (A \13\:A) resistor r=24.2328 c=0
Rl13 (A \5\:A) resistor r=24.2328 c=0
Rl16 (A \9\:A) resistor r=75.2759 c=0
Rl1 (A \1\:A) resistor r=109.125 c=0
Rl26 (\2\:B \12\:B) resistor r=80.5643 c=0
Rl18 (\2\:B \7\:B) resistor r=75.6918 c=0
Rl11 (\2\:B \4\:B) resistor r=44.9225 c=0
Rl4 (\2\:B \1\:B) resistor r=45.9489 c=0
Rl6 (\2\:C \1\:C) resistor r=88.4394 c=0
Rl9 (\2\:C \5\:C) resistor r=44.2087 c=0
Rl7 (\2\:C \3\:C) resistor r=68.1451 c=0
Rl20 (\8\:C \7\:C) resistor r=100.426 c=0
Rl22 (\8\:C \10\:C) resistor r=35.772 c=0
Rl21 (\8\:C \3\:C) resistor r=83.0817 c=0
Rz14 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz15 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Rz16 (\1\:VDD \6\:VDD) resistor r=6.25 c=0
Ry1 (\15\:Y \14\:Y) resistor r=31 c=0
Ry2 (\17\:Y \16\:Y) resistor r=31 c=0
Ry9 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry10 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry11 (\12\:VDD \13\:VDD) resistor r=31 c=0
mn0 (\1\:Y A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=6.585e-14 \
        ad=4.16e-14 ps=1.18e-06 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2e-06 sd=160n sca=8.97712 scb=0.00732387 \
        scc=0.000196032 m=(4)
mn1 (\1\:Y \2\:B VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=8e-14 \
        ad=4.16e-14 ps=1.34e-06 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=2e-06 sd=160n sca=8.97712 scb=0.00732387 \
        scc=0.000196032 m=(4)
mn2 (\1\:Y \3\:C VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=8e-14 \
        ad=4.16e-14 ps=1.34e-06 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.1e-07 sb=2e-06 sd=160n sca=8.97712 scb=0.00732387 \
        scc=0.000196032 m=(4)
mp1_1__rcx (3 \1\:B 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0725e-13 ad=2.34e-14 ps=1.33e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=17.4295 scb=0.0156155 \
        scc=0.00102793 m=(1)
mp2_1__rcx (\14\:Y \5\:C 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0725e-13 ad=6.24e-14 ps=1.33e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.93e-06 sd=160n sca=15.7064 \
        scb=0.0139953 scc=0.00102272 m=(1)
mp2 (\14\:Y \1\:C 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 sa=7.7e-07 \
        sb=1.725e-06 sd=160n sca=15.4348 scb=0.0139233 scc=0.00102271 \
        m=(1)
mp1 (6 \4\:B 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=8.58e-14 \
        ad=2.34e-14 ps=1.22e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.75e-07 sb=1.62e-06 sd=160n sca=15.4348 scb=0.0139233 \
        scc=0.00102271 m=(1)
mp0 (7 \9\:A \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=8.58e-14 ps=1.1e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.14e-06 sb=1.355e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp0_2__rcx (8 \5\:A \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.345e-06 sb=1.15e-06 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp1_2__rcx (8 \7\:B 9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-06 sb=9.45e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp2_2__rcx (\16\:Y \10\:C 9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.58e-14 ad=6.24e-14 ps=1.22e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.815e-06 sb=6.8e-07 sd=160n sca=15.5468 \
        scb=0.0139471 scc=0.00102271 m=(1)
mp2_3__rcx (\16\:Y \7\:C 10 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.215e-14 ad=6.24e-14 ps=1.15e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.75e-07 sd=160n sca=16.1994 scb=0.0142604 \
        scc=0.00102289 m=(1)
mp1_3__rcx (10 \12\:B 11 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.215e-14 ps=9e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=18.0108 scb=0.016492 \
        scc=0.00103567 m=(1)
mp0_3__rcx (11 \13\:A \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=19.9649 scb=0.0198601 \
        scc=0.0011076 m=(1)
ends NOR3X4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:16:59 2012 )
// Library name: gsclib045
// Cell name: NOR3X6
// View name: extracted

simulator lang=spectre

subckt NOR3X6 A B C VDD VSS Y
mp0_1__rcx (3 \1\:A \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.7415 scb=0.0157405 \
        scc=0.000674193 m=(1)
C1 (C VSS) capacitor c=8.80744e-16
C2 (A VSS) capacitor c=1.92399e-17
C3 (Y VSS) capacitor c=1.16695e-16
C4 (B VSS) capacitor c=6.33539e-17
C5 (VDD VSS) capacitor c=2.28059e-16
C6 (3 VSS) capacitor c=1.56659e-18
C7 (4 VSS) capacitor c=1.13351e-17
C8 (6 VSS) capacitor c=2.44041e-18
C9 (7 VSS) capacitor c=7.40695e-18
C10 (8 VSS) capacitor c=9.64221e-18
C11 (9 VSS) capacitor c=1.73744e-17
C12 (10 VSS) capacitor c=2.44041e-18
C13 (11 VSS) capacitor c=8.76735e-18
C14 (12 VSS) capacitor c=7.87897e-18
C15 (13 VSS) capacitor c=2.44041e-18
C16 (14 VSS) capacitor c=2.37923e-18
C17 (15 VSS) capacitor c=3.57883e-18
C18 (\16\:A VSS) capacitor c=5.13473e-17
C19 (\16\:B VSS) capacitor c=1.00886e-16
C20 (\15\:C VSS) capacitor c=5.87776e-17
C21 (\17\:C VSS) capacitor c=7.59416e-17
C22 (\13\:B VSS) capacitor c=7.60871e-17
C23 (\14\:A VSS) capacitor c=2.74237e-17
C24 (\15\:A VSS) capacitor c=2.29894e-17
C25 (\10\:B VSS) capacitor c=8.13084e-17
C26 (\8\:C VSS) capacitor c=7.93003e-17
C27 (\14\:C VSS) capacitor c=2.74829e-17
C28 (\7\:B VSS) capacitor c=3.63712e-17
C29 (\8\:A VSS) capacitor c=2.33104e-17
C30 (\9\:A VSS) capacitor c=2.79499e-17
C31 (\4\:B VSS) capacitor c=7.7862e-17
C32 (\1\:C VSS) capacitor c=7.27986e-17
C33 (\7\:C VSS) capacitor c=2.72668e-17
C34 (\1\:B VSS) capacitor c=6.85202e-17
C35 (\1\:A VSS) capacitor c=6.11116e-17
C36 (\17\:A VSS) capacitor c=4.05361e-17
C37 (\17\:B VSS) capacitor c=6.31524e-17
C38 (\2\:B VSS) capacitor c=1.20552e-15
C39 (\2\:A VSS) capacitor c=1.0804e-15
C40 (\10\:VDD VSS) capacitor c=3.29759e-17
C41 (\9\:Y VSS) capacitor c=1.54527e-16
C42 (\12\:VDD VSS) capacitor c=3.62304e-17
C43 (\11\:Y VSS) capacitor c=2.17469e-16
C44 (\14\:VDD VSS) capacitor c=3.88847e-17
C45 (\13\:Y VSS) capacitor c=1.5295e-16
C46 (\16\:VDD VSS) capacitor c=3.32558e-17
C47 (\1\:VDD VSS) capacitor c=1.03833e-16
C48 (\1\:Y VSS) capacitor c=6.30593e-16
C49 (\16\:C VSS) capacitor c=3.26207e-17
C50 (\18\:B VSS) capacitor c=2.61864e-17
C51 (\20\:A VSS) capacitor c=1.57627e-16
C52 (\3\:VDD VSS) capacitor c=1.30791e-18
C53 (\5\:VDD VSS) capacitor c=1.73539e-18
C54 (\7\:VDD VSS) capacitor c=2.17552e-17
C55 (\9\:VDD VSS) capacitor c=1.5227e-17
Rk15 (\2\:A A) resistor r=0.03773 c=0
Rk11 (\2\:A \20\:A) resistor r=0.9952 c=0
Rk53 (\1\:VSS VSS) resistor r=0.06469 c=0
Rk19 (\1\:Y Y) resistor r=0.6777 c=0
Rk20 (Y \10\:Y) resistor r=0.464 c=0
Rk21 (\10\:Y \12\:Y) resistor r=0.8066 c=0
Rk22 (\12\:Y \14\:Y) resistor r=1.0442 c=0
Rk5 (B \2\:B) resistor r=0.2915 c=0
Rk4 (\18\:B B) resistor r=0.08133 c=0
Rk27 (\2\:VDD \3\:VDD) resistor r=0.05999 c=0
Rk28 (\3\:VDD \4\:VDD) resistor r=0.2406 c=0
Rk29 (\4\:VDD \5\:VDD) resistor r=0.2456 c=0
Rk30 (\5\:VDD \6\:VDD) resistor r=0.1553 c=0
Rk31 (\6\:VDD \7\:VDD) resistor r=0.5766 c=0
Rk32 (\7\:VDD \8\:VDD) resistor r=0.1754 c=0
Rk34 (\9\:VDD VDD) resistor r=0.1149 c=0
Rk33 (\8\:VDD \9\:VDD) resistor r=0.4362 c=0
Rk35 (\3\:VDD \11\:VDD) resistor r=0.2196 c=0
Rk36 (\5\:VDD \13\:VDD) resistor r=0.2196 c=0
Rk37 (\7\:VDD \15\:VDD) resistor r=0.2196 c=0
Rk38 (\9\:VDD \17\:VDD) resistor r=0.2677 c=0
Rl20 (C \8\:C) resistor r=159.593 c=0
Rl25 (C \14\:C) resistor r=101.605 c=0
Rl5 (C \1\:C) resistor r=119.762 c=0
Rl10 (C \7\:C) resistor r=103.431 c=0
Rl37 (C \16\:C) resistor r=70.5495 c=0
Rl35 (\16\:C \15\:C) resistor r=44.2087 c=0
Rl36 (\16\:C \17\:C) resistor r=88.4394 c=0
Rl41 (\17\:A \16\:A) resistor r=62.2302 c=0
Rl31 (\2\:A \14\:A) resistor r=49.5589 c=0
Rl32 (\2\:A \15\:A) resistor r=24.2328 c=0
Rl16 (\2\:A \8\:A) resistor r=24.2328 c=0
Rl17 (\2\:A \9\:A) resistor r=47.3105 c=0
Rl1 (\2\:A \1\:A) resistor r=44.208 c=0
Rl40 (\17\:B \16\:B) resistor r=74.2328 c=0
Rl33 (\2\:B \13\:B) resistor r=44.9225 c=0
Rl26 (\2\:B \10\:B) resistor r=75.6918 c=0
Rl18 (\2\:B \7\:B) resistor r=53.0211 c=0
Rl11 (\2\:B \4\:B) resistor r=44.9225 c=0
Rl3 (\2\:B \1\:B) resistor r=44.9225 c=0
Rz9 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz10 (\1\:VDD \4\:VDD) resistor r=15 c=0
Rz11 (\1\:VDD \6\:VDD) resistor r=25 c=0
Rz12 (\1\:VDD \8\:VDD) resistor r=6.25 c=0
Ry1 (\10\:Y \9\:Y) resistor r=62 c=0
Ry2 (\12\:Y \11\:Y) resistor r=62 c=0
Ry3 (\14\:Y \13\:Y) resistor r=62 c=0
Ry4 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry5 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry6 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry7 (\16\:VDD \17\:VDD) resistor r=31 c=0
Rx11 (\20\:A \17\:A) resistor r=45 c=0
Rx4 (\18\:B \17\:B) resistor r=45 c=0
mn0_1__rcx (\1\:Y \2\:A \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.388e-14 ad=4.96e-14 ps=1.372e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.5366 scb=0.0108681 \
        scc=0.000577396 m=(5)
mn1_1__rcx (\1\:Y \2\:B \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.4e-14 ad=4.96e-14 ps=1.49e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=11.5366 scb=0.0108681 \
        scc=0.000577396 m=(5)
mn2 (\1\:Y C \1\:VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 as=9.4e-14 \
        ad=4.836e-14 ps=1.49e-06 pd=9.32e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.1e-07 sb=2e-06 sd=160n sca=11.5366 scb=0.0108681 \
        scc=0.000577396 m=(5)
mp1_1__rcx (3 \1\:B 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.482e-13 ad=2.34e-14 ps=1.54e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=15.4152 scb=0.0136728 \
        scc=0.00065148 m=(1)
mp2_1__rcx (\13\:Y \7\:C 4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.482e-13 ad=6.24e-14 ps=1.54e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp2 (\13\:Y \1\:C 6 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=8.75e-07 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp2_5__rcx (\9\:Y \15\:C 14 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.8e-07 sd=160n sca=15.4628 scb=0.0137376 \
        scc=0.00065186 m=(1)
mp1 (6 \4\:B 7 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 sa=9.8e-07 \
        sb=2e-06 sd=160n sca=13.5671 scb=0.012183 scc=0.000647513 m=(1)
mp1_5__rcx (14 \16\:B 15 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.51e-14 ad=2.34e-14 ps=9.6e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.75e-07 sd=160n sca=16.8269 scb=0.0158863 \
        scc=0.000676698 m=(1)
mp0 (7 \9\:A \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0_2__rcx (8 \8\:A \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=8.58e-14 ps=1.1e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1_2__rcx (8 \7\:B 9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.482e-13 ad=8.58e-14 ps=1.54e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=2e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp2_2__rcx (\11\:Y \14\:C 9 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.482e-13 ad=6.24e-14 ps=1.54e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.675e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp2_3__rcx (\11\:Y \8\:C 10 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.47e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1_3__rcx (10 \10\:B 11 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.19e-14 ad=2.34e-14 ps=1.2e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.365e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0_3__rcx (11 \15\:A \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=8.19e-14 ps=1.1e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.11e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp0_4__rcx (12 \14\:A \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.63e-14 ps=1.1e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.05e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(1)
mp1_4__rcx (12 \13\:B 13 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.63e-14 ps=9e-07 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.9e-07 sd=160n sca=13.8386 scb=0.012255 \
        scc=0.000647525 m=(1)
mp2_4__rcx (\9\:Y \17\:C 13 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.85e-07 sd=160n sca=14.1837 scb=0.0124217 \
        scc=0.000647608 m=(1)
mp0_5__rcx (15 \16\:A \10\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=3.51e-14 ps=1.06e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=20.691 scb=0.0225653 \
        scc=0.00096071 m=(1)
ends NOR3X6
// End of subcircuit definition.

// Generated for: spectre (May  9 16:17:37 2012 )
// Library name: gsclib045
// Cell name: NOR3X8
// View name: extracted

simulator lang=spectre

subckt NOR3X8 A B C VDD VSS Y
mp0_1__rcx (3 \1\:A \15\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.23e-14 ad=2.67e-14 ps=1.17e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=31.7728 scb=0.0232209 \
        scc=0.00300084 m=(1)
mp0_3__rcx (8 \9\:A \13\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=9.79e-14 ps=1.21e-06 pd=1.33e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp1_4__rcx (10 \10\:B 11 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=9.79e-14 ps=1.21e-06 pd=1.33e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp2_5__rcx (\26\:Y \13\:C 14 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=5.118e-14 ad=7.12e-14 ps=1.12e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.08e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
C1 (C VSS) capacitor c=1.41003e-15
C2 (B VSS) capacitor c=1.46895e-15
C3 (A VSS) capacitor c=2.0627e-17
C4 (Y VSS) capacitor c=1.42477e-17
C5 (VDD VSS) capacitor c=1.54784e-16
C6 (4 VSS) capacitor c=1.49146e-17
C7 (6 VSS) capacitor c=2.8629e-18
C8 (7 VSS) capacitor c=9.03041e-18
C9 (8 VSS) capacitor c=1.16064e-17
C10 (9 VSS) capacitor c=1.28502e-17
C11 (10 VSS) capacitor c=1.28435e-17
C12 (11 VSS) capacitor c=9.08614e-18
C13 (12 VSS) capacitor c=9.62154e-18
C14 (13 VSS) capacitor c=2.15567e-17
C15 (14 VSS) capacitor c=5.56191e-18
C16 (15 VSS) capacitor c=7.93447e-18
C17 (16 VSS) capacitor c=6.50893e-18
C18 (17 VSS) capacitor c=2.79218e-18
C19 (\21\:C VSS) capacitor c=8.02848e-17
C20 (\19\:B VSS) capacitor c=8.84573e-17
C21 (\22\:A VSS) capacitor c=3.34019e-17
C22 (\24\:A VSS) capacitor c=2.56888e-17
C23 (\16\:B VSS) capacitor c=6.58951e-17
C24 (\13\:C VSS) capacitor c=4.94577e-17
C25 (\18\:C VSS) capacitor c=2.62633e-17
C26 (\15\:B VSS) capacitor c=4.62645e-17
C27 (\15\:A VSS) capacitor c=3.4337e-17
C28 (\17\:A VSS) capacitor c=2.63475e-17
C29 (\10\:B VSS) capacitor c=5.21499e-17
C30 (\7\:C VSS) capacitor c=3.23208e-17
C31 (\12\:C VSS) capacitor c=3.20826e-17
C32 (\7\:B VSS) capacitor c=4.68931e-17
C33 (\9\:A VSS) capacitor c=2.36654e-17
C34 (\10\:A VSS) capacitor c=3.4101e-17
C35 (\4\:B VSS) capacitor c=9.18692e-17
C36 (\1\:C VSS) capacitor c=7.64449e-17
C37 (\6\:C VSS) capacitor c=2.65388e-17
C38 (\1\:B VSS) capacitor c=7.70808e-17
C39 (\1\:A VSS) capacitor c=6.39587e-17
C40 (\2\:A VSS) capacitor c=1.3151e-15
C41 (\2\:Y VSS) capacitor c=7.4824e-17
C42 (\9\:VDD VSS) capacitor c=4.03375e-17
C43 (\26\:Y VSS) capacitor c=2.21429e-16
C44 (\11\:VDD VSS) capacitor c=4.05958e-17
C45 (\28\:Y VSS) capacitor c=2.43635e-16
C46 (\13\:VDD VSS) capacitor c=4.32899e-17
C47 (\30\:Y VSS) capacitor c=1.37133e-16
C48 (\15\:VDD VSS) capacitor c=3.44741e-17
C49 (\1\:VDD VSS) capacitor c=7.60035e-17
C50 (\4\:Y VSS) capacitor c=9.94509e-16
C51 (\1\:Y VSS) capacitor c=4.88806e-17
C52 (\3\:VDD VSS) capacitor c=1.47096e-17
C53 (\5\:VDD VSS) capacitor c=2.77813e-17
C54 (\6\:VDD VSS) capacitor c=2.42884e-17
C55 (\8\:VDD VSS) capacitor c=1.15052e-17
Rk48 (\1\:VSS VSS) resistor r=0.04717 c=0
Rk3 (\2\:A A) resistor r=0.01663 c=0
Rk20 (Y \1\:Y) resistor r=0.0235 c=0
Rk22 (\1\:Y \4\:Y) resistor r=0.4843 c=0
Rk21 (\1\:Y \3\:Y) resistor r=0.07709 c=0
Rk33 (\3\:Y \27\:Y) resistor r=0.8154 c=0
Rk34 (\27\:Y \29\:Y) resistor r=1.1238 c=0
Rk35 (\29\:Y \31\:Y) resistor r=0.9267 c=0
Rk60 (\2\:VDD \3\:VDD) resistor r=0.2205 c=0
Rk61 (\3\:VDD \4\:VDD) resistor r=0.4814 c=0
Rk62 (\4\:VDD \5\:VDD) resistor r=0.2381 c=0
Rk63 (\5\:VDD \6\:VDD) resistor r=0.7069 c=0
Rk64 (\6\:VDD \7\:VDD) resistor r=0.1578 c=0
Rk66 (\8\:VDD VDD) resistor r=0.09737 c=0
Rk65 (\7\:VDD \8\:VDD) resistor r=0.4538 c=0
Rk67 (\3\:VDD \10\:VDD) resistor r=0.2601 c=0
Rk68 (\5\:VDD \12\:VDD) resistor r=0.2601 c=0
Rk69 (\6\:VDD \14\:VDD) resistor r=0.2601 c=0
Rk70 (\8\:VDD \16\:VDD) resistor r=0.2648 c=0
Rk71 (\16\:VDD \17\:VDD) resistor r=0.1539 c=0
Rl51 (C \21\:C) resistor r=83.0212 c=0
Rl35 (C \13\:C) resistor r=122.34 c=0
Rl39 (C \18\:C) resistor r=85.7463 c=0
Rl20 (C \7\:C) resistor r=85.7713 c=0
Rl24 (C \12\:C) resistor r=87.6951 c=0
Rl5 (C \1\:C) resistor r=110.155 c=0
Rl9 (C \6\:C) resistor r=84.1998 c=0
Rl48 (B \19\:B) resistor r=81.461 c=0
Rl40 (B \16\:B) resistor r=83.3841 c=0
Rl34 (B \15\:B) resistor r=83.7912 c=0
Rl25 (B \10\:B) resistor r=83.3841 c=0
Rl18 (B \7\:B) resistor r=75.6918 c=0
Rl10 (B \4\:B) resistor r=83.3841 c=0
Rl3 (B \1\:B) resistor r=62.2302 c=0
Rl45 (\2\:A \22\:A) resistor r=93.9123 c=0
Rl47 (\2\:A \24\:A) resistor r=24.2328 c=0
Rl30 (\2\:A \15\:A) resistor r=93.9123 c=0
Rl32 (\2\:A \17\:A) resistor r=24.848 c=0
Rl16 (\2\:A \9\:A) resistor r=24.2328 c=0
Rl17 (\2\:A \10\:A) resistor r=99.2335 c=0
Rl1 (\2\:A \1\:A) resistor r=30.5087 c=0
Rz23 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Rz24 (\1\:VDD \4\:VDD) resistor r=7.5 c=0
Rz25 (\1\:VDD \7\:VDD) resistor r=6.25 c=0
Ry1 (\3\:Y \2\:Y) resistor r=20.6667 c=0
Ry2 (\27\:Y \26\:Y) resistor r=62 c=0
Ry3 (\29\:Y \28\:Y) resistor r=62 c=0
Ry4 (\31\:Y \30\:Y) resistor r=62 c=0
Ry9 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry10 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry11 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry12 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry13 (\15\:VDD \17\:VDD) resistor r=62 c=0
mn0_1__rcx (\4\:Y \2\:A \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 \
        nf=1 as=7.85e-14 ad=4.72e-14 ps=1.29e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=8.89726 scb=0.00719534 \
        scc=0.00020576 m=(7)
mn1_1__rcx (\4\:Y B \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=8.47e-14 ad=4.72e-14 ps=1.36e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=8.89726 \
        scb=0.00719534 scc=0.00020576 m=(7)
mn2_1__rcx (\4\:Y C \1\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=8.47e-14 ad=4.636e-14 ps=1.36e-06 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=2e-06 sd=160n sca=8.89726 scb=0.00719534 \
        scc=0.00020576 m=(7)
mp1_1__rcx (3 \1\:B 4 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=1.691e-13 ad=2.67e-14 ps=1.65e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2e-06 sd=160n sca=30.1491 scb=0.0205231 \
        scc=0.00295848 m=(1)
mp2_1__rcx (\30\:Y \6\:C 4 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=1.691e-13 ad=7.12e-14 ps=1.65e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=2e-06 sd=160n sca=28.0095 scb=0.0185345 \
        scc=0.00295096 m=(1)
mp2_2__rcx (\30\:Y \1\:C 6 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=7.12e-14 ps=1.01e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp1_2__rcx (6 \4\:B 7 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.67e-14 ps=1.21e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp0_2__rcx (7 \10\:A \13\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=7.12e-14 ps=1.21e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=2e-06 sd=160n sca=27.9404 \
        scb=0.0185207 scc=0.00295096 m=(1)
mp1_3__rcx (8 \7\:B 9 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=9.79e-14 ad=9.79e-14 ps=1.33e-06 pd=1.33e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=2e-06 sd=160n sca=27.9404 \
        scb=0.0185207 scc=0.00295096 m=(1)
mp2_3__rcx (\28\:Y \12\:C 9 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=9.79e-14 ad=7.12e-14 ps=1.33e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.92e-06 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp2_4__rcx (\28\:Y \7\:C 10 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=9.79e-14 ad=7.12e-14 ps=1.33e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp0_4__rcx (11 \17\:A \11\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=7.12e-14 ps=1.21e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp0 (12 \15\:A \11\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=7.342e-14 ps=1.21e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.92e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp1 (12 \15\:B 13 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 as=1.691e-13 \
        ad=7.343e-14 ps=1.65e-06 pd=1.22e-06 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=1.71e-06 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp2 (\26\:Y \18\:C 13 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=1.691e-13 ad=7.12e-14 ps=1.65e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.285e-06 sd=160n sca=27.9404 \
        scb=0.0185207 scc=0.00295096 m=(1)
mp1_5__rcx (14 \16\:B 15 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=8.232e-14 ad=5.118e-14 ps=1.26e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.2e-07 sd=160n sca=27.9404 scb=0.0185207 \
        scc=0.00295096 m=(1)
mp0_5__rcx (15 \24\:A \9\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=8.232e-14 ps=1.21e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.9e-07 sd=160n sca=28.0414 scb=0.0185419 \
        scc=0.00295096 m=(1)
mp0_6__rcx (16 \22\:A \9\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=8.677e-14 ps=1.21e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.85e-07 sd=160n sca=28.6826 scb=0.0188419 \
        scc=0.00295113 m=(1)
mp1_6__rcx (16 \19\:B 17 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=8.677e-14 ps=1.01e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.45e-07 sd=160n sca=30.5839 scb=0.0211973 \
        scc=0.00296515 m=(1)
mp2_6__rcx (\2\:Y \21\:C 17 VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=6.23e-14 ps=1.01e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=32.6015 scb=0.02469 \
        scc=0.00304367 m=(1)
ends NOR3X8
// End of subcircuit definition.

// Generated for: spectre (May  9 16:18:14 2012 )
// Library name: gsclib045
// Cell name: NOR3XL
// View name: extracted

simulator lang=spectre

subckt NOR3XL A B C VDD VSS Y
mp0 (n1 \1\:A \4\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=2.688e-14 ps=7.1e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.4e-07 sd=160n sca=17.0184 \
        scb=0.0161278 scc=0.000306233 m=(1)
C1 (C VSS) capacitor c=6.74119e-17
C2 (B VSS) capacitor c=9.02065e-17
C3 (A VSS) capacitor c=3.43749e-17
C4 (Y VSS) capacitor c=3.21459e-18
C5 (VDD VSS) capacitor c=9.26048e-17
C6 (n1 VSS) capacitor c=5.17527e-18
C7 (n0 VSS) capacitor c=1.68211e-19
C8 (\3\:C VSS) capacitor c=3.63796e-17
C9 (\1\:B VSS) capacitor c=4.10975e-17
C10 (\1\:A VSS) capacitor c=2.70154e-17
C11 (\1\:C VSS) capacitor c=3.57415e-17
C12 (\3\:B VSS) capacitor c=4.68114e-17
C13 (\3\:A VSS) capacitor c=4.13168e-17
C14 (\2\:C VSS) capacitor c=3.98739e-17
C15 (\2\:B VSS) capacitor c=5.46664e-17
C16 (\2\:A VSS) capacitor c=4.27101e-17
C17 (\4\:Y VSS) capacitor c=6.07273e-17
C18 (\4\:VDD VSS) capacitor c=3.8904e-17
C19 (\6\:Y VSS) capacitor c=1.5223e-17
C20 (\1\:Y VSS) capacitor c=4.41019e-17
C21 (\4\:A VSS) capacitor c=4.62947e-17
C22 (\4\:B VSS) capacitor c=2.9245e-17
C23 (\4\:C VSS) capacitor c=5.91192e-17
C24 (\3\:Y VSS) capacitor c=5.7772e-17
C25 (\3\:VDD VSS) capacitor c=3.4733e-17
Rk5 (C \4\:C) resistor r=0.1866 c=0
Rk10 (\2\:VSS \3\:VSS) resistor r=0.07981 c=0
Rk11 (\3\:VSS \4\:VSS) resistor r=0.06981 c=0
Rk14 (\5\:VSS VSS) resistor r=0.1004 c=0
Rk12 (\4\:VSS \5\:VSS) resistor r=0.1 c=0
Rk13 (\3\:VSS \7\:VSS) resistor r=0.3399 c=0
Rk16 (\5\:VSS \10\:VSS) resistor r=0.1189 c=0
Rk4 (\4\:B B) resistor r=0.0239 c=0
Rk1 (\4\:A A) resistor r=0.08564 c=0
Rk8 (\3\:Y Y) resistor r=0.04375 c=0
Rk6 (\2\:Y \3\:Y) resistor r=0.4284 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.3569 c=0
Rk9 (Y \7\:Y) resistor r=0.05974 c=0
Rk18 (\3\:VDD VDD) resistor r=0.08206 c=0
Rk19 (\3\:VDD \5\:VDD) resistor r=0.282 c=0
Rl6 (\2\:C \3\:C) resistor r=62.6374 c=0
Rl5 (\1\:C \2\:C) resistor r=101.923 c=0
Rl3 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl4 (\2\:B \3\:B) resistor r=133.384 c=0
Rl1 (\1\:A \2\:A) resistor r=24.2328 c=0
Rl2 (\2\:A \3\:A) resistor r=135.771 c=0
Rz3 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz4 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\6\:Y \7\:Y) resistor r=75 c=0
Ry5 (\1\:VSS VSS) resistor r=62 c=0
Ry2 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry3 (\1\:VSS \4\:VSS) resistor r=62 c=0
Ry4 (\1\:VSS \5\:VSS) resistor r=62 c=0
Ry1 (\4\:Y \5\:Y) resistor r=62 c=0
Ry6 (\4\:VDD \5\:VDD) resistor r=62 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
mn0 (\1\:Y \3\:A \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=2.32e-14 ps=1.43e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=5.95e-07 sd=160n sca=17.8702 scb=0.0189183 \
        scc=0.00156031 m=(1)
mn1 (\1\:Y \3\:B \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=3.9e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn2 (\6\:Y \1\:C \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.682e-14 ps=6.1e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.85e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mp1 (n1 \1\:B n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=2.258e-14 \
        ad=2.688e-14 ps=6.4e-07 pd=6.8e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.1e-07 sb=3.7e-07 sd=160n sca=15.9187 scb=0.0138219 \
        scc=0.000240159 m=(1)
mp2 (\4\:Y \3\:C n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.258e-14 ad=4.73e-14 ps=6.4e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=2.2e-07 sd=160n sca=18.4685 \
        scb=0.0189127 scc=0.000442866 m=(1)
ends NOR3XL
// End of subcircuit definition.

// Generated for: spectre (May  9 16:18:52 2012 )
// Library name: gsclib045
// Cell name: NOR4BBX1
// View name: extracted

simulator lang=spectre

subckt NOR4BBX1 AN BN C D VDD VSS Y
mp1 (\8\:n1 \1\:BN \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.01e-14 ps=1.35e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=65.2419 scb=0.0523585 \
        scc=0.00853102 m=(1)
C1 (BN VSS) capacitor c=4.29664e-17
C2 (Y VSS) capacitor c=1.21658e-16
C3 (C VSS) capacitor c=3.53408e-17
C4 (VDD VSS) capacitor c=9.95876e-17
C5 (D VSS) capacitor c=5.10959e-17
C6 (n1 VSS) capacitor c=3.9525e-17
C7 (n0 VSS) capacitor c=4.05139e-17
C8 (n2 VSS) capacitor c=2.13646e-18
C9 (n3 VSS) capacitor c=4.776e-18
C10 (n4 VSS) capacitor c=8.88383e-18
C11 (\1\:AN VSS) capacitor c=3.60897e-17
C12 (\3\:n0 VSS) capacitor c=5.44406e-17
C13 (\3\:n1 VSS) capacitor c=6.29052e-17
C14 (\3\:C VSS) capacitor c=8.95952e-17
C15 (\1\:D VSS) capacitor c=7.61475e-17
C16 (\1\:BN VSS) capacitor c=2.31462e-17
C17 (\3\:AN VSS) capacitor c=4.40831e-17
C18 (\1\:C VSS) capacitor c=5.15938e-17
C19 (\3\:D VSS) capacitor c=4.19306e-17
C20 (\4\:BN VSS) capacitor c=2.51592e-17
C21 (\2\:AN VSS) capacitor c=3.66812e-17
C22 (\2\:n0 VSS) capacitor c=4.90728e-17
C23 (\2\:n1 VSS) capacitor c=6.25841e-17
C24 (\2\:C VSS) capacitor c=7.42354e-17
C25 (\2\:D VSS) capacitor c=5.58973e-17
C26 (\3\:BN VSS) capacitor c=1.09736e-17
C27 (\4\:n0 VSS) capacitor c=7.34506e-17
C28 (\7\:VDD VSS) capacitor c=5.57799e-17
C29 (\4\:Y VSS) capacitor c=9.03485e-17
C30 (\8\:n1 VSS) capacitor c=4.73528e-17
C31 (\5\:VDD VSS) capacitor c=3.56386e-17
C32 (\1\:VDD VSS) capacitor c=4.92201e-17
C33 (\7\:n0 VSS) capacitor c=4.57101e-17
C34 (\1\:Y VSS) capacitor c=3.63726e-17
C35 (\6\:Y VSS) capacitor c=6.81698e-17
C36 (\6\:n1 VSS) capacitor c=1.12361e-17
C37 (\2\:BN VSS) capacitor c=1.08754e-17
C38 (\5\:BN VSS) capacitor c=4.40565e-17
C39 (\4\:D VSS) capacitor c=6.35904e-17
C40 (\4\:C VSS) capacitor c=4.43004e-17
C41 (\4\:n1 VSS) capacitor c=7.96701e-17
C42 (\5\:n1 VSS) capacitor c=7.20765e-17
C43 (\3\:Y VSS) capacitor c=7.68103e-17
C44 (\4\:AN VSS) capacitor c=7.42732e-17
C45 (\6\:n0 VSS) capacitor c=1.02805e-16
C46 (\3\:VDD VSS) capacitor c=1.3907e-17
Rk1 (BN \5\:BN) resistor r=0.1741 c=0
Rk11 (AN \4\:AN) resistor r=0.02589 c=0
Rk8 (\3\:Y Y) resistor r=0.3769 c=0
Rk7 (\2\:Y \3\:Y) resistor r=0.09026 c=0
Rk9 (Y \5\:Y) resistor r=0.6351 c=0
Rk10 (\3\:Y \7\:Y) resistor r=0.3696 c=0
Rk3 (C \4\:C) resistor r=0.1081 c=0
Rk23 (\2\:VDD \3\:VDD) resistor r=0.08758 c=0
Rk25 (\4\:VDD VDD) resistor r=0.2508 c=0
Rk24 (\3\:VDD \4\:VDD) resistor r=0.3133 c=0
Rk26 (VDD \6\:VDD) resistor r=0.2329 c=0
Rk27 (\3\:VDD \8\:VDD) resistor r=0.238 c=0
Rk2 (D \4\:D) resistor r=0.1011 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.4551 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.07504 c=0
Rk16 (\5\:VSS \6\:VSS) resistor r=0.2278 c=0
Rk18 (\7\:VSS VSS) resistor r=0.1004 c=0
Rk17 (\6\:VSS \7\:VSS) resistor r=0.04745 c=0
Rk20 (\5\:VSS \10\:VSS) resistor r=0.226 c=0
Rk21 (\6\:VSS \12\:VSS) resistor r=0.1374 c=0
Rk22 (VSS \14\:VSS) resistor r=0.1878 c=0
Rk4 (\4\:n1 \5\:n1) resistor r=0.4512 c=0
Rk5 (\5\:n1 \7\:n1) resistor r=0.08766 c=0
Rk6 (\5\:n1 \9\:n1) resistor r=0.2049 c=0
Rk12 (\5\:n0 \6\:n0) resistor r=0.5576 c=0
Rk13 (\6\:n0 \8\:n0) resistor r=0.3153 c=0
Rl1 (\1\:BN \2\:BN) resistor r=49.7141 c=0
Rl3 (\2\:BN \4\:BN) resistor r=34.3295 c=0
Rl2 (\2\:BN \3\:BN) resistor r=1.2666 c=0
Rl12 (\1\:AN \2\:AN) resistor r=74.2328 c=0
Rl13 (\2\:AN \3\:AN) resistor r=97.3098 c=0
Rl7 (\2\:C \3\:C) resistor r=68.4066 c=0
Rl6 (\1\:C \2\:C) resistor r=107.692 c=0
Rl4 (\1\:D \2\:D) resistor r=71.131 c=0
Rl5 (\2\:D \3\:D) resistor r=101.718 c=0
Rl8 (n1 \2\:n1) resistor r=56.1096 c=0
Rl9 (\2\:n1 \3\:n1) resistor r=126.374 c=0
Rl10 (n0 \2\:n0) resistor r=26.098 c=0
Rl11 (\2\:n0 \3\:n0) resistor r=155.689 c=0
Rz2 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz3 (\6\:Y \7\:Y) resistor r=37.5 c=0
Rz9 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz10 (\1\:VDD \4\:VDD) resistor r=12.5 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz7 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz8 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz1 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz4 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry2 (\4\:Y \5\:Y) resistor r=31 c=0
Ry7 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry8 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry6 (\3\:VSS VSS) resistor r=62 c=0
Ry4 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry5 (\3\:VSS \7\:VSS) resistor r=62 c=0
Ry1 (\8\:n1 \9\:n1) resistor r=62 c=0
Ry3 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx1 (\3\:BN \5\:BN) resistor r=45 c=0
Rx5 (\2\:AN \4\:AN) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx6 (\2\:n0 \6\:n0) resistor r=45 c=0
mn1 (\6\:n1 \4\:BN \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.375e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn5 (\6\:Y \3\:D \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.18e-14 ad=4.16e-14 ps=1.29e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=8.91635e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn4 (\6\:Y \1\:C \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=6.86635e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn3 (\1\:Y n1 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.81e-14 ps=8.7e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=4.66635e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn2 (\1\:Y n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=4.81e-14 ps=8.4e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=2.36635e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn0 (\7\:n0 \3\:AN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=1.4e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mp5 (\4\:Y \1\:D n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=8.3609e-07 sd=160n sca=13.1685 scb=0.0109658 \
        scc=0.000276178 m=(1)
mp4 (n2 \3\:C n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=2.34e-14 ps=1.01e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=7.3109e-07 sd=160n sca=12.5855 scb=0.0103077 \
        scc=0.000274391 m=(1)
mp3 (n3 \3\:n1 n4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=9.36e-14 \
        ad=4.485e-14 ps=1.26e-06 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.05e-07 sb=5.7109e-07 sd=160n sca=12.4303 scb=0.0101252 \
        scc=0.000274165 m=(1)
mp2 (n4 \3\:n0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=9.36e-14 ps=1.22e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=2.8609e-07 sd=160n sca=14.1331 \
        scb=0.0123288 scc=0.000285937 m=(1)
mp0 (\4\:n0 \1\:AN \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=3.01e-14 ps=1.22e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.55e-07 sb=1.4e-07 sd=160n sca=25.3128 \
        scb=0.0295551 scc=0.00162105 m=(1)
ends NOR4BBX1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:19:29 2012 )
// Library name: gsclib045
// Cell name: NOR4BBX2
// View name: extracted

simulator lang=spectre

subckt NOR4BBX2 AN BN C D VDD VSS Y
mp1 (\9\:n1 \1\:BN \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=3.655e-14 ps=1.1e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.20814e-07 sd=160n sca=28.0767 \
        scb=0.0303449 scc=0.00237588 m=(1)
C1 (BN VSS) capacitor c=5.1544e-17
C2 (D VSS) capacitor c=4.88011e-17
C3 (C VSS) capacitor c=3.96267e-17
C4 (VDD VSS) capacitor c=1.22269e-16
C5 (Y VSS) capacitor c=4.70738e-17
C6 (AN VSS) capacitor c=8.38681e-17
C7 (n1 VSS) capacitor c=1.95657e-16
C8 (n0 VSS) capacitor c=8.98367e-17
C9 (n4 VSS) capacitor c=2.49085e-16
C10 (n3 VSS) capacitor c=1.08359e-16
C11 (n2 VSS) capacitor c=1.82018e-16
C12 (\1\:D VSS) capacitor c=1.64254e-16
C13 (\1\:C VSS) capacitor c=1.94574e-16
C14 (\1\:AN VSS) capacitor c=3.06672e-17
C15 (\1\:BN VSS) capacitor c=4.06373e-17
C16 (\3\:AN VSS) capacitor c=4.33654e-17
C17 (\3\:BN VSS) capacitor c=2.98779e-17
C18 (\3\:n0 VSS) capacitor c=8.41085e-17
C19 (\2\:AN VSS) capacitor c=2.84425e-17
C20 (\2\:BN VSS) capacitor c=2.79531e-17
C21 (\9\:Y VSS) capacitor c=6.18219e-17
C22 (\3\:n3 VSS) capacitor c=9.34363e-17
C23 (\7\:VDD VSS) capacitor c=6.31943e-17
C24 (\9\:n0 VSS) capacitor c=5.83924e-17
C25 (\9\:VDD VSS) capacitor c=3.20848e-17
C26 (\9\:n1 VSS) capacitor c=5.39682e-17
C27 (\1\:VDD VSS) capacitor c=6.95265e-17
C28 (\1\:Y VSS) capacitor c=5.54957e-17
C29 (\3\:Y VSS) capacitor c=6.70936e-17
C30 (\5\:Y VSS) capacitor c=6.2111e-17
C31 (\7\:Y VSS) capacitor c=5.71938e-17
C32 (\11\:n0 VSS) capacitor c=5.03479e-17
C33 (\7\:n1 VSS) capacitor c=1.91706e-16
C34 (\4\:AN VSS) capacitor c=3.92642e-17
C35 (\4\:BN VSS) capacitor c=7.4667e-17
C36 (\7\:n0 VSS) capacitor c=6.73702e-17
C37 (\8\:n0 VSS) capacitor c=5.49449e-17
C38 (\6\:n1 VSS) capacitor c=1.76793e-16
C39 (\8\:C VSS) capacitor c=7.75491e-17
C40 (\8\:D VSS) capacitor c=6.58483e-17
C41 (\4\:VDD VSS) capacitor c=1.73949e-17
C42 (\5\:VDD VSS) capacitor c=8.08825e-18
Rk2 (BN \4\:BN) resistor r=0.1085 c=0
Rk12 (\8\:D D) resistor r=0.1691 c=0
Rk21 (\2\:VSS \3\:VSS) resistor r=0.06498 c=0
Rk28 (\3\:VSS \10\:VSS) resistor r=0.343 c=0
Rk30 (\11\:VSS VSS) resistor r=0.04988 c=0
Rk29 (\10\:VSS \11\:VSS) resistor r=0.1151 c=0
Rk36 (\10\:VSS \23\:VSS) resistor r=0.186 c=0
Rk10 (C \8\:C) resistor r=0.06228 c=0
Rk37 (\2\:VDD \3\:VDD) resistor r=0.6517 c=0
Rk38 (\3\:VDD \4\:VDD) resistor r=0.2354 c=0
Rk39 (\4\:VDD \5\:VDD) resistor r=0.3505 c=0
Rk41 (\6\:VDD VDD) resistor r=0.04988 c=0
Rk40 (\5\:VDD \6\:VDD) resistor r=0.1151 c=0
Rk42 (\4\:VDD \8\:VDD) resistor r=0.3456 c=0
Rk43 (\5\:VDD \10\:VDD) resistor r=0.2898 c=0
Rk16 (\2\:Y Y) resistor r=0.1955 c=0
Rk13 (\2\:Y \4\:Y) resistor r=0.2877 c=0
Rk14 (\4\:Y \6\:Y) resistor r=0.3704 c=0
Rk15 (\6\:Y \8\:Y) resistor r=0.2975 c=0
Rk17 (Y \10\:Y) resistor r=0.2495 c=0
Rk1 (\4\:AN AN) resistor r=0.1266 c=0
Rk6 (\6\:n1 \8\:n1) resistor r=1.4337 c=0
Rk7 (\8\:n1 \10\:n1) resistor r=0.3995 c=0
Rk3 (\7\:n0 \8\:n0) resistor r=0.3198 c=0
Rk4 (\8\:n0 \10\:n0) resistor r=0.1901 c=0
Rk5 (\8\:n0 \12\:n0) resistor r=0.1986 c=0
Rk11 (\2\:n3 \4\:n3) resistor r=0.5146 c=0
Rl1 (\1\:BN \2\:BN) resistor r=98.7687 c=0
Rl2 (\2\:BN \3\:BN) resistor r=39.1533 c=0
Rl3 (\1\:AN \2\:AN) resistor r=26.098 c=0
Rl4 (\2\:AN \3\:AN) resistor r=104.944 c=0
Rl6 (\3\:n0 n0) resistor r=7.0216 c=0
Rz12 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz13 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz14 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz15 (\6\:VDD \1\:VDD) resistor r=37.5 c=0
Rz3 (\2\:Y \1\:Y) resistor r=75 c=0
Rz4 (\4\:Y \3\:Y) resistor r=75 c=0
Rz5 (\6\:Y \5\:Y) resistor r=75 c=0
Rz6 (\8\:Y \7\:Y) resistor r=75 c=0
Rz2 (\8\:n1 \7\:n1) resistor r=75 c=0
Rz1 (\12\:n0 \11\:n0) resistor r=75 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry14 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\11\:VSS \1\:VSS) resistor r=31 c=0
Ry16 (\8\:VDD \7\:VDD) resistor r=62 c=0
Ry17 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry8 (\10\:Y \9\:Y) resistor r=62 c=0
Ry2 (\10\:n1 \9\:n1) resistor r=62 c=0
Ry1 (\10\:n0 \9\:n0) resistor r=62 c=0
Ry6 (\2\:n3 n3) resistor r=62 c=0
Ry7 (\4\:n3 \3\:n3) resistor r=62 c=0
Rx2 (\2\:BN \4\:BN) resistor r=45 c=0
Rx6 (\8\:D \1\:D) resistor r=45 c=0
Rx5 (\8\:C \1\:C) resistor r=45 c=0
Rx1 (\2\:AN \4\:AN) resistor r=45 c=0
Rx4 (\6\:n1 n1) resistor r=45 c=0
Rx3 (\7\:n0 \3\:n0) resistor r=45 c=0
mn1 (\7\:n1 \3\:BN \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=2.03e-14 ps=1.05e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.9e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn0 (\11\:n0 \3\:AN \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=3.263e-14 ps=1.05e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2.25e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn2 (\7\:Y n0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.095e-14 ad=4.16e-14 ps=8.35e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.59e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn3 (\5\:Y n1 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=4.16e-14 ps=8.55e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.165e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn4 (\3\:Y \1\:C \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75e-07 sb=7.55e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn5 (\1\:Y \1\:D \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=3.45e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mp0 (\9\:n0 \1\:AN \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=3.35e-14 ps=1.1e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.55814e-07 sd=160n sca=22.8052 \
        scb=0.0215313 scc=0.00209094 m=(1)
mp2 (n4 \3\:n0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.31e-14 ps=1.1e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=7.55e-07 sd=160n sca=25.6993 \
        scb=0.0190507 scc=0.00277827 m=(2)
mp5 (\9\:Y \1\:D n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=5.85e-14 \
        ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.5e-07 sb=3.45e-07 sd=160n sca=28.791 scb=0.0224678 \
        scc=0.00280266 m=(2)
mp3 (\3\:n3 n1 n4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=5.85e-14 \
        ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.22308e-07 sb=3.45e-07 sd=160n sca=25.6993 scb=0.0190507 \
        scc=0.00277827 m=(2)
mp4 (n2 \1\:C n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=5.85e-14 ps=1.1e-06 pd=1.08e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.55e-07 sd=160n sca=25.9574 scb=0.019118 \
        scc=0.00277828 m=(2)
ends NOR4BBX2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:20:07 2012 )
// Library name: gsclib045
// Cell name: NOR4BBX4
// View name: extracted

simulator lang=spectre

subckt NOR4BBX4 AN BN C D VDD VSS Y
mp1 (\18\:n1 \1\:BN \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=16.9422 \
        scb=0.0172816 scc=0.000388705 m=(1)
C1 (BN VSS) capacitor c=1.00177e-16
C2 (D VSS) capacitor c=3.49883e-17
C3 (C VSS) capacitor c=4.98738e-17
C4 (Y VSS) capacitor c=1.84969e-16
C5 (AN VSS) capacitor c=7.93776e-17
C6 (VDD VSS) capacitor c=3.05942e-16
C7 (n1 VSS) capacitor c=3.01572e-16
C8 (n0 VSS) capacitor c=2.92825e-16
C9 (n4 VSS) capacitor c=3.93222e-16
C10 (n3 VSS) capacitor c=1.59483e-16
C11 (n2 VSS) capacitor c=3.67628e-16
C12 (\1\:D VSS) capacitor c=3.13529e-16
C13 (\1\:C VSS) capacitor c=3.08236e-16
C14 (\1\:AN VSS) capacitor c=4.44805e-17
C15 (\1\:BN VSS) capacitor c=4.60868e-17
C16 (\3\:AN VSS) capacitor c=3.31922e-17
C17 (\3\:BN VSS) capacitor c=2.92109e-17
C18 (\2\:AN VSS) capacitor c=3.23961e-17
C19 (\2\:BN VSS) capacitor c=3.90455e-17
C20 (\5\:n3 VSS) capacitor c=1.34899e-16
C21 (\17\:n0 VSS) capacitor c=5.98577e-17
C22 (\14\:VDD VSS) capacitor c=3.43948e-17
C23 (\18\:n1 VSS) capacitor c=8.46817e-17
C24 (\1\:VDD VSS) capacitor c=2.51447e-16
C25 (\7\:Y VSS) capacitor c=1.14924e-16
C26 (\11\:Y VSS) capacitor c=1.13471e-16
C27 (\15\:Y VSS) capacitor c=1.43162e-16
C28 (\19\:n0 VSS) capacitor c=5.76985e-17
C29 (\16\:n1 VSS) capacitor c=2.48269e-16
C30 (\4\:BN VSS) capacitor c=3.42311e-17
C31 (\4\:AN VSS) capacitor c=5.13802e-17
C32 (\15\:n0 VSS) capacitor c=5.60183e-17
C33 (\16\:n0 VSS) capacitor c=6.6682e-17
C34 (\15\:n1 VSS) capacitor c=1.63068e-16
C35 (\16\:D VSS) capacitor c=6.78995e-17
C36 (\4\:Y VSS) capacitor c=1.05329e-16
C37 (\4\:VDD VSS) capacitor c=9.88783e-17
C38 (\8\:VDD VSS) capacitor c=3.45004e-18
Rk1 (\4\:BN BN) resistor r=0.02098 c=0
Rk19 (\16\:D D) resistor r=0.04495 c=0
Rk38 (\2\:VSS \3\:VSS) resistor r=0.03991 c=0
Rk50 (\3\:VSS \15\:VSS) resistor r=0.3606 c=0
Rk52 (\16\:VSS VSS) resistor r=0.04988 c=0
Rk51 (\15\:VSS \16\:VSS) resistor r=0.08001 c=0
Rk62 (\15\:VSS \36\:VSS) resistor r=0.2791 c=0
Rk13 (\15\:C C) resistor r=0.002997 c=0
Rk25 (\7\:Y \11\:Y) resistor r=0.2972 c=0
Rk27 (\11\:Y \15\:Y) resistor r=0.2969 c=0
Rk21 (Y \4\:Y) resistor r=0.341 c=0
Rk23 (\4\:Y \7\:Y) resistor r=0.2983 c=0
Rk2 (AN \4\:AN) resistor r=0.1348 c=0
Rk63 (\2\:VDD \3\:VDD) resistor r=0.752 c=0
Rk64 (\3\:VDD \4\:VDD) resistor r=0.5914 c=0
Rk67 (\4\:VDD \7\:VDD) resistor r=0.2053 c=0
Rk68 (\7\:VDD \8\:VDD) resistor r=0.1828 c=0
Rk70 (\9\:VDD VDD) resistor r=0.04988 c=0
Rk69 (\8\:VDD \9\:VDD) resistor r=0.1176 c=0
Rk73 (\8\:VDD \15\:VDD) resistor r=0.1804 c=0
Rk6 (\15\:n1 \17\:n1) resistor r=1.5866 c=0
Rk7 (\17\:n1 \19\:n1) resistor r=0.6493 c=0
Rk3 (\15\:n0 \16\:n0) resistor r=0.3138 c=0
Rk4 (\16\:n0 \18\:n0) resistor r=0.2641 c=0
Rk5 (\16\:n0 \20\:n0) resistor r=0.2621 c=0
Rk15 (n3 \5\:n3) resistor r=0.4344 c=0
Rl1 (\1\:BN \2\:BN) resistor r=92.3077 c=0
Rl2 (\2\:BN \3\:BN) resistor r=57.1429 c=0
Rl3 (\1\:AN \2\:AN) resistor r=91.0764 c=0
Rl4 (\2\:AN \3\:AN) resistor r=56.461 c=0
Rz20 (\36\:VSS \35\:VSS) resistor r=75 c=0
Rz21 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz22 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz23 (\4\:VDD \1\:VDD) resistor r=37.5 c=0
Rz24 (\7\:VDD \1\:VDD) resistor r=18.75 c=0
Rz25 (\9\:VDD \1\:VDD) resistor r=37.5 c=0
Rz2 (\17\:n1 \16\:n1) resistor r=75 c=0
Rz1 (\20\:n0 \19\:n0) resistor r=75 c=0
Ry19 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry22 (\3\:VSS \1\:VSS) resistor r=3.1 c=0
Ry23 (\16\:VSS \1\:VSS) resistor r=31 c=0
Ry26 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry2 (\19\:n1 \18\:n1) resistor r=62 c=0
Ry1 (\18\:n0 \17\:n0) resistor r=20.6667 c=0
Rx1 (\2\:BN \4\:BN) resistor r=45 c=0
Rx6 (\16\:D \1\:D) resistor r=45 c=0
Rx5 (\15\:C \1\:C) resistor r=45 c=0
Rx2 (\2\:AN \4\:AN) resistor r=45 c=0
Rx4 (\15\:n1 n1) resistor r=45 c=0
Rx3 (\15\:n0 n0) resistor r=45 c=0
mn1 (\16\:n1 \3\:BN \35\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=3.64e-14 ps=9.9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.6e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn0 (\19\:n0 \3\:AN \35\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=4.68e-14 ps=9.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.2e-07 sb=1.8e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn2_1__rcx (\15\:Y n0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=7.84363 scb=0.00546499 \
        scc=9.84911e-05 m=(4)
mn3_1__rcx (\11\:Y n1 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=4.16e-14 ps=8.55e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=2e-06 sd=160n sca=7.84363 scb=0.00546499 \
        scc=9.84911e-05 m=(4)
mn4_1__rcx (\7\:Y \1\:C \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.355e-14 ad=4.16e-14 ps=8.55e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.81e-06 sb=1.605e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(4)
mn5_1__rcx (\4\:Y \1\:D \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.55e-14 ps=8.3e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.85e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(4)
mp0 (\17\:n0 \1\:AN \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.63e-14 ps=1.1e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.7e-07 sd=160n sca=13.2347 \
        scb=0.0110279 scc=0.000235823 m=(1)
mp2_1__rcx (n4 n0 \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(4)
mp3_1__rcx (\5\:n3 n1 n4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(4)
mp4_1__rcx (n2 \1\:C n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.575e-06 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(4)
mp5_1__rcx (Y \1\:D n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=12.0193 \
        scb=0.0100773 scc=0.000291813 m=(4)
ends NOR4BBX4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:20:45 2012 )
// Library name: gsclib045
// Cell name: NOR4BBXL
// View name: extracted

simulator lang=spectre

subckt NOR4BBXL AN BN C D VDD VSS Y
mp1 (\9\:n1 \1\:BN \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=49.4198 \
        scb=0.0326741 scc=0.00592591 m=(1)
C1 (AN VSS) capacitor c=4.72217e-17
C2 (Y VSS) capacitor c=9.39321e-17
C3 (C VSS) capacitor c=3.72163e-17
C4 (D VSS) capacitor c=6.74987e-17
C5 (VDD VSS) capacitor c=1.48232e-16
C6 (n1 VSS) capacitor c=7.75386e-17
C7 (n0 VSS) capacitor c=2.20678e-17
C8 (n2 VSS) capacitor c=1.5042e-18
C9 (n3 VSS) capacitor c=2.65872e-18
C10 (n4 VSS) capacitor c=5.28568e-18
C11 (\1\:AN VSS) capacitor c=3.02497e-17
C12 (\4\:n0 VSS) capacitor c=7.33615e-17
C13 (\1\:C VSS) capacitor c=6.53781e-17
C14 (\1\:D VSS) capacitor c=6.52963e-17
C15 (\1\:BN VSS) capacitor c=2.80852e-17
C16 (\3\:AN VSS) capacitor c=7.30325e-17
C17 (\3\:n0 VSS) capacitor c=2.88044e-17
C18 (\4\:n1 VSS) capacitor c=3.88272e-17
C19 (\3\:C VSS) capacitor c=7.7407e-17
C20 (\3\:D VSS) capacitor c=5.681e-17
C21 (\3\:BN VSS) capacitor c=2.42461e-17
C22 (\2\:AN VSS) capacitor c=5.41879e-17
C23 (\3\:n1 VSS) capacitor c=2.79264e-17
C24 (\2\:C VSS) capacitor c=8.62542e-17
C25 (\2\:D VSS) capacitor c=5.47715e-17
C26 (\2\:BN VSS) capacitor c=2.34499e-17
C27 (\5\:n0 VSS) capacitor c=7.46684e-17
C28 (\1\:VDD VSS) capacitor c=5.26208e-17
C29 (\4\:Y VSS) capacitor c=7.80794e-17
C30 (\9\:n1 VSS) capacitor c=6.69796e-17
C31 (\6\:VDD VSS) capacitor c=4.33118e-17
C32 (\9\:n0 VSS) capacitor c=2.46898e-17
C33 (\1\:Y VSS) capacitor c=3.20772e-17
C34 (\6\:Y VSS) capacitor c=6.65904e-17
C35 (\7\:n1 VSS) capacitor c=1.45213e-17
C36 (\2\:n1 VSS) capacitor c=5.24647e-17
C37 (\2\:n0 VSS) capacitor c=5.1636e-17
C38 (\4\:BN VSS) capacitor c=3.17983e-17
C39 (\6\:BN VSS) capacitor c=5.66688e-17
C40 (\4\:D VSS) capacitor c=4.14214e-17
C41 (\4\:C VSS) capacitor c=6.4819e-17
C42 (\5\:n1 VSS) capacitor c=8.02823e-17
C43 (\6\:n1 VSS) capacitor c=6.82001e-17
C44 (\3\:Y VSS) capacitor c=6.4719e-17
C45 (\4\:AN VSS) capacitor c=5.3488e-17
C46 (\7\:n0 VSS) capacitor c=7.23845e-17
C47 (\8\:n0 VSS) capacitor c=3.91466e-17
C48 (\4\:VDD VSS) capacitor c=4.73981e-17
C49 (\5\:VDD VSS) capacitor c=1.35314e-17
Rk1 (\4\:BN BN) resistor r=0.009523 c=0
Rk3 (\4\:BN \6\:BN) resistor r=0.08106 c=0
Rk2 (\5\:BN \6\:BN) resistor r=0.009523 c=0
Rk13 (\4\:AN AN) resistor r=0.1852 c=0
Rk10 (\3\:Y Y) resistor r=0.2585 c=0
Rk9 (\2\:Y \3\:Y) resistor r=0.1247 c=0
Rk11 (Y \5\:Y) resistor r=0.6791 c=0
Rk12 (\3\:Y \7\:Y) resistor r=0.4067 c=0
Rk21 (\2\:VSS \4\:VSS) resistor r=0.2906 c=0
Rk22 (\4\:VSS \5\:VSS) resistor r=0.1176 c=0
Rk23 (\5\:VSS \6\:VSS) resistor r=0.2202 c=0
Rk24 (\6\:VSS \7\:VSS) resistor r=0.1126 c=0
Rk26 (\8\:VSS VSS) resistor r=0.08478 c=0
Rk25 (\7\:VSS \8\:VSS) resistor r=0.06498 c=0
Rk28 (\5\:VSS \11\:VSS) resistor r=0.1787 c=0
Rk29 (\6\:VSS \13\:VSS) resistor r=0.07358 c=0
Rk30 (\8\:VSS \15\:VSS) resistor r=0.07358 c=0
Rk5 (\4\:C C) resistor r=0.05486 c=0
Rk4 (\4\:D D) resistor r=0.02433 c=0
Rk17 (\2\:VDD \4\:VDD) resistor r=0.4632 c=0
Rk19 (\5\:VDD VDD) resistor r=0.1023 c=0
Rk18 (\4\:VDD \5\:VDD) resistor r=0.3482 c=0
Rk20 (\5\:VDD \7\:VDD) resistor r=0.4207 c=0
Rk6 (\5\:n1 \6\:n1) resistor r=0.397 c=0
Rk7 (\6\:n1 \8\:n1) resistor r=0.1263 c=0
Rk8 (\6\:n1 \10\:n1) resistor r=0.316 c=0
Rk14 (\6\:n0 \7\:n0) resistor r=0.6684 c=0
Rk15 (\7\:n0 \8\:n0) resistor r=0.2776 c=0
Rk16 (\7\:n0 \10\:n0) resistor r=0.2342 c=0
Rl1 (\1\:BN \2\:BN) resistor r=48.0769 c=0
Rl2 (\2\:BN \3\:BN) resistor r=39.8352 c=0
Rl13 (\1\:AN \2\:AN) resistor r=33.3841 c=0
Rl14 (\2\:AN \3\:AN) resistor r=268 c=0
Rl5 (\1\:C \2\:C) resistor r=45.9489 c=0
Rl6 (\2\:C \3\:C) resistor r=253.823 c=0
Rl3 (\1\:D \2\:D) resistor r=80.7464 c=0
Rl4 (\2\:D \3\:D) resistor r=257.487 c=0
Rl7 (n1 \2\:n1) resistor r=220.033 c=0
Rl9 (\2\:n1 \4\:n1) resistor r=96.9565 c=0
Rl8 (\2\:n1 \3\:n1) resistor r=2.4801 c=0
Rl10 (n0 \2\:n0) resistor r=2.0213 c=0
Rl12 (\2\:n0 \4\:n0) resistor r=272.791 c=0
Rl11 (\2\:n0 \3\:n0) resistor r=45.868 c=0
Rz2 (\1\:Y \2\:Y) resistor r=75 c=0
Rz3 (\6\:Y \7\:Y) resistor r=75 c=0
Rz6 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz7 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz8 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz9 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz1 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz4 (\9\:n0 \10\:n0) resistor r=75 c=0
Ry2 (\4\:Y \5\:Y) resistor r=62 c=0
Ry8 (\3\:VSS VSS) resistor r=62 c=0
Ry6 (\3\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry7 (\3\:VSS \7\:VSS) resistor r=31 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\9\:n1 \10\:n1) resistor r=62 c=0
Ry3 (\5\:n0 \6\:n0) resistor r=62 c=0
Rx1 (\2\:BN \5\:BN) resistor r=45 c=0
Rx5 (\2\:AN \4\:AN) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\3\:n1 \5\:n1) resistor r=45 c=0
Rx6 (n0 \8\:n0) resistor r=45 c=0
mn1 (\7\:n1 \3\:BN \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.215e-14 ad=2.03e-14 ps=1.4e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=16.2011 scb=0.0172667 \
        scc=0.0012292 m=(1)
mn5 (\6\:Y \3\:D \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.04e-14 ad=2.32e-14 ps=9.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.005e-06 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn4 (\6\:Y \3\:C \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=8e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn3 (\1\:Y \4\:n1 \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.973e-14 ps=6.1e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=5.95e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (\1\:Y \3\:n0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.973e-14 ps=6.1e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=3.45e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn0 (\9\:n0 \3\:AN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mp5 (\4\:Y \1\:D n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=8.6e-07 sd=160n sca=10.2576 scb=0.00735405 \
        scc=7.25622e-05 m=(1)
mp4 (n2 \1\:C n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=2.472e-14 \
        ad=1.29e-14 ps=6.6e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=7.55e-07 sd=160n sca=10.1345 scb=0.00732736 \
        scc=7.25592e-05 m=(1)
mp3 (n3 n1 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=4.408e-14 \
        ad=2.473e-14 ps=8.4e-07 pd=6.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.05e-07 sb=5.95e-07 sd=160n sca=10.4338 scb=0.00740954 \
        scc=7.25741e-05 m=(1)
mp2 (n4 \4\:n0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.408e-14 ps=7.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=3.45e-07 sd=160n sca=11.603 \
        scb=0.00833729 scc=7.42936e-05 m=(1)
mp0 (\5\:n0 \1\:AN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.4e-07 sd=160n sca=14.4159 \
        scb=0.0128226 scc=0.000143703 m=(1)
ends NOR4BBXL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:17:23 2012 )
// Library name: gsclib045
// Cell name: NOR4BX1
// View name: extracted

simulator lang=spectre

subckt NOR4BX1 AN B C D VDD VSS Y
mp4 (\6\:Y \1\:D n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.73846e-07 sd=160n sca=17.2376 scb=0.0171686 \
        scc=0.000563105 m=(1)
C1 (B VSS) capacitor c=8.33002e-17
C2 (C VSS) capacitor c=2.00046e-17
C3 (VDD VSS) capacitor c=1.13429e-16
C4 (Y VSS) capacitor c=1.26344e-17
C5 (AN VSS) capacitor c=3.94936e-17
C6 (n0 VSS) capacitor c=4.17522e-17
C7 (n2 VSS) capacitor c=1.99728e-18
C8 (\3\:AN VSS) capacitor c=4.35352e-17
C9 (\3\:n0 VSS) capacitor c=7.64233e-17
C10 (\1\:B VSS) capacitor c=5.46374e-17
C11 (\1\:C VSS) capacitor c=7.59096e-17
C12 (\1\:D VSS) capacitor c=7.32648e-17
C13 (\1\:AN VSS) capacitor c=3.26175e-17
C14 (\3\:B VSS) capacitor c=5.10375e-17
C15 (\3\:C VSS) capacitor c=5.14111e-17
C16 (\3\:D VSS) capacitor c=3.59247e-17
C17 (\2\:AN VSS) capacitor c=4.31481e-17
C18 (\2\:n0 VSS) capacitor c=5.67942e-17
C19 (\2\:B VSS) capacitor c=5.6278e-17
C20 (\2\:C VSS) capacitor c=5.90296e-17
C21 (\2\:D VSS) capacitor c=5.66877e-17
C22 (\7\:n0 VSS) capacitor c=5.60461e-17
C23 (\1\:VDD VSS) capacitor c=4.70269e-17
C24 (\6\:Y VSS) capacitor c=5.10316e-17
C25 (\5\:n0 VSS) capacitor c=7.83744e-17
C26 (\1\:Y VSS) capacitor c=7.41532e-17
C27 (\3\:Y VSS) capacitor c=4.88759e-17
C28 (\4\:D VSS) capacitor c=7.86163e-17
C29 (\4\:C VSS) capacitor c=4.91816e-17
C30 (\5\:Y VSS) capacitor c=8.35106e-17
C31 (\4\:AN VSS) capacitor c=5.68371e-17
C32 (\4\:n0 VSS) capacitor c=7.53315e-17
C33 (\4\:VDD VSS) capacitor c=2.88693e-17
Rk3 (B \4\:B) resistor r=0.00406 c=0
Rk11 (\2\:VSS \3\:VSS) resistor r=0.09973 c=0
Rk12 (\3\:VSS \4\:VSS) resistor r=0.09973 c=0
Rk13 (\4\:VSS \5\:VSS) resistor r=0.1122 c=0
Rk14 (\5\:VSS \6\:VSS) resistor r=0.08724 c=0
Rk16 (\7\:VSS VSS) resistor r=0.03203 c=0
Rk15 (\6\:VSS \7\:VSS) resistor r=0.1172 c=0
Rk18 (\3\:VSS \10\:VSS) resistor r=0.1982 c=0
Rk19 (\5\:VSS \12\:VSS) resistor r=0.1982 c=0
Rk20 (\7\:VSS \14\:VSS) resistor r=0.1982 c=0
Rk2 (C \4\:C) resistor r=0.1134 c=0
Rk22 (\4\:VDD VDD) resistor r=0.2995 c=0
Rk21 (\2\:VDD \4\:VDD) resistor r=0.4258 c=0
Rk1 (\4\:D D) resistor r=0.01679 c=0
Rk4 (\2\:Y \4\:Y) resistor r=0.3382 c=0
Rk6 (\5\:Y Y) resistor r=0.004828 c=0
Rk5 (\4\:Y \5\:Y) resistor r=0.2692 c=0
Rk7 (\5\:Y \7\:Y) resistor r=0.5372 c=0
Rk8 (AN \4\:AN) resistor r=0.09359 c=0
Rk9 (\4\:n0 \6\:n0) resistor r=0.3044 c=0
Rk10 (\6\:n0 \8\:n0) resistor r=0.5005 c=0
Rl5 (\1\:B \2\:B) resistor r=62.2302 c=0
Rl6 (\2\:B \3\:B) resistor r=106.461 c=0
Rl3 (\1\:C \2\:C) resistor r=56.461 c=0
Rl4 (\2\:C \3\:C) resistor r=112.23 c=0
Rl1 (\1\:D \2\:D) resistor r=70.9439 c=0
Rl2 (\2\:D \3\:D) resistor r=101.099 c=0
Rl10 (\2\:AN \3\:AN) resistor r=116.54 c=0
Rl9 (\1\:AN \2\:AN) resistor r=49.2328 c=0
Rl7 (n0 \2\:n0) resistor r=37.6944 c=0
Rl8 (\2\:n0 \3\:n0) resistor r=128.079 c=0
Rz4 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz5 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz6 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\3\:Y \4\:Y) resistor r=75 c=0
Rz3 (\5\:n0 \6\:n0) resistor r=75 c=0
Ry6 (\1\:VSS VSS) resistor r=62 c=0
Ry3 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry4 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry5 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry7 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry1 (\6\:Y \7\:Y) resistor r=31 c=0
Ry2 (\7\:n0 \8\:n0) resistor r=62 c=0
Rx3 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:AN \4\:AN) resistor r=45 c=0
Rx5 (\2\:n0 \4\:n0) resistor r=45 c=0
mn4 (\3\:Y \3\:D \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.01058e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn3 (\3\:Y \3\:C \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.96058e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn2 (\1\:Y \3\:B \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=4.76058e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn1 (\1\:Y n0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=2.71058e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn0 (\5\:n0 \1\:AN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=1.4e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mp3 (n1 \1\:C n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.825e-14 \
        ad=2.34e-14 ps=1.13e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.68846e-07 sd=160n sca=15.3527 scb=0.0138144 \
        scc=0.000491181 m=(1)
mp2 (n2 \1\:B n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=6.825e-14 ps=1.01e-06 pd=1.13e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.65e-07 sb=4.48846e-07 sd=160n sca=14.2604 scb=0.0119242 \
        scc=0.000478605 m=(1)
mp1 (n3 \3\:n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=4.485e-14 ps=1.16e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2.88846e-07 sd=160n sca=14.7087 \
        scb=0.0126621 scc=0.000481524 m=(1)
mp0 (\7\:n0 \3\:AN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.762e-14 ps=1.16e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.75e-07 sd=160n sca=21.1756 \
        scb=0.0235868 scc=0.00103894 m=(1)
ends NOR4BX1
// End of subcircuit definition.

// Generated for: spectre (May  9 16:22:07 2012 )
// Library name: gsclib045
// Cell name: NOR4BX2
// View name: extracted

simulator lang=spectre

subckt NOR4BX2 AN B C D VDD VSS Y
mp0 (\12\:n0 \1\:AN \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.128e-14 ad=3.41e-14 ps=1e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.58605e-07 sd=160n sca=36.537 \
        scb=0.0294967 scc=0.00430052 m=(1)
C1 (C VSS) capacitor c=4.10127e-17
C2 (Y VSS) capacitor c=1.6579e-16
C3 (B VSS) capacitor c=5.3354e-17
C4 (VDD VSS) capacitor c=1.60801e-16
C5 (D VSS) capacitor c=5.75812e-17
C6 (AN VSS) capacitor c=3.82034e-17
C7 (n0 VSS) capacitor c=6.49477e-17
C8 (n3 VSS) capacitor c=2.1978e-16
C9 (n2 VSS) capacitor c=9.83553e-17
C10 (n1 VSS) capacitor c=1.90403e-16
C11 (\1\:D VSS) capacitor c=8.51366e-17
C12 (\1\:C VSS) capacitor c=1.11551e-16
C13 (\1\:AN VSS) capacitor c=2.35488e-17
C14 (\1\:B VSS) capacitor c=7.43317e-17
C15 (\3\:AN VSS) capacitor c=2.387e-17
C16 (\3\:D VSS) capacitor c=1.46504e-17
C17 (\3\:B VSS) capacitor c=1.04419e-16
C18 (\3\:n0 VSS) capacitor c=1.21902e-17
C19 (\2\:AN VSS) capacitor c=1.926e-17
C20 (\10\:Y VSS) capacitor c=1.80974e-16
C21 (\3\:n2 VSS) capacitor c=9.19258e-17
C22 (\7\:VDD VSS) capacitor c=4.34912e-17
C23 (\12\:n0 VSS) capacitor c=1.49907e-17
C24 (\9\:VDD VSS) capacitor c=2.65892e-17
C25 (\1\:VDD VSS) capacitor c=9.33849e-17
C26 (\1\:Y VSS) capacitor c=4.48977e-17
C27 (\3\:Y VSS) capacitor c=7.04257e-17
C28 (\5\:Y VSS) capacitor c=3.84598e-17
C29 (\8\:Y VSS) capacitor c=2.91046e-17
C30 (\10\:n0 VSS) capacitor c=2.28251e-17
C31 (\4\:n0 VSS) capacitor c=7.34936e-17
C32 (\3\:C VSS) capacitor c=8.53293e-17
C33 (\4\:D VSS) capacitor c=7.17797e-17
C34 (\4\:AN VSS) capacitor c=4.9774e-17
C35 (\8\:n0 VSS) capacitor c=2.41459e-17
C36 (\9\:n0 VSS) capacitor c=3.4047e-17
C37 (\7\:B VSS) capacitor c=5.94214e-17
C38 (\7\:C VSS) capacitor c=7.75961e-17
C39 (\7\:Y VSS) capacitor c=3.55436e-17
C40 (\8\:D VSS) capacitor c=3.62244e-17
C41 (\4\:VDD VSS) capacitor c=2.09363e-17
C42 (\5\:VDD VSS) capacitor c=8.92719e-18
Rk28 (\1\:VSS \11\:VSS) resistor r=0.1902 c=0
Rk30 (\12\:VSS VSS) resistor r=0.1123 c=0
Rk29 (\11\:VSS \12\:VSS) resistor r=0.03739 c=0
Rk35 (\12\:VSS \22\:VSS) resistor r=0.362 c=0
Rk9 (C \7\:C) resistor r=0.06779 c=0
Rk10 (\2\:Y \4\:Y) resistor r=0.2725 c=0
Rk11 (\4\:Y \6\:Y) resistor r=0.2954 c=0
Rk14 (\7\:Y Y) resistor r=0.2136 c=0
Rk12 (\6\:Y \7\:Y) resistor r=0.07033 c=0
Rk13 (\7\:Y \9\:Y) resistor r=0.2141 c=0
Rk15 (Y \11\:Y) resistor r=0.9982 c=0
Rk7 (\7\:B B) resistor r=0.1211 c=0
Rk36 (\2\:VDD \3\:VDD) resistor r=0.6515 c=0
Rk37 (\3\:VDD \4\:VDD) resistor r=0.2353 c=0
Rk39 (\5\:VDD VDD) resistor r=0.03965 c=0
Rk38 (\4\:VDD \5\:VDD) resistor r=0.3755 c=0
Rk41 (\4\:VDD \8\:VDD) resistor r=0.2191 c=0
Rk42 (\5\:VDD \10\:VDD) resistor r=0.3985 c=0
Rk16 (\8\:D \9\:D) resistor r=0.01775 c=0
Rk17 (\10\:D D) resistor r=0.01788 c=0
Rk18 (\9\:D \10\:D) resistor r=0.04313 c=0
Rk1 (\4\:AN AN) resistor r=0.1719 c=0
Rk2 (\8\:n0 \9\:n0) resistor r=0.1459 c=0
Rk3 (\9\:n0 \11\:n0) resistor r=0.1384 c=0
Rk4 (\9\:n0 \13\:n0) resistor r=0.09946 c=0
Rk8 (\2\:n2 \4\:n2) resistor r=0.5221 c=0
Rl15 (\3\:C \1\:C) resistor r=62.4901 c=0
Rl10 (\3\:B \1\:B) resistor r=29.4415 c=0
Rl20 (\1\:D \3\:D) resistor r=78.2445 c=0
Rl21 (\4\:D \3\:D) resistor r=4.3511 c=0
Rl1 (\1\:AN \2\:AN) resistor r=35.7713 c=0
Rl2 (\2\:AN \3\:AN) resistor r=37.6944 c=0
Rl4 (\3\:n0 n0) resistor r=59.5407 c=0
Rl5 (\4\:n0 \3\:n0) resistor r=12.1383 c=0
Rz11 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz2 (\2\:Y \1\:Y) resistor r=75 c=0
Rz3 (\4\:Y \3\:Y) resistor r=75 c=0
Rz4 (\6\:Y \5\:Y) resistor r=75 c=0
Rz5 (\9\:Y \8\:Y) resistor r=75 c=0
Rz14 (VDD \1\:VDD) resistor r=75 c=0
Rz12 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz13 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz1 (\11\:n0 \10\:n0) resistor r=75 c=0
Ry12 (\1\:VSS \3\:VSS) resistor r=6.2 c=0
Ry14 (\11\:VSS \3\:VSS) resistor r=15.5 c=0
Ry7 (\11\:Y \10\:Y) resistor r=62 c=0
Ry15 (\8\:VDD \7\:VDD) resistor r=62 c=0
Ry16 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry1 (\13\:n0 \12\:n0) resistor r=62 c=0
Ry5 (\2\:n2 n2) resistor r=62 c=0
Ry6 (\4\:n2 \3\:n2) resistor r=62 c=0
Rx4 (\7\:C \1\:C) resistor r=45 c=0
Rx3 (\7\:B \3\:B) resistor r=45 c=0
Rx5 (\8\:D \3\:D) resistor r=45 c=0
Rx1 (\2\:AN \4\:AN) resistor r=45 c=0
Rx2 (\8\:n0 \3\:n0) resistor r=45 c=0
mn0 (\10\:n0 \3\:AN \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.05e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (\8\:Y n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.263e-14 ad=4.16e-14 ps=1.035e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.615e-06 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(2)
mn2 (\5\:Y \1\:B \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.68e-14 ad=4.16e-14 ps=8.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.205e-06 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(2)
mn3 (\3\:Y \3\:C \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.68e-14 ad=4.16e-14 ps=8.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=7.55e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(2)
mn4 (\1\:Y \4\:D \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=3.45e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(2)
mp1 (n3 \4\:n0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.57e-14 ps=1.1e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.25641e-07 sb=7.55e-07 sd=160n sca=13.7988 \
        scb=0.0122414 scc=0.000647521 m=(2)
mp2 (n2 \3\:B n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=5.85e-14 \
        ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.35641e-07 sb=3.45e-07 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(2)
mp3 (n1 \1\:C \3\:n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=5.85e-14 ps=1.1e-06 pd=1.08e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.55e-07 sd=160n sca=13.895 scb=0.0122763 \
        scc=0.000647531 m=(2)
mp4 (\10\:Y \1\:D n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=5.85e-14 \
        ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.5e-07 sb=3.45e-07 sd=160n sca=17.0995 scb=0.0163575 \
        scc=0.000685689 m=(2)
ends NOR4BX2
// End of subcircuit definition.

// Generated for: spectre (May  9 16:22:46 2012 )
// Library name: gsclib045
// Cell name: NOR4BX4
// View name: extracted

simulator lang=spectre

subckt NOR4BX4 AN B C D VDD VSS Y
mp0 (\20\:n0 \1\:AN \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.8e-14 ps=1.06e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23077e-07 sd=160n sca=38.3623 \
        scb=0.0317516 scc=0.00376558 m=(1)
C1 (C VSS) capacitor c=4.30165e-16
C2 (Y VSS) capacitor c=2.39212e-16
C3 (B VSS) capacitor c=3.89829e-16
C4 (VDD VSS) capacitor c=2.39745e-16
C5 (D VSS) capacitor c=3.84901e-16
C6 (AN VSS) capacitor c=3.16436e-17
C7 (n0 VSS) capacitor c=3.20696e-16
C8 (n3 VSS) capacitor c=3.99369e-16
C9 (n2 VSS) capacitor c=1.73833e-16
C10 (n1 VSS) capacitor c=3.63408e-16
C11 (\1\:AN VSS) capacitor c=3.37991e-17
C12 (\3\:AN VSS) capacitor c=2.51423e-17
C13 (\2\:AN VSS) capacitor c=1.74168e-17
C14 (\18\:Y VSS) capacitor c=3.46471e-16
C15 (\4\:n2 VSS) capacitor c=1.63278e-16
C16 (\20\:n0 VSS) capacitor c=2.13048e-17
C17 (\12\:VDD VSS) capacitor c=2.67617e-17
C18 (\1\:VDD VSS) capacitor c=1.7132e-16
C19 (\1\:Y VSS) capacitor c=9.54727e-17
C20 (\5\:Y VSS) capacitor c=1.16038e-16
C21 (\9\:Y VSS) capacitor c=9.14492e-17
C22 (\14\:Y VSS) capacitor c=1.15632e-16
C23 (\18\:n0 VSS) capacitor c=1.88706e-17
C24 (\4\:AN VSS) capacitor c=6.18388e-17
C25 (\17\:n0 VSS) capacitor c=4.43307e-17
C26 (\13\:Y VSS) capacitor c=4.03187e-17
C27 (\4\:VDD VSS) capacitor c=1.14762e-16
C28 (\6\:VDD VSS) capacitor c=9.18598e-18
Rk37 (\2\:VSS \3\:VSS) resistor r=0.1075 c=0
Rk58 (\3\:VSS \32\:VSS) resistor r=0.1508 c=0
Rk60 (\33\:VSS VSS) resistor r=0.03712 c=0
Rk59 (\32\:VSS \33\:VSS) resistor r=0.1125 c=0
Rk63 (\33\:VSS \38\:VSS) resistor r=0.272 c=0
Rk31 (Y \18\:Y) resistor r=1.4551 c=0
Rk23 (\1\:Y \5\:Y) resistor r=0.2626 c=0
Rk25 (\5\:Y \9\:Y) resistor r=0.2626 c=0
Rk30 (\13\:Y Y) resistor r=0.3021 c=0
Rk27 (\9\:Y \13\:Y) resistor r=0.04705 c=0
Rk28 (\13\:Y \14\:Y) resistor r=0.237 c=0
Rk64 (\2\:VDD \3\:VDD) resistor r=1.0519 c=0
Rk65 (\3\:VDD \4\:VDD) resistor r=0.06492 c=0
Rk68 (\6\:VDD VDD) resistor r=0.03712 c=0
Rk67 (\4\:VDD \6\:VDD) resistor r=0.3427 c=0
Rk72 (\6\:VDD \13\:VDD) resistor r=0.3383 c=0
Rk1 (\4\:AN AN) resistor r=0.08125 c=0
Rk3 (n0 \17\:n0) resistor r=0.3699 c=0
Rk4 (\17\:n0 \19\:n0) resistor r=0.1248 c=0
Rk5 (\17\:n0 \21\:n0) resistor r=0.1664 c=0
Rk16 (n2 \4\:n2) resistor r=0.4476 c=0
Rl1 (\1\:AN \2\:AN) resistor r=47.3097 c=0
Rl2 (\2\:AN \3\:AN) resistor r=24.2328 c=0
Rz19 (\38\:VSS \37\:VSS) resistor r=75 c=0
Rz22 (VDD \1\:VDD) resistor r=75 c=0
Rz20 (\2\:VDD \1\:VDD) resistor r=8.3333 c=0
Rz21 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz1 (\19\:n0 \18\:n0) resistor r=75 c=0
Ry25 (VSS \1\:VSS) resistor r=62 c=0
Ry18 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry19 (\3\:VSS \1\:VSS) resistor r=3.6471 c=0
Ry24 (\32\:VSS \1\:VSS) resistor r=31 c=0
Ry28 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry1 (\21\:n0 \20\:n0) resistor r=62 c=0
Rx1 (\2\:AN \4\:AN) resistor r=45 c=0
mn0 (\18\:n0 \3\:AN \37\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=5.06e-14 ps=8e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.94615e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn1 (\14\:Y n0 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.299e-14 ad=4.16e-14 ps=9.725e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2e-06 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(4)
mn2 (\9\:Y B \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=2e-06 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(4)
mn3 (\5\:Y C \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=1.575e-06 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(4)
mn4 (\1\:Y D \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(4)
mp1 (n3 n0 \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=6.051e-14 ps=1.1e-06 pd=1.0975e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.25641e-07 sb=1.6e-06 sd=160n sca=12.8019 scb=0.0109628 \
        scc=0.00041245 m=(4)
mp2 (\4\:n2 B n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.386e-14 \
        ad=6.24e-14 ps=1.1075e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=9.60641e-07 sb=7.65e-07 sd=160n sca=12.3656 scb=0.0108222 \
        scc=0.000412413 m=(4)
mp3 (n1 C n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=6.045e-14 ps=1.1e-06 pd=1.09e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.575e-06 sd=160n sca=13.5671 scb=0.012183 \
        scc=0.000647513 m=(4)
mp4 (\18\:Y D n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.045e-14 \
        ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=9.6e-07 sb=7.55e-07 sd=160n sca=13.6362 scb=0.0121968 \
        scc=0.000647514 m=(4)
ends NOR4BX4
// End of subcircuit definition.

// Generated for: spectre (May  9 16:23:24 2012 )
// Library name: gsclib045
// Cell name: NOR4BXL
// View name: extracted

simulator lang=spectre

subckt NOR4BXL AN B C D VDD VSS Y
mp4 (\6\:Y \1\:D n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.828e-14 ad=3.01e-14 ps=6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.05e-07 sd=160n sca=34.5672 \
        scb=0.0266035 scc=0.00427242 m=(1)
C1 (B VSS) capacitor c=5.53195e-17
C2 (Y VSS) capacitor c=8.88556e-17
C3 (C VSS) capacitor c=4.5174e-17
C4 (D VSS) capacitor c=4.56478e-17
C5 (AN VSS) capacitor c=7.57909e-17
C6 (VDD VSS) capacitor c=9.76466e-17
C7 (n0 VSS) capacitor c=5.08697e-17
C8 (n1 VSS) capacitor c=3.58718e-18
C9 (n2 VSS) capacitor c=1.31157e-18
C10 (n3 VSS) capacitor c=4.81392e-18
C11 (\1\:AN VSS) capacitor c=3.54806e-17
C12 (\1\:B VSS) capacitor c=3.73425e-17
C13 (\1\:C VSS) capacitor c=4.85632e-17
C14 (\1\:D VSS) capacitor c=4.23325e-17
C15 (\3\:AN VSS) capacitor c=3.92306e-17
C16 (\3\:n0 VSS) capacitor c=3.12133e-17
C17 (\3\:B VSS) capacitor c=4.10241e-17
C18 (\3\:C VSS) capacitor c=4.67377e-17
C19 (\3\:D VSS) capacitor c=3.97984e-17
C20 (\2\:AN VSS) capacitor c=4.0167e-17
C21 (\2\:n0 VSS) capacitor c=4.95278e-17
C22 (\2\:B VSS) capacitor c=5.04924e-17
C23 (\2\:C VSS) capacitor c=5.10593e-17
C24 (\2\:D VSS) capacitor c=4.89367e-17
C25 (\8\:n0 VSS) capacitor c=8.18412e-17
C26 (\1\:VDD VSS) capacitor c=3.30004e-17
C27 (\6\:Y VSS) capacitor c=6.93153e-17
C28 (\4\:n0 VSS) capacitor c=1.93526e-17
C29 (\4\:Y VSS) capacitor c=7.18998e-17
C30 (\1\:Y VSS) capacitor c=2.64982e-17
C31 (\4\:D VSS) capacitor c=6.77963e-17
C32 (\4\:C VSS) capacitor c=5.51795e-17
C33 (\3\:Y VSS) capacitor c=7.81263e-17
C34 (\4\:B VSS) capacitor c=3.68895e-17
C35 (\4\:AN VSS) capacitor c=2.61464e-17
C36 (\6\:n0 VSS) capacitor c=6.45078e-17
C37 (\7\:n0 VSS) capacitor c=3.79409e-17
C38 (\4\:VDD VSS) capacitor c=3.53677e-17
Rk7 (\4\:B B) resistor r=0.1578 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.2241 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.2303 c=0
Rk16 (\5\:VSS \6\:VSS) resistor r=0.1197 c=0
Rk17 (\6\:VSS \7\:VSS) resistor r=0.08474 c=0
Rk19 (\8\:VSS VSS) resistor r=0.04971 c=0
Rk18 (\7\:VSS \8\:VSS) resistor r=0.1147 c=0
Rk20 (\5\:VSS \10\:VSS) resistor r=0.1782 c=0
Rk21 (\7\:VSS \12\:VSS) resistor r=0.1777 c=0
Rk4 (\3\:Y Y) resistor r=0.4804 c=0
Rk3 (\2\:Y \3\:Y) resistor r=0.09909 c=0
Rk5 (\3\:Y \5\:Y) resistor r=0.3772 c=0
Rk6 (Y \7\:Y) resistor r=0.535 c=0
Rk2 (\4\:C C) resistor r=0.185 c=0
Rk1 (D \4\:D) resistor r=0.0638 c=0
Rk8 (AN \4\:AN) resistor r=0.1458 c=0
Rk13 (\4\:VDD VDD) resistor r=0.3995 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.5856 c=0
Rk9 (\5\:n0 \6\:n0) resistor r=0.09588 c=0
Rk10 (\6\:n0 \7\:n0) resistor r=0.2001 c=0
Rk11 (\6\:n0 \9\:n0) resistor r=0.6626 c=0
Rl5 (\1\:B \2\:B) resistor r=83.3841 c=0
Rl6 (\2\:B \3\:B) resistor r=100.692 c=0
Rl3 (\1\:C \2\:C) resistor r=64.1533 c=0
Rl4 (\2\:C \3\:C) resistor r=119.922 c=0
Rl1 (\1\:D \2\:D) resistor r=53.8233 c=0
Rl2 (\2\:D \3\:D) resistor r=140.18 c=0
Rl9 (\1\:AN \2\:AN) resistor r=81.9251 c=0
Rl10 (\2\:AN \3\:AN) resistor r=99.2328 c=0
Rl7 (n0 \2\:n0) resistor r=144.923 c=0
Rl8 (\2\:n0 \3\:n0) resistor r=39.1533 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz7 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\4\:Y \5\:Y) resistor r=75 c=0
Rz3 (\4\:n0 \5\:n0) resistor r=75 c=0
Ry4 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry5 (\3\:VSS \6\:VSS) resistor r=31 c=0
Ry6 (\3\:VSS \8\:VSS) resistor r=31 c=0
Ry1 (\6\:Y \7\:Y) resistor r=62 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry2 (\8\:n0 \9\:n0) resistor r=62 c=0
Rx3 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:AN \4\:AN) resistor r=45 c=0
Rx5 (\2\:n0 \7\:n0) resistor r=45 c=0
mn4 (\1\:Y \3\:D \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.8e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn3 (\1\:Y \3\:C \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.75e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn2 (\4\:Y \3\:B \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.61e-14 ps=6.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=5.7e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn1 (\4\:Y \3\:n0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.61e-14 ps=6.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=3.45e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn0 (\4\:n0 \3\:AN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=1.4e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mp3 (n1 \1\:C n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.44e-14 \
        ad=1.828e-14 ps=7.5e-07 pd=6e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.7e-07 sb=7.75e-07 sd=160n sca=33.8938 scb=0.0260321 \
        scc=0.00427143 m=(1)
mp2 (n2 \1\:B n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.87e-14 \
        ad=3.44e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.75e-07 sb=5.7e-07 sd=160n sca=33.5475 scb=0.0258591 \
        scc=0.00427134 m=(1)
mp1 (n3 n0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.44e-14 \
        ad=3.87e-14 ps=7.5e-07 pd=7.9e-07 nrd=1.16667 nrs=1.16667 sa=7e-07 \
        sb=3.45e-07 sd=160n sca=34.4077 scb=0.0264408 scc=0.00427202 m=(1)
mp0 (\8\:n0 \1\:AN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.05e-07 sb=1.4e-07 sd=160n sca=36.537 \
        scb=0.0294967 scc=0.00430052 m=(1)
ends NOR4BXL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:18:08 2012 )
// Library name: gsclib045
// Cell name: NOR4X1
// View name: extracted

simulator lang=spectre

subckt NOR4X1 A B C D VDD VSS Y
mp0 (n2 \1\:A \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.7e-07 sd=160n sca=39.8224 \
        scb=0.0332643 scc=0.00388272 m=(1)
C1 (Y VSS) capacitor c=2.88223e-17
C2 (B VSS) capacitor c=7.91706e-17
C3 (D VSS) capacitor c=3.02429e-17
C4 (A VSS) capacitor c=2.18591e-17
C5 (C VSS) capacitor c=6.07672e-17
C6 (VDD VSS) capacitor c=4.62353e-17
C7 (n2 VSS) capacitor c=2.62435e-18
C8 (n1 VSS) capacitor c=7.65769e-18
C9 (n0 VSS) capacitor c=2.19493e-18
C10 (\3\:D VSS) capacitor c=4.27532e-17
C11 (\1\:C VSS) capacitor c=5.01282e-17
C12 (\1\:B VSS) capacitor c=6.89565e-17
C13 (\1\:A VSS) capacitor c=6.98697e-17
C14 (\1\:D VSS) capacitor c=2.90982e-17
C15 (\3\:C VSS) capacitor c=4.16088e-17
C16 (\3\:B VSS) capacitor c=4.59021e-17
C17 (\3\:A VSS) capacitor c=2.69411e-17
C18 (\2\:D VSS) capacitor c=2.79616e-17
C19 (\2\:C VSS) capacitor c=3.50394e-17
C20 (\2\:B VSS) capacitor c=4.38959e-17
C21 (\2\:A VSS) capacitor c=4.1968e-17
C22 (\1\:Y VSS) capacitor c=7.28505e-17
C23 (\5\:VDD VSS) capacitor c=6.85701e-17
C24 (\1\:VDD VSS) capacitor c=3.87373e-17
C25 (\3\:Y VSS) capacitor c=8.3859e-17
C26 (\5\:Y VSS) capacitor c=5.48431e-17
C27 (\4\:A VSS) capacitor c=3.24011e-17
C28 (\4\:B VSS) capacitor c=3.96902e-17
C29 (\4\:C VSS) capacitor c=7.58167e-17
C30 (\4\:D VSS) capacitor c=5.9657e-17
Rk5 (Y \2\:Y) resistor r=0.1984 c=0
Rk6 (\2\:Y \4\:Y) resistor r=0.4988 c=0
Rk7 (\4\:Y \6\:Y) resistor r=0.2869 c=0
Rk2 (\4\:B B) resistor r=0.1701 c=0
Rk4 (D \4\:D) resistor r=0.02918 c=0
Rk1 (\4\:A A) resistor r=0.06282 c=0
Rk9 (\4\:VSS VSS) resistor r=0.2017 c=0
Rk8 (\2\:VSS \4\:VSS) resistor r=0.4508 c=0
Rk10 (\4\:VSS \6\:VSS) resistor r=0.3016 c=0
Rk11 (VSS \8\:VSS) resistor r=0.06245 c=0
Rk3 (\4\:C C) resistor r=0.3466 c=0
Rk13 (\3\:VDD VDD) resistor r=0.02966 c=0
Rk12 (\2\:VDD \3\:VDD) resistor r=0.2206 c=0
Rk15 (\3\:VDD \6\:VDD) resistor r=0.3943 c=0
Rl3 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl4 (\2\:B \3\:B) resistor r=56.461 c=0
Rl8 (\2\:D \3\:D) resistor r=29.9451 c=0
Rl7 (\1\:D \2\:D) resistor r=57.6923 c=0
Rl1 (\1\:A \2\:A) resistor r=55.5593 c=0
Rl2 (\2\:A \3\:A) resistor r=33.7912 c=0
Rl5 (\1\:C \2\:C) resistor r=29.5379 c=0
Rl6 (\2\:C \3\:C) resistor r=56.461 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\5\:Y \6\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz5 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz7 (\1\:VDD VDD) resistor r=75 c=0
Rz6 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=20.6667 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
mn0 (\5\:Y \3\:A \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.79e-14 ad=4.16e-14 ps=1.4e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.65e-07 sd=160n sca=12.8392 scb=0.0126987 \
        scc=0.00074151 m=(1)
mn1 (\5\:Y \3\:B \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=5.6e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn2 (\3\:Y \3\:C \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=3.45e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn3 (\3\:Y \1\:D \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.4e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mp1 (n1 \1\:B n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.63e-14 ps=9e-07 pd=1.12e-06 nrd=1.16667 nrs=1.16667 \
