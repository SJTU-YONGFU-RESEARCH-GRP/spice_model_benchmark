C168 (VDD VSS) capacitor c=6.94204e-17
C169 (\2\:CKbb VSS) capacitor c=6.16866e-17
C170 (\2\:CK VSS) capacitor c=3.38152e-17
C171 (\2\:D VSS) capacitor c=3.55168e-17
C172 (\2\:SE VSS) capacitor c=2.5012e-17
C173 (\2\:CKb VSS) capacitor c=1.511e-16
C174 (\3\:CKb VSS) capacitor c=8.78376e-17
C175 (\2\:n35g VSS) capacitor c=2.91123e-17
C176 (\4\:RT VSS) capacitor c=7.42727e-17
C177 (\2\:qbint VSS) capacitor c=4.13305e-17
C178 (\6\:CKbb VSS) capacitor c=1.37045e-16
C179 (\7\:CKbb VSS) capacitor c=7.33584e-17
C180 (\4\:SN VSS) capacitor c=3.6098e-16
C181 (\2\:net573 VSS) capacitor c=1.5308e-17
C182 (\12\:n20 VSS) capacitor c=4.40581e-17
C183 (\5\:RNb VSS) capacitor c=3.89503e-16
C184 (\6\:RNb VSS) capacitor c=1.81254e-16
C185 (\12\:RNb VSS) capacitor c=1.12461e-16
C186 (\13\:CKbb VSS) capacitor c=1.5538e-16
C187 (\14\:CKbb VSS) capacitor c=1.3771e-16
C188 (\8\:qbint VSS) capacitor c=5.09063e-17
C189 (\9\:qbint VSS) capacitor c=7.54296e-17
C190 (\15\:n20 VSS) capacitor c=7.51695e-17
C191 (\16\:n20 VSS) capacitor c=9.23447e-17
C192 (\19\:CKbb VSS) capacitor c=4.27767e-17
C193 (\6\:CK VSS) capacitor c=4.1089e-17
C194 (\15\:CKb VSS) capacitor c=6.18223e-17
C195 (\16\:CKb VSS) capacitor c=4.2145e-17
C196 (\10\:SN VSS) capacitor c=4.01325e-17
C197 (\11\:SN VSS) capacitor c=4.61727e-17
C198 (\7\:D VSS) capacitor c=4.72535e-17
C199 (\19\:n20 VSS) capacitor c=8.0144e-17
C200 (\20\:n20 VSS) capacitor c=8.09807e-17
C201 (\15\:RNb VSS) capacitor c=7.07284e-17
C202 (\16\:RNb VSS) capacitor c=8.29616e-17
C203 (\7\:mout VSS) capacitor c=1.55818e-16
C204 (\8\:mout VSS) capacitor c=5.28652e-17
C205 (\9\:mout VSS) capacitor c=1.04266e-16
C206 (\10\:mout VSS) capacitor c=8.64662e-17
C207 (\15\:mout VSS) capacitor c=6.04063e-17
C208 (\18\:mout VSS) capacitor c=7.19626e-17
C209 (\6\:SEb VSS) capacitor c=8.34493e-17
C210 (\7\:SEb VSS) capacitor c=6.92775e-17
C211 (\6\:n35 VSS) capacitor c=1.06598e-16
C212 (\19\:CKb VSS) capacitor c=3.86002e-17
C213 (\20\:CKb VSS) capacitor c=4.1645e-17
C214 (\8\:n35g VSS) capacitor c=3.50411e-17
C215 (\11\:n35 VSS) capacitor c=7.53442e-17
C216 (\15\:qbint VSS) capacitor c=8.75403e-17
C217 (\16\:qbint VSS) capacitor c=1.11665e-16
C218 (\13\:n35g VSS) capacitor c=1.02467e-16
C219 (\14\:n35g VSS) capacitor c=1.15714e-16
C220 (\5\:RTb VSS) capacitor c=4.93559e-17
C221 (\8\:RTb VSS) capacitor c=1.00362e-16
C222 (\9\:RTb VSS) capacitor c=9.12712e-17
C223 (\12\:SN VSS) capacitor c=8.24211e-17
C224 (\13\:SN VSS) capacitor c=8.01901e-17
C225 (\20\:CKbb VSS) capacitor c=1.33803e-16
C226 (\21\:CKbb VSS) capacitor c=1.33492e-16
C227 (\21\:qbint VSS) capacitor c=2.40592e-17
C228 (\22\:qbint VSS) capacitor c=2.9991e-17
C229 (\9\:RT VSS) capacitor c=1.10679e-16
C230 (\10\:RT VSS) capacitor c=1.17695e-16
C231 (\11\:RT VSS) capacitor c=5.56594e-17
C232 (\3\:QN VSS) capacitor c=3.33685e-17
C233 (\16\:n35 VSS) capacitor c=5.05282e-17
C234 (\7\:net573 VSS) capacitor c=5.04197e-17
C235 (\8\:net573 VSS) capacitor c=3.48307e-17
C236 (\3\:VDD VSS) capacitor c=3.01355e-17
C237 (\4\:VDD VSS) capacitor c=3.07325e-17
C238 (\6\:VDD VSS) capacitor c=9.78486e-18
C239 (\7\:VDD VSS) capacitor c=2.27379e-16
C240 (\8\:VDD VSS) capacitor c=2.02744e-16
C241 (\9\:VDD VSS) capacitor c=2.90114e-17
C242 (\11\:VDD VSS) capacitor c=5.32489e-17
C243 (\22\:VDD VSS) capacitor c=6.10398e-17
Rk80 (\2\:Q Q) resistor r=0.1725 c=0
Rk81 (Q \4\:Q) resistor r=0.3385 c=0
Rk19 (\5\:D D) resistor r=0.007241 c=0
Rk21 (\5\:D \7\:D) resistor r=0.01725 c=0
Rk20 (\6\:D \7\:D) resistor r=0.007241 c=0
Rk72 (\3\:QN QN) resistor r=0.02836 c=0
Rk71 (\2\:QN \3\:QN) resistor r=0.1971 c=0
Rk73 (\3\:QN \5\:QN) resistor r=0.3615 c=0
Rk112 (VDD VDD) resistor r=0.2377 c=0
Rk96 (\2\:VDD \3\:VDD) resistor r=0.34 c=0
Rk97 (\3\:VDD \4\:VDD) resistor r=0.2193 c=0
Rk98 (\4\:VDD \6\:VDD) resistor r=0.0672 c=0
Rk99 (\6\:VDD \7\:VDD) resistor r=0.05222 c=0
Rk100 (\7\:VDD \8\:VDD) resistor r=1.5323 c=0
Rk101 (\8\:VDD \9\:VDD) resistor r=0.1194 c=0
Rk102 (\9\:VDD \11\:VDD) resistor r=0.2226 c=0
Rk103 (\3\:VDD \13\:VDD) resistor r=0.3605 c=0
Rk104 (\4\:VDD \15\:VDD) resistor r=0.2961 c=0
Rk105 (\7\:VDD \17\:VDD) resistor r=0.3784 c=0
Rk106 (\8\:VDD \19\:VDD) resistor r=0.3704 c=0
Rk107 (\9\:VDD \21\:VDD) resistor r=0.2039 c=0
Rk111 (\22\:VDD VDD) resistor r=0.1968 c=0
Rk108 (\11\:VDD \22\:VDD) resistor r=0.172 c=0
Rk109 (\22\:VDD \24\:VDD) resistor r=0.2093 c=0
Rk110 (\11\:VDD \26\:VDD) resistor r=0.2416 c=0
Rk113 (VDD \28\:VDD) resistor r=0.3818 c=0
Rk52 (ExtVDD ExtVDD) resistor r=0.002073 c=0
Rk50 (\2\:ExtVDD ExtVDD) resistor r=0.02227 c=0
Rk53 (ExtVDD \5\:ExtVDD) resistor r=0.02025 c=0
Rk54 (ExtVDD \6\:ExtVDD) resistor r=0.1504 c=0
Rk13 (CK \6\:CK) resistor r=0.01226 c=0
Rk12 (\5\:CK \6\:CK) resistor r=0.004824 c=0
Rk84 (\2\:VSS \3\:VSS) resistor r=0.03225 c=0
Rk85 (\3\:VSS \4\:VSS) resistor r=0.5165 c=0
Rk86 (\4\:VSS \5\:VSS) resistor r=0.5194 c=0
Rk88 (\6\:VSS VSS) resistor r=0.04967 c=0
Rk87 (\5\:VSS \6\:VSS) resistor r=0.3293 c=0
Rk90 (\7\:VSS VSS) resistor r=0.1221 c=0
Rk89 (VSS \7\:VSS) resistor r=0.8989 c=0
Rk91 (VSS \8\:VSS) resistor r=0.01753 c=0
Rk92 (\8\:VSS \10\:VSS) resistor r=0.6682 c=0
Rk93 (\3\:VSS \12\:VSS) resistor r=0.2514 c=0
Rk94 (\5\:VSS \14\:VSS) resistor r=0.2463 c=0
Rk95 (\8\:VSS \16\:VSS) resistor r=0.2539 c=0
Rk114 (\18\:VSS \20\:VSS) resistor r=0.3648 c=0
Rk115 (\20\:VSS \21\:VSS) resistor r=0.2394 c=0
Rk116 (\21\:VSS \22\:VSS) resistor r=0.05971 c=0
Rk117 (\22\:VSS \23\:VSS) resistor r=0.6164 c=0
Rk118 (\23\:VSS \24\:VSS) resistor r=0.03225 c=0
Rk120 (\25\:VSS VSS) resistor r=0.1219 c=0
Rk119 (\24\:VSS \25\:VSS) resistor r=0.177 c=0
Rk121 (VSS \26\:VSS) resistor r=0.5242 c=0
Rk122 (\26\:VSS \27\:VSS) resistor r=0.3091 c=0
Rk124 (\28\:VSS VSS) resistor r=0.1221 c=0
Rk123 (\27\:VSS \28\:VSS) resistor r=0.0647 c=0
Rk125 (VSS \30\:VSS) resistor r=0.3149 c=0
Rk126 (\21\:VSS \32\:VSS) resistor r=0.2698 c=0
Rk127 (\23\:VSS \34\:VSS) resistor r=0.1914 c=0
Rk128 (\25\:VSS \36\:VSS) resistor r=0.1965 c=0
Rk129 (\26\:VSS \38\:VSS) resistor r=0.2562 c=0
Rk130 (\27\:VSS \40\:VSS) resistor r=0.2517 c=0
Rk17 (SN \10\:SN) resistor r=0.01165 c=0
Rk18 (\10\:SN \11\:SN) resistor r=0.3167 c=0
Rk65 (\12\:SN \13\:SN) resistor r=0.5417 c=0
Rk1 (\5\:RN RN) resistor r=0.008217 c=0
Rk68 (RT \9\:RT) resistor r=0.1927 c=0
Rk69 (\9\:RT \10\:RT) resistor r=0.6534 c=0
Rk70 (RT \11\:RT) resistor r=0.008064 c=0
Rk2 (\9\:n20 \11\:n20) resistor r=0.5491 c=0
Rk3 (\11\:n20 \12\:n20) resistor r=0.2569 c=0
Rk7 (\14\:n20 \15\:n20) resistor r=0.3492 c=0
Rk8 (\14\:n20 \16\:n20) resistor r=0.232 c=0
Rk9 (\16\:n20 \18\:n20) resistor r=0.5019 c=0
Rk25 (\19\:n20 \20\:n20) resistor r=0.4664 c=0
Rk6 (\13\:CKbb \14\:CKbb) resistor r=0.8583 c=0
Rk10 (\16\:CKbb \18\:CKbb) resistor r=0.5434 c=0
Rk11 (\18\:CKbb \19\:CKbb) resistor r=0.1435 c=0
Rk66 (\20\:CKbb \21\:CKbb) resistor r=0.8355 c=0
Rk30 (\6\:mout \7\:mout) resistor r=0.7703 c=0
Rk31 (\7\:mout \8\:mout) resistor r=0.3564 c=0
Rk32 (\8\:mout \9\:mout) resistor r=0.1729 c=0
Rk33 (\9\:mout \10\:mout) resistor r=0.3451 c=0
Rk34 (\7\:mout \12\:mout) resistor r=0.1244 c=0
Rk35 (\8\:mout \14\:mout) resistor r=0.1009 c=0
Rk36 (\9\:mout \15\:mout) resistor r=0.5302 c=0
Rk37 (\15\:mout \17\:mout) resistor r=0.04505 c=0
Rk38 (\10\:mout \18\:mout) resistor r=0.4297 c=0
Rk39 (\15\:mout \20\:mout) resistor r=0.03481 c=0
Rk4 (\11\:RNb \12\:RNb) resistor r=0.1652 c=0
Rk5 (\12\:RNb \14\:RNb) resistor r=0.3847 c=0
Rk27 (\15\:RNb \16\:RNb) resistor r=0.3502 c=0
Rk14 (\14\:CKb \15\:CKb) resistor r=0.3366 c=0
Rk15 (\15\:CKb \16\:CKb) resistor r=0.1634 c=0
Rk16 (\15\:CKb \18\:CKb) resistor r=0.1787 c=0
Rk45 (\19\:CKb \20\:CKb) resistor r=0.3756 c=0
Rk40 (\5\:SEb \6\:SEb) resistor r=0.2186 c=0
Rk41 (\6\:SEb \7\:SEb) resistor r=0.3586 c=0
Rk42 (\6\:SEb \9\:SEb) resistor r=0.3131 c=0
Rk46 (\7\:n35g \8\:n35g) resistor r=0.2763 c=0
Rk47 (\7\:n35g \10\:n35g) resistor r=0.6991 c=0
Rk58 (\12\:n35g \13\:n35g) resistor r=0.2457 c=0
Rk59 (\13\:n35g \14\:n35g) resistor r=0.5719 c=0
Rk60 (\13\:n35g \16\:n35g) resistor r=0.4367 c=0
Rk55 (\15\:qbint \16\:qbint) resistor r=0.5002 c=0
Rk56 (\16\:qbint \18\:qbint) resistor r=0.5734 c=0
Rk57 (\16\:qbint \20\:qbint) resistor r=0.1479 c=0
Rk67 (\21\:qbint \22\:qbint) resistor r=0.2141 c=0
Rk61 (\5\:RTb \7\:RTb) resistor r=0.2186 c=0
Rk62 (\7\:RTb \8\:RTb) resistor r=0.4212 c=0
Rk63 (\8\:RTb \9\:RTb) resistor r=0.6964 c=0
Rk64 (\8\:RTb \11\:RTb) resistor r=0.31 c=0
Rk76 (\6\:net573 \7\:net573) resistor r=0.2387 c=0
Rk77 (\7\:net573 \8\:net573) resistor r=0.1669 c=0
Rk78 (\7\:net573 \10\:net573) resistor r=0.2869 c=0
Rk43 (\5\:n35 \6\:n35) resistor r=0.4337 c=0
Rk44 (\6\:n35 \8\:n35) resistor r=0.306 c=0
Rk48 (\10\:n35 \11\:n35) resistor r=0.4054 c=0
Rk49 (\11\:n35 \13\:n35) resistor r=0.3336 c=0
Rk74 (\15\:n35 \16\:n35) resistor r=0.3071 c=0
Rk75 (\16\:n35 \18\:n35) resistor r=0.2906 c=0
Rk22 (\2\:Db \4\:Db) resistor r=0.6434 c=0
Rk23 (\4\:Db \6\:Db) resistor r=1.436 c=0
Rk24 (\6\:Db \8\:Db) resistor r=0.5713 c=0
Rk82 (\2\:n11 \4\:n11) resistor r=0.7216 c=0
Rk83 (\2\:n8 \4\:n8) resistor r=0.536 c=0
Rk79 (\2\:n10 \4\:n10) resistor r=0.6325 c=0
Rk26 (\2\:n4 \4\:n4) resistor r=0.5583 c=0
Rl16 (\2\:D \4\:D) resistor r=115.099 c=0
Rl14 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl15 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl27 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl29 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl26 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl28 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl25 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl12 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl10 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl11 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl83 (\7\:SN \8\:SN) resistor r=237.735 c=0
Rl84 (\8\:SN \9\:SN) resistor r=491.014 c=0
Rl13 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl61 (\4\:SN \6\:SN) resistor r=95.229 c=0
Rl59 (\3\:SN \4\:SN) resistor r=1129.61 c=0
Rl60 (\4\:SN \5\:SN) resistor r=14.5488 c=0
Rl24 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl23 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl58 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl45 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl48 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl47 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl46 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl19 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl17 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl18 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl4 (n20 \2\:n20) resistor r=123.512 c=0
Rl64 (\11\:CKbb \12\:CKbb) resistor r=166.412 c=0
Rl5 (CKbb \2\:CKbb) resistor r=50.7843 c=0
Rl6 (\2\:CKbb \3\:CKbb) resistor r=64.7751 c=0
Rl7 (\2\:CKbb \4\:CKbb) resistor r=266.141 c=0
Rl53 (\5\:CKbb \6\:CKbb) resistor r=66.1349 c=0
Rl56 (\6\:CKbb \9\:CKbb) resistor r=762.322 c=0
Rl57 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl55 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl54 (\6\:CKbb \7\:CKbb) resistor r=462.851 c=0
Rl8 (mout \2\:mout) resistor r=24.2328 c=0
Rl9 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl69 (\3\:RNb \4\:RNb) resistor r=234.8 c=0
Rl22 (RNb \2\:RNb) resistor r=62.7075 c=0
Rl70 (\4\:RNb \5\:RNb) resistor r=1411.82 c=0
Rl73 (\5\:RNb \8\:RNb) resistor r=2.7666 c=0
Rl74 (\6\:RNb \9\:RNb) resistor r=75.8186 c=0
Rl72 (\6\:RNb \7\:RNb) resistor r=458.889 c=0
Rl71 (\5\:RNb \6\:RNb) resistor r=64.6153 c=0
Rl65 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl30 (CKb \2\:CKb) resistor r=349.798 c=0
Rl35 (\2\:CKb \7\:CKb) resistor r=127.816 c=0
Rl32 (\3\:CKb \4\:CKb) resistor r=103.952 c=0
Rl36 (\3\:CKb \8\:CKb) resistor r=147.793 c=0
Rl31 (\2\:CKb \3\:CKb) resistor r=431.465 c=0
Rl33 (\4\:CKb \5\:CKb) resistor r=63.8165 c=0
Rl37 (\5\:CKb \9\:CKb) resistor r=126.273 c=0
Rl34 (\5\:CKb \6\:CKb) resistor r=264.86 c=0
Rl38 (\5\:CKb \10\:CKb) resistor r=4.0236 c=0
Rl20 (SEb \2\:SEb) resistor r=101.718 c=0
Rl21 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl41 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl39 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl40 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl42 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl75 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl80 (\11\:qbint \12\:qbint) resistor r=237.758 c=0
Rl82 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl52 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl49 (qbint \2\:qbint) resistor r=112.732 c=0
Rl51 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl50 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl76 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl79 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl81 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl78 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl77 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl43 (RTb \2\:RTb) resistor r=112.412 c=0
Rl44 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl66 (net573 \2\:net573) resistor r=3.1216 c=0
Rl67 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl68 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl62 (n35 \2\:n35) resistor r=508.667 c=0
Rl63 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz25 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz20 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz28 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz29 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz30 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz31 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz34 (\17\:VSS \18\:VSS) resistor r=37.5 c=0
Rz35 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz36 (\31\:VSS \32\:VSS) resistor r=37.5 c=0
Rz37 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz38 (\35\:VSS \36\:VSS) resistor r=75 c=0
Rz39 (\37\:VSS \38\:VSS) resistor r=75 c=0
Rz40 (\39\:VSS \40\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz3 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz4 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz10 (\11\:mout \12\:mout) resistor r=75 c=0
Rz11 (\13\:mout \14\:mout) resistor r=75 c=0
Rz2 (\13\:RNb \14\:RNb) resistor r=75 c=0
Rz5 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz12 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz14 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz18 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz17 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz19 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz22 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz13 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz15 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz21 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz26 (n8 \2\:n8) resistor r=75 c=0
Rz27 (\3\:n8 \4\:n8) resistor r=75 c=0
Rz23 (n10 \2\:n10) resistor r=75 c=0
Rz24 (\3\:n10 \4\:n10) resistor r=75 c=0
Rz8 (n4 \2\:n4) resistor r=75 c=0
Rz9 (\3\:n4 \4\:n4) resistor r=75 c=0
Ry24 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry21 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry31 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry32 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry33 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry34 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry35 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry36 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry37 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry38 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry39 (\27\:VDD \28\:VDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry17 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry27 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry28 (\1\:VSS \4\:VSS) resistor r=6.2 c=0
Ry29 (\1\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry30 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry40 (\19\:VSS \20\:VSS) resistor r=12.4 c=0
Ry41 (\19\:VSS \22\:VSS) resistor r=62 c=0
Ry42 (\19\:VSS \24\:VSS) resistor r=5.1667 c=0
Ry43 (\19\:VSS \28\:VSS) resistor r=5.1667 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry3 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry4 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry8 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\16\:mout \17\:mout) resistor r=62 c=0
Ry10 (\19\:mout \20\:mout) resistor r=62 c=0
Ry2 (\10\:RNb \11\:RNb) resistor r=62 c=0
Ry5 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry11 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry13 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry19 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry18 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry20 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry23 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry12 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry14 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry22 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Ry25 (n11 \2\:n11) resistor r=62 c=0
Ry26 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx13 (\3\:D \6\:D) resistor r=45 c=0
Rx19 (\1\:SE SE) resistor r=45 c=0
Rx9 (\3\:CK \5\:CK) resistor r=45 c=0
Rx11 (\5\:SN \10\:SN) resistor r=45 c=0
Rx12 (\2\:SN \11\:SN) resistor r=45 c=0
Rx32 (\3\:SN \12\:SN) resistor r=45 c=0
Rx33 (\9\:SN \13\:SN) resistor r=45 c=0
Rx18 (\2\:SI SI) resistor r=45 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx38 (\3\:RT \9\:RT) resistor r=45 c=0
Rx39 (\1\:RT \10\:RT) resistor r=45 c=0
Rx40 (\7\:RT \11\:RT) resistor r=45 c=0
Rx2 (n20 \12\:n20) resistor r=45 c=0
Rx6 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx7 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx14 (\7\:n20 \19\:n20) resistor r=45 c=0
Rx15 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx4 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx5 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx8 (CKbb \19\:CKbb) resistor r=45 c=0
Rx34 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx35 (\9\:CKbb \21\:CKbb) resistor r=45 c=0
Rx20 (\4\:mout \10\:mout) resistor r=45 c=0
Rx21 (\2\:mout \18\:mout) resistor r=45 c=0
Rx3 (\7\:RNb \12\:RNb) resistor r=45 c=0
Rx16 (\8\:RNb \15\:RNb) resistor r=45 c=0
Rx17 (\2\:RNb \16\:RNb) resistor r=45 c=0
Rx10 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx24 (CKb \19\:CKb) resistor r=45 c=0
Rx25 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx22 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx26 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx29 (n35g \14\:n35g) resistor r=45 c=0
Rx28 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx36 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx37 (qbint \22\:qbint) resistor r=45 c=0
Rx30 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx31 (RTb \9\:RTb) resistor r=45 c=0
Rx42 (net573 \8\:net573) resistor r=45 c=0
Rx23 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx27 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx41 (n35 \16\:n35) resistor r=45 c=0
mn22 (\13\:RNb \4\:RN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (\7\:Db \6\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \9\:CKb \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (\3\:n4 \6\:SN \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.858e-14 ps=6.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 \3\:n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn31 (\11\:mout RNb n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn13 (n2 \1\:SI \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \5\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb \3\:n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \31\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn56 (\5\:net573 \14\:qbint \31\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn51 (n10 \3\:RNb \3\:n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n10 \12\:qbint n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn50 (n8 \8\:SN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp25 (\10\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
mp36 (\13\:n20 \8\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\17\:CKb \4\:CK \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\16\:mout \1\:SN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp32 (\19\:mout \3\:n20 n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp31 (n5 \9\:RNb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.44121 \
        scb=0.00199344 scc=3.60278e-06 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp51 (n9 \4\:RNb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (n11 \11\:qbint n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\3\:Q \7\:qbint \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
mp50 (n11 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.4549 \
        scb=0.0114313 scc=0.00019992 m=(1)
ends SRDFFSRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:07:19 2012 )
// Library name: gsclib045
// Cell name: SRDFFSX1
// View name: extracted

simulator lang=spectre

subckt SRDFFSX1 CK D ExtVDD Q QN RT SE SI SN VDD VSS
mp25 (\10\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (Q VSS) capacitor c=5.88779e-17
C2 (D VSS) capacitor c=7.95582e-17
C3 (QN VSS) capacitor c=1.89066e-17
C4 (CK VSS) capacitor c=7.48802e-17
C5 (SI VSS) capacitor c=8.73684e-17
C6 (RT VSS) capacitor c=6.46039e-17
C7 (ExtVDD VSS) capacitor c=2.26793e-16
C8 (SN VSS) capacitor c=5.16294e-17
C9 (VDD VSS) capacitor c=7.47013e-16
C10 (SE VSS) capacitor c=9.25495e-17
C11 (n20 VSS) capacitor c=3.84704e-17
C12 (CKbb VSS) capacitor c=2.98958e-17
C13 (mout VSS) capacitor c=5.41849e-17
C14 (CKb VSS) capacitor c=5.04575e-17
C15 (SEb VSS) capacitor c=7.75157e-17
C16 (n35g VSS) capacitor c=1.7772e-17
C17 (qbint VSS) capacitor c=4.57835e-17
C18 (RTb VSS) capacitor c=5.17974e-17
C19 (net573 VSS) capacitor c=2.25505e-17
C20 (n35 VSS) capacitor c=1.72515e-16
C21 (Db VSS) capacitor c=1.02659e-16
C22 (n11 VSS) capacitor c=7.99274e-17
C23 (n1 VSS) capacitor c=1.02126e-18
C24 (\7\:qbint VSS) capacitor c=3.28246e-17
C25 (\7\:SN VSS) capacitor c=8.60102e-17
C26 (\11\:qbint VSS) capacitor c=1.07191e-16
C27 (\13\:qbint VSS) capacitor c=4.38863e-17
C28 (\3\:net573 VSS) capacitor c=5.86658e-17
C29 (\11\:CKbb VSS) capacitor c=4.51636e-17
C30 (\4\:RTb VSS) capacitor c=9.88373e-17
C31 (\6\:RT VSS) capacitor c=2.23208e-17
C32 (\4\:qbint VSS) capacitor c=5.36612e-17
C33 (\3\:n35g VSS) capacitor c=5.1929e-17
C34 (\5\:RT VSS) capacitor c=6.48597e-17
C35 (\3\:SE VSS) capacitor c=7.72628e-17
C36 (\7\:CKb VSS) capacitor c=3.10427e-17
C37 (\3\:SI VSS) capacitor c=9.47876e-17
C38 (\4\:SE VSS) capacitor c=1.22542e-16
C39 (\3\:n20 VSS) capacitor c=2.47551e-17
C40 (\4\:D VSS) capacitor c=7.11031e-17
C41 (\1\:SN VSS) capacitor c=3.03251e-17
C42 (\4\:CK VSS) capacitor c=5.78548e-17
C43 (\4\:CKb VSS) capacitor c=4.5846e-17
C44 (\8\:CKb VSS) capacitor c=8.3611e-17
C45 (\3\:CKbb VSS) capacitor c=2.57688e-17
C46 (\6\:qbint VSS) capacitor c=3.83344e-17
C47 (\14\:qbint VSS) capacitor c=4.62185e-17
C48 (\8\:SN VSS) capacitor c=1.45704e-16
C49 (\12\:qbint VSS) capacitor c=1.48984e-16
C50 (\4\:net573 VSS) capacitor c=3.67878e-17
C51 (\11\:CKb VSS) capacitor c=2.53721e-16
C52 (\8\:RT VSS) capacitor c=1.21316e-16
C53 (\2\:RT VSS) capacitor c=6.21869e-17
C54 (\5\:qbint VSS) capacitor c=3.89021e-17
C55 (\5\:n35g VSS) capacitor c=3.28693e-17
C56 (\2\:RTb VSS) capacitor c=4.64921e-17
C57 (\5\:SE VSS) capacitor c=5.7365e-17
C58 (\5\:CKbb VSS) capacitor c=2.72722e-17
C59 (\1\:SI VSS) capacitor c=4.90982e-17
C60 (\6\:SE VSS) capacitor c=8.63749e-17
C61 (\3\:SEb VSS) capacitor c=6.59302e-17
C62 (\1\:D VSS) capacitor c=4.94494e-17
C63 (\6\:n20 VSS) capacitor c=8.23106e-17
C64 (\6\:SN VSS) capacitor c=7.01056e-17
C65 (\1\:CK VSS) capacitor c=2.87489e-17
C66 (\3\:mout VSS) capacitor c=4.47479e-17
C67 (\9\:CKb VSS) capacitor c=3.64392e-17
C68 (\10\:CKbb VSS) capacitor c=4.84288e-17
C69 (\6\:CKb VSS) capacitor c=4.93311e-17
C70 (\10\:qbint VSS) capacitor c=8.42187e-17
C71 (\12\:CKbb VSS) capacitor c=5.14498e-17
C72 (\3\:SN VSS) capacitor c=2.84633e-16
C73 (\9\:SN VSS) capacitor c=6.35258e-17
C74 (\7\:RT VSS) capacitor c=1.445e-16
C75 (\9\:CKbb VSS) capacitor c=1.67836e-16
C76 (\3\:RT VSS) capacitor c=3.94588e-17
C77 (\1\:RT VSS) capacitor c=5.29002e-17
C78 (\3\:RTb VSS) capacitor c=7.5942e-17
C79 (\3\:qbint VSS) capacitor c=4.44019e-17
C80 (\2\:n35 VSS) capacitor c=2.52896e-16
C81 (\4\:n35g VSS) capacitor c=6.67426e-17
C82 (\12\:CKb VSS) capacitor c=2.18493e-16
C83 (\3\:n35 VSS) capacitor c=1.16031e-16
C84 (\1\:SE VSS) capacitor c=2.47752e-17
C85 (\2\:SI VSS) capacitor c=7.74104e-17
C86 (\2\:SEb VSS) capacitor c=7.84364e-17
C87 (\7\:n20 VSS) capacitor c=4.70827e-17
C88 (\4\:n20 VSS) capacitor c=7.28737e-17
C89 (\3\:D VSS) capacitor c=1.51045e-17
C90 (\2\:SN VSS) capacitor c=4.20762e-17
C91 (\5\:SN VSS) capacitor c=2.65613e-17
C92 (\3\:CK VSS) capacitor c=2.31437e-17
C93 (\2\:mout VSS) capacitor c=4.66573e-17
C94 (\4\:mout VSS) capacitor c=2.82052e-17
C95 (\10\:CKb VSS) capacitor c=2.21463e-17
C96 (\5\:n20 VSS) capacitor c=7.87098e-17
C97 (\4\:CKbb VSS) capacitor c=6.32587e-17
C98 (\8\:CKbb VSS) capacitor c=2.44292e-17
C99 (\2\:n20 VSS) capacitor c=3.95634e-17
C100 (\1\:VDD VSS) capacitor c=4.33505e-17
C101 (\12\:VDD VSS) capacitor c=2.78404e-17
C102 (\3\:Q VSS) capacitor c=7.97765e-17
C103 (\14\:VDD VSS) capacitor c=5.29599e-17
C104 (\9\:net573 VSS) capacitor c=5.55504e-17
C105 (\16\:VDD VSS) capacitor c=7.97455e-17
C106 (\3\:n11 VSS) capacitor c=8.48924e-17
C107 (\4\:QN VSS) capacitor c=6.86594e-17
C108 (\14\:n35 VSS) capacitor c=5.21976e-17
C109 (\15\:n35g VSS) capacitor c=5.5909e-17
C110 (\6\:RTb VSS) capacitor c=7.27087e-17
C111 (\1\:ExtVDD VSS) capacitor c=2.77768e-16
C112 (\9\:n35 VSS) capacitor c=6.20489e-17
C113 (\17\:qbint VSS) capacitor c=6.81911e-17
C114 (\6\:n35g VSS) capacitor c=9.39178e-17
C115 (\8\:SEb VSS) capacitor c=5.06012e-17
C116 (\4\:n35 VSS) capacitor c=6.29062e-17
C117 (\18\:VDD VSS) capacitor c=6.10013e-17
C118 (\5\:mout VSS) capacitor c=8.78996e-17
C119 (\3\:Db VSS) capacitor c=1.94197e-16
C120 (\20\:VDD VSS) capacitor c=5.06609e-17
C121 (\19\:mout VSS) capacitor c=3.95742e-17
C122 (\25\:VDD VSS) capacitor c=3.45959e-17
C123 (\16\:mout VSS) capacitor c=4.39997e-17
C124 (\17\:CKb VSS) capacitor c=2.98518e-17
C125 (\23\:VDD VSS) capacitor c=4.83128e-17
C126 (\17\:CKbb VSS) capacitor c=6.82922e-17
C127 (\13\:n20 VSS) capacitor c=6.05939e-17
C128 (\5\:Db VSS) capacitor c=2.29715e-16
C129 (\10\:n20 VSS) capacitor c=6.36434e-17
C130 (\1\:Q VSS) capacitor c=5.32881e-17
C131 (\5\:net573 VSS) capacitor c=4.31107e-17
C132 (\1\:QN VSS) capacitor c=3.95495e-17
C133 (\17\:n35 VSS) capacitor c=3.9291e-17
C134 (\11\:n35g VSS) capacitor c=2.96827e-17
C135 (\10\:RTb VSS) capacitor c=5.81982e-17
C136 (\12\:n35 VSS) capacitor c=6.35981e-17
C137 (\19\:qbint VSS) capacitor c=2.43447e-17
C138 (\9\:n35g VSS) capacitor c=8.04088e-17
C139 (\4\:SEb VSS) capacitor c=3.94714e-17
C140 (\7\:n35 VSS) capacitor c=4.09459e-17
C141 (\11\:mout VSS) capacitor c=2.19228e-17
C142 (\13\:mout VSS) capacitor c=1.77684e-17
C143 (\13\:CKb VSS) capacitor c=5.69102e-17
C144 (\15\:CKbb VSS) capacitor c=8.68125e-17
C145 (\17\:n20 VSS) capacitor c=8.69141e-17
C146 (\7\:Db VSS) capacitor c=7.83291e-17
C147 (\8\:n20 VSS) capacitor c=5.88588e-17
C148 (VDD VSS) capacitor c=4.23916e-17
C149 (\2\:CKbb VSS) capacitor c=6.33399e-17
C150 (\2\:CK VSS) capacitor c=3.70344e-17
C151 (\2\:D VSS) capacitor c=3.58843e-17
C152 (\2\:SE VSS) capacitor c=2.5012e-17
C153 (\2\:CKb VSS) capacitor c=1.47509e-16
C154 (\3\:CKb VSS) capacitor c=8.67096e-17
C155 (\5\:CKb VSS) capacitor c=5.70483e-17
C156 (\2\:n35g VSS) capacitor c=2.91068e-17
C157 (\4\:RT VSS) capacitor c=4.60748e-17
C158 (\2\:qbint VSS) capacitor c=4.13305e-17
C159 (\6\:CKbb VSS) capacitor c=1.2768e-16
C160 (\7\:CKbb VSS) capacitor c=7.19841e-17
C161 (\4\:SN VSS) capacitor c=2.47908e-16
C162 (\2\:net573 VSS) capacitor c=1.5265e-17
C163 (\12\:n20 VSS) capacitor c=4.44175e-17
C164 (\13\:CKbb VSS) capacitor c=9.9031e-17
C165 (\14\:CKbb VSS) capacitor c=9.72819e-17
C166 (\15\:n20 VSS) capacitor c=5.20721e-17
C167 (\16\:n20 VSS) capacitor c=9.21474e-17
C168 (\8\:qbint VSS) capacitor c=4.48796e-17
C169 (\9\:qbint VSS) capacitor c=6.56685e-17
C170 (\19\:CKbb VSS) capacitor c=5.18124e-17
C171 (\15\:CKb VSS) capacitor c=6.00279e-17
C172 (\16\:CKb VSS) capacitor c=3.92201e-17
C173 (\10\:SN VSS) capacitor c=3.93965e-17
C174 (\11\:SN VSS) capacitor c=4.44027e-17
C175 (\19\:n20 VSS) capacitor c=6.57619e-17
C176 (\20\:n20 VSS) capacitor c=7.69525e-17
C177 (\7\:mout VSS) capacitor c=8.21686e-17
C178 (\8\:mout VSS) capacitor c=4.27767e-17
C179 (\9\:mout VSS) capacitor c=9.97875e-17
C180 (\10\:mout VSS) capacitor c=8.77644e-17
C181 (\15\:mout VSS) capacitor c=6.71878e-17
C182 (\18\:mout VSS) capacitor c=7.29698e-17
C183 (\6\:SEb VSS) capacitor c=8.36943e-17
C184 (\7\:SEb VSS) capacitor c=6.95574e-17
C185 (\6\:n35 VSS) capacitor c=7.82109e-17
C186 (\19\:CKb VSS) capacitor c=3.91478e-17
C187 (\20\:CKb VSS) capacitor c=4.23519e-17
C188 (\8\:n35g VSS) capacitor c=3.45284e-17
C189 (\11\:n35 VSS) capacitor c=7.50221e-17
C190 (\15\:qbint VSS) capacitor c=8.78471e-17
C191 (\16\:qbint VSS) capacitor c=1.11964e-16
C192 (\13\:n35g VSS) capacitor c=1.02391e-16
C193 (\14\:n35g VSS) capacitor c=1.1611e-16
C194 (\5\:RTb VSS) capacitor c=4.94791e-17
C195 (\8\:RTb VSS) capacitor c=9.93242e-17
C196 (\9\:RTb VSS) capacitor c=9.14752e-17
C197 (\10\:RT VSS) capacitor c=1.09503e-16
C198 (\11\:RT VSS) capacitor c=1.1814e-16
C199 (\12\:SN VSS) capacitor c=8.30194e-17
C200 (\13\:SN VSS) capacitor c=7.94276e-17
C201 (\20\:CKbb VSS) capacitor c=1.30835e-16
C202 (\21\:CKbb VSS) capacitor c=1.34343e-16
C203 (\21\:qbint VSS) capacitor c=2.41935e-17
C204 (\22\:qbint VSS) capacitor c=3.00163e-17
C205 (\3\:QN VSS) capacitor c=3.12928e-17
C206 (\16\:n35 VSS) capacitor c=4.52226e-17
C207 (\7\:net573 VSS) capacitor c=5.43172e-17
C208 (\8\:net573 VSS) capacitor c=3.52344e-17
C209 (\3\:VDD VSS) capacitor c=2.70942e-17
C210 (\4\:VDD VSS) capacitor c=2.45956e-17
C211 (\6\:VDD VSS) capacitor c=9.10299e-18
C212 (\7\:VDD VSS) capacitor c=2.13361e-16
C213 (\8\:VDD VSS) capacitor c=2.06955e-16
C214 (\9\:VDD VSS) capacitor c=2.63757e-17
C215 (\11\:VDD VSS) capacitor c=4.71375e-17
C216 (\22\:VDD VSS) capacitor c=6.14773e-17
Rk72 (\2\:Q Q) resistor r=0.1675 c=0
Rk73 (Q \4\:Q) resistor r=0.332 c=0
Rk64 (\3\:QN QN) resistor r=0.03624 c=0
Rk63 (\2\:QN \3\:QN) resistor r=0.1939 c=0
Rk65 (\3\:QN \5\:QN) resistor r=0.3451 c=0
Rk74 (\2\:VSS \4\:VSS) resistor r=0.3626 c=0
Rk75 (\4\:VSS \5\:VSS) resistor r=0.2384 c=0
Rk76 (\5\:VSS \6\:VSS) resistor r=0.05947 c=0
Rk77 (\6\:VSS \7\:VSS) resistor r=0.6138 c=0
Rk78 (\7\:VSS \8\:VSS) resistor r=0.03212 c=0
Rk80 (\9\:VSS VSS) resistor r=0.1214 c=0
Rk79 (\8\:VSS \9\:VSS) resistor r=0.1763 c=0
Rk81 (VSS \10\:VSS) resistor r=0.5221 c=0
Rk82 (\10\:VSS \11\:VSS) resistor r=0.3079 c=0
Rk84 (\12\:VSS VSS) resistor r=0.1216 c=0
Rk83 (\11\:VSS \12\:VSS) resistor r=0.06444 c=0
Rk85 (VSS \14\:VSS) resistor r=0.313 c=0
Rk86 (\5\:VSS \16\:VSS) resistor r=0.2678 c=0
Rk87 (\7\:VSS \18\:VSS) resistor r=0.19 c=0
Rk88 (\9\:VSS \20\:VSS) resistor r=0.1951 c=0
Rk89 (\10\:VSS \22\:VSS) resistor r=0.2543 c=0
Rk90 (\11\:VSS \24\:VSS) resistor r=0.2499 c=0
Rk108 (\26\:VSS \27\:VSS) resistor r=0.1813 c=0
Rk109 (\27\:VSS \28\:VSS) resistor r=0.3652 c=0
Rk110 (\28\:VSS \29\:VSS) resistor r=0.3681 c=0
Rk112 (\30\:VSS VSS) resistor r=0.04947 c=0
Rk111 (\29\:VSS \30\:VSS) resistor r=0.3279 c=0
Rk114 (\31\:VSS VSS) resistor r=0.1216 c=0
Rk113 (VSS \31\:VSS) resistor r=0.8951 c=0
Rk115 (VSS \33\:VSS) resistor r=0.3043 c=0
Rk116 (\27\:VSS \35\:VSS) resistor r=0.2357 c=0
Rk117 (\29\:VSS \37\:VSS) resistor r=0.2445 c=0
Rk118 (\33\:VSS \38\:VSS) resistor r=0.1028 c=0
Rk58 (RT \10\:RT) resistor r=0.1993 c=0
Rk59 (\10\:RT \11\:RT) resistor r=0.6488 c=0
Rk44 (ExtVDD ExtVDD) resistor r=0.002066 c=0
Rk42 (\2\:ExtVDD ExtVDD) resistor r=0.02219 c=0
Rk45 (ExtVDD \5\:ExtVDD) resistor r=0.02018 c=0
Rk46 (ExtVDD \6\:ExtVDD) resistor r=0.1499 c=0
Rk13 (SN \10\:SN) resistor r=0.0106 c=0
Rk14 (\10\:SN \11\:SN) resistor r=0.3153 c=0
Rk60 (\12\:SN \13\:SN) resistor r=0.538 c=0
Rk107 (VDD VDD) resistor r=0.2362 c=0
Rk91 (\2\:VDD \3\:VDD) resistor r=0.3819 c=0
Rk92 (\3\:VDD \4\:VDD) resistor r=0.1963 c=0
Rk93 (\4\:VDD \6\:VDD) resistor r=0.06692 c=0
Rk94 (\6\:VDD \7\:VDD) resistor r=0.05201 c=0
Rk95 (\7\:VDD \8\:VDD) resistor r=1.5259 c=0
Rk96 (\8\:VDD \9\:VDD) resistor r=0.1711 c=0
Rk97 (\9\:VDD \11\:VDD) resistor r=0.1695 c=0
Rk98 (\3\:VDD \13\:VDD) resistor r=0.32 c=0
Rk99 (\4\:VDD \15\:VDD) resistor r=0.3026 c=0
Rk100 (\7\:VDD \17\:VDD) resistor r=0.3757 c=0
Rk101 (\8\:VDD \19\:VDD) resistor r=0.3677 c=0
Rk102 (\9\:VDD \21\:VDD) resistor r=0.2078 c=0
Rk106 (\22\:VDD VDD) resistor r=0.1959 c=0
Rk103 (\11\:VDD \22\:VDD) resistor r=0.1713 c=0
Rk104 (\22\:VDD \24\:VDD) resistor r=0.2078 c=0
Rk105 (\11\:VDD \26\:VDD) resistor r=0.2399 c=0
Rk1 (\9\:n20 \11\:n20) resistor r=0.5452 c=0
Rk2 (\11\:n20 \12\:n20) resistor r=0.2551 c=0
Rk4 (\14\:n20 \15\:n20) resistor r=0.3416 c=0
Rk5 (\14\:n20 \16\:n20) resistor r=0.2303 c=0
Rk6 (\16\:n20 \18\:n20) resistor r=0.4984 c=0
Rk19 (\19\:n20 \20\:n20) resistor r=0.4375 c=0
Rk3 (\13\:CKbb \14\:CKbb) resistor r=0.7542 c=0
Rk7 (\16\:CKbb \18\:CKbb) resistor r=0.532 c=0
Rk8 (\18\:CKbb \19\:CKbb) resistor r=0.2044 c=0
Rk61 (\20\:CKbb \21\:CKbb) resistor r=0.8279 c=0
Rk20 (\6\:mout \7\:mout) resistor r=0.6045 c=0
Rk21 (\7\:mout \8\:mout) resistor r=0.3058 c=0
Rk22 (\8\:mout \9\:mout) resistor r=0.1684 c=0
Rk23 (\9\:mout \10\:mout) resistor r=0.3479 c=0
Rk24 (\7\:mout \12\:mout) resistor r=0.1284 c=0
Rk25 (\8\:mout \14\:mout) resistor r=0.09239 c=0
Rk26 (\9\:mout \15\:mout) resistor r=0.5264 c=0
Rk27 (\15\:mout \17\:mout) resistor r=0.0449 c=0
Rk28 (\10\:mout \18\:mout) resistor r=0.4268 c=0
Rk29 (\15\:mout \20\:mout) resistor r=0.03469 c=0
Rk10 (\14\:CKb \15\:CKb) resistor r=0.318 c=0
Rk11 (\15\:CKb \16\:CKb) resistor r=0.1585 c=0
Rk12 (\15\:CKb \18\:CKb) resistor r=0.1872 c=0
Rk37 (\19\:CKb \20\:CKb) resistor r=0.3729 c=0
Rk32 (\5\:SEb \6\:SEb) resistor r=0.217 c=0
Rk33 (\6\:SEb \7\:SEb) resistor r=0.3559 c=0
Rk34 (\6\:SEb \9\:SEb) resistor r=0.3109 c=0
Rk38 (\7\:n35g \8\:n35g) resistor r=0.2744 c=0
Rk39 (\7\:n35g \10\:n35g) resistor r=0.6943 c=0
Rk50 (\12\:n35g \13\:n35g) resistor r=0.2439 c=0
Rk51 (\13\:n35g \14\:n35g) resistor r=0.5678 c=0
Rk52 (\13\:n35g \16\:n35g) resistor r=0.4337 c=0
Rk47 (\15\:qbint \16\:qbint) resistor r=0.4966 c=0
Rk48 (\16\:qbint \18\:qbint) resistor r=0.5694 c=0
Rk49 (\16\:qbint \20\:qbint) resistor r=0.1469 c=0
Rk62 (\21\:qbint \22\:qbint) resistor r=0.2126 c=0
Rk53 (\5\:RTb \7\:RTb) resistor r=0.2171 c=0
Rk54 (\7\:RTb \8\:RTb) resistor r=0.4182 c=0
Rk55 (\8\:RTb \9\:RTb) resistor r=0.6914 c=0
Rk56 (\8\:RTb \11\:RTb) resistor r=0.3078 c=0
Rk68 (\6\:net573 \7\:net573) resistor r=0.2375 c=0
Rk69 (\7\:net573 \8\:net573) resistor r=0.1656 c=0
Rk70 (\7\:net573 \10\:net573) resistor r=0.2849 c=0
Rk35 (\5\:n35 \6\:n35) resistor r=0.4114 c=0
Rk36 (\6\:n35 \8\:n35) resistor r=0.2915 c=0
Rk40 (\10\:n35 \11\:n35) resistor r=0.4026 c=0
Rk41 (\11\:n35 \13\:n35) resistor r=0.3312 c=0
Rk66 (\15\:n35 \16\:n35) resistor r=0.305 c=0
Rk67 (\16\:n35 \18\:n35) resistor r=0.2683 c=0
Rk16 (\2\:Db \4\:Db) resistor r=0.6389 c=0
Rk17 (\4\:Db \6\:Db) resistor r=1.4324 c=0
Rk18 (\6\:Db \8\:Db) resistor r=0.5673 c=0
Rk71 (\2\:n11 \4\:n11) resistor r=0.6555 c=0
Rl13 (\2\:D \4\:D) resistor r=115.099 c=0
Rl11 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl12 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl9 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl7 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl8 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl20 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl19 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl54 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl41 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl44 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl43 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl42 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl65 (\7\:SN \8\:SN) resistor r=367.487 c=0
Rl66 (\8\:SN \9\:SN) resistor r=284.764 c=0
Rl10 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl57 (\4\:SN \6\:SN) resistor r=115.884 c=0
Rl55 (\3\:SN \4\:SN) resistor r=1092.88 c=0
Rl56 (\4\:SN \5\:SN) resistor r=66.1252 c=0
Rl23 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl25 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl22 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl24 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl21 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl16 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl14 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl15 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl1 (n20 \2\:n20) resistor r=123.512 c=0
Rl60 (\11\:CKbb \12\:CKbb) resistor r=166.412 c=0
Rl2 (CKbb \2\:CKbb) resistor r=38.8525 c=0
Rl3 (\2\:CKbb \3\:CKbb) resistor r=68.4981 c=0
Rl4 (\2\:CKbb \4\:CKbb) resistor r=262.732 c=0
Rl49 (\5\:CKbb \6\:CKbb) resistor r=66.1349 c=0
Rl52 (\6\:CKbb \9\:CKbb) resistor r=762.322 c=0
Rl53 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl51 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl50 (\6\:CKbb \7\:CKbb) resistor r=462.851 c=0
Rl5 (mout \2\:mout) resistor r=24.2328 c=0
Rl6 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl61 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl26 (CKb \2\:CKb) resistor r=349.798 c=0
Rl31 (\2\:CKb \7\:CKb) resistor r=127.816 c=0
Rl28 (\3\:CKb \4\:CKb) resistor r=103.952 c=0
Rl32 (\3\:CKb \8\:CKb) resistor r=147.793 c=0
Rl27 (\2\:CKb \3\:CKb) resistor r=431.465 c=0
Rl29 (\4\:CKb \5\:CKb) resistor r=74.8465 c=0
Rl33 (\5\:CKb \9\:CKb) resistor r=132.539 c=0
Rl30 (\5\:CKb \6\:CKb) resistor r=266.282 c=0
Rl34 (\5\:CKb \10\:CKb) resistor r=4.3228 c=0
Rl17 (SEb \2\:SEb) resistor r=101.718 c=0
Rl18 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl37 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl35 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl36 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl38 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl67 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl74 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl72 (\11\:qbint \12\:qbint) resistor r=343.448 c=0
Rl48 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl45 (qbint \2\:qbint) resistor r=112.732 c=0
Rl47 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl46 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl68 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl71 (\8\:qbint \11\:qbint) resistor r=200.917 c=0
Rl73 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl70 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl69 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl39 (RTb \2\:RTb) resistor r=112.412 c=0
Rl40 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl62 (net573 \2\:net573) resistor r=3.1216 c=0
Rl63 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl64 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl58 (n35 \2\:n35) resistor r=508.667 c=0
Rl59 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz20 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz17 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz22 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz23 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz24 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz30 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz31 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz32 (\36\:VSS \37\:VSS) resistor r=75 c=0
Rz33 (\32\:VSS \38\:VSS) resistor r=75 c=0
Rz1 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz2 (\17\:n20 \18\:n20) resistor r=75 c=0
Rz3 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz7 (\11\:mout \12\:mout) resistor r=75 c=0
Rz8 (\13\:mout \14\:mout) resistor r=75 c=0
Rz4 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz9 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz19 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz18 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz5 (Db \2\:Db) resistor r=75 c=0
Rz6 (\7\:Db \8\:Db) resistor r=75 c=0
Ry25 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry20 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry26 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry27 (\3\:VSS \6\:VSS) resistor r=62 c=0
Ry28 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry29 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry38 (\25\:VSS \26\:VSS) resistor r=15.5 c=0
Ry39 (\25\:VSS \28\:VSS) resistor r=8.8571 c=0
Ry40 (\25\:VSS \30\:VSS) resistor r=8.8571 c=0
Ry41 (\25\:VSS \31\:VSS) resistor r=5.1667 c=0
Ry14 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry16 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry30 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry31 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry32 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry33 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry34 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry35 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry36 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry37 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry1 (\10\:n20 \11\:n20) resistor r=62 c=0
Ry2 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry3 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\16\:mout \17\:mout) resistor r=62 c=0
Ry9 (\19\:mout \20\:mout) resistor r=62 c=0
Ry4 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry12 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry18 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry17 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry19 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry22 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry11 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry13 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry21 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry5 (\3\:Db \4\:Db) resistor r=62 c=0
Ry6 (\5\:Db \6\:Db) resistor r=62 c=0
Ry23 (n11 \2\:n11) resistor r=62 c=0
Ry24 (\3\:n11 \4\:n11) resistor r=62 c=0
Rx11 (\3\:D D) resistor r=45 c=0
Rx7 (\3\:CK CK) resistor r=45 c=0
Rx16 (\2\:SI SI) resistor r=45 c=0
Rx28 (\7\:RT RT) resistor r=45 c=0
Rx29 (\3\:RT \10\:RT) resistor r=45 c=0
Rx30 (\1\:RT \11\:RT) resistor r=45 c=0
Rx9 (\5\:SN \10\:SN) resistor r=45 c=0
Rx10 (\2\:SN \11\:SN) resistor r=45 c=0
Rx31 (\3\:SN \12\:SN) resistor r=45 c=0
Rx32 (\9\:SN \13\:SN) resistor r=45 c=0
Rx17 (\1\:SE SE) resistor r=45 c=0
Rx1 (n20 \12\:n20) resistor r=45 c=0
Rx4 (\2\:n20 \15\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \16\:n20) resistor r=45 c=0
Rx12 (\7\:n20 \19\:n20) resistor r=45 c=0
Rx13 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx2 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx3 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx6 (CKbb \19\:CKbb) resistor r=45 c=0
Rx33 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx34 (\9\:CKbb \21\:CKbb) resistor r=45 c=0
Rx14 (\4\:mout \10\:mout) resistor r=45 c=0
Rx15 (\2\:mout \18\:mout) resistor r=45 c=0
Rx8 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx20 (CKb \19\:CKb) resistor r=45 c=0
Rx21 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx18 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx22 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx25 (n35g \14\:n35g) resistor r=45 c=0
Rx24 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx35 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx36 (qbint \22\:qbint) resistor r=45 c=0
Rx26 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx27 (RTb \9\:RTb) resistor r=45 c=0
Rx38 (net573 \8\:net573) resistor r=45 c=0
Rx19 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx23 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx37 (n35 \16\:n35) resistor r=45 c=0
mn25 (\7\:Db \6\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\17\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \9\:CKb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.307e-14 ad=8.7e-15 ps=1.16e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (net0119 \6\:SN \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=6.307e-14 ps=4.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 net0119 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn11 (n0 \1\:D \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \5\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb net0118 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn52 (net0118 \12\:qbint net0116 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=8.7e-15 ps=4.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (net0116 \8\:SN \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn56 (\5\:net573 \14\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp36 (\13\:n20 \8\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\17\:CKb \4\:CK \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\16\:mout \1\:SN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp32 (\19\:mout \3\:n20 \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb \3\:n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp52 (n11 \11\:qbint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp50 (n11 \7\:SN \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1714 \
        scb=0.00703773 scc=5.55028e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends SRDFFSX1
// End of subcircuit definition.

// Generated for: spectre (May  3 16:08:11 2012 )
// Library name: gsclib045
// Cell name: SRDFFX1
// View name: extracted

simulator lang=spectre

subckt SRDFFX1 CK D ExtVDD Q QN RT SE SI VDD VSS
mp25 (\9\:n20 \3\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (QN VSS) capacitor c=1.96753e-17
C2 (SI VSS) capacitor c=8.75259e-17
C3 (RT VSS) capacitor c=3.67638e-17
C4 (ExtVDD VSS) capacitor c=2.18919e-16
C5 (CK VSS) capacitor c=7.98675e-17
C6 (VDD VSS) capacitor c=7.1504e-16
C7 (SE VSS) capacitor c=3.96872e-17
C8 (Q VSS) capacitor c=6.17444e-17
C9 (D VSS) capacitor c=7.97214e-17
C10 (n20 VSS) capacitor c=3.84704e-17
C11 (CKbb VSS) capacitor c=3.32985e-17
C12 (mout VSS) capacitor c=5.37744e-17
C13 (CKb VSS) capacitor c=4.82614e-17
C14 (SEb VSS) capacitor c=7.75108e-17
C15 (n35g VSS) capacitor c=1.7772e-17
C16 (qbint VSS) capacitor c=4.57835e-17
C17 (RTb VSS) capacitor c=5.18061e-17
C18 (net573 VSS) capacitor c=2.25505e-17
C19 (n35 VSS) capacitor c=1.45528e-16
C20 (Db VSS) capacitor c=1.02833e-16
C21 (net0110 VSS) capacitor c=6.33869e-17
C22 (n1 VSS) capacitor c=1.02126e-18
C23 (\7\:qbint VSS) capacitor c=3.39026e-17
C24 (\11\:qbint VSS) capacitor c=8.31359e-17
C25 (\13\:qbint VSS) capacitor c=4.3763e-17
C26 (\3\:net573 VSS) capacitor c=5.86679e-17
C27 (\11\:CKbb VSS) capacitor c=4.93916e-17
C28 (\4\:RTb VSS) capacitor c=9.88373e-17
C29 (\6\:RT VSS) capacitor c=2.22306e-17
C30 (\4\:qbint VSS) capacitor c=5.36612e-17
C31 (\3\:n35g VSS) capacitor c=5.22105e-17
C32 (\5\:RT VSS) capacitor c=5.86041e-17
C33 (\3\:SE VSS) capacitor c=7.73577e-17
C34 (\7\:CKb VSS) capacitor c=2.48722e-17
C35 (\3\:SI VSS) capacitor c=9.47876e-17
C36 (\4\:SE VSS) capacitor c=1.22829e-16
C37 (\4\:D VSS) capacitor c=7.17432e-17
C38 (\3\:n20 VSS) capacitor c=4.49327e-17
C39 (\4\:CK VSS) capacitor c=5.80043e-17
C40 (\4\:CKb VSS) capacitor c=4.923e-17
C41 (\8\:CKb VSS) capacitor c=8.26279e-17
C42 (\3\:CKbb VSS) capacitor c=2.60323e-17
C43 (\6\:qbint VSS) capacitor c=3.71807e-17
C44 (\14\:qbint VSS) capacitor c=4.56859e-17
C45 (\12\:qbint VSS) capacitor c=8.5727e-17
C46 (\4\:net573 VSS) capacitor c=3.6802e-17
C47 (\11\:CKb VSS) capacitor c=2.33773e-16
C48 (\8\:RT VSS) capacitor c=1.21363e-16
C49 (\2\:RT VSS) capacitor c=6.22925e-17
C50 (\5\:qbint VSS) capacitor c=3.89021e-17
C51 (\5\:n35g VSS) capacitor c=3.28693e-17
C52 (\2\:RTb VSS) capacitor c=4.65527e-17
C53 (\5\:SE VSS) capacitor c=5.7365e-17
C54 (\5\:CKbb VSS) capacitor c=2.45241e-17
C55 (\1\:SI VSS) capacitor c=4.90982e-17
C56 (\6\:SE VSS) capacitor c=8.63749e-17
C57 (\3\:SEb VSS) capacitor c=6.59302e-17
C58 (\1\:D VSS) capacitor c=4.94494e-17
C59 (\6\:n20 VSS) capacitor c=6.51408e-17
C60 (\1\:CK VSS) capacitor c=2.87489e-17
C61 (\3\:mout VSS) capacitor c=5.00546e-17
C62 (\9\:CKb VSS) capacitor c=3.64731e-17
C63 (\10\:CKbb VSS) capacitor c=4.86151e-17
C64 (\6\:CKb VSS) capacitor c=5.11913e-17
C65 (\10\:qbint VSS) capacitor c=8.4112e-17
C66 (\12\:CKbb VSS) capacitor c=3.97735e-17
C67 (\7\:RT VSS) capacitor c=1.4413e-16
C68 (\9\:CKbb VSS) capacitor c=1.55969e-16
C69 (\3\:RT VSS) capacitor c=3.3013e-17
C70 (\1\:RT VSS) capacitor c=5.2467e-17
C71 (\3\:RTb VSS) capacitor c=7.61997e-17
C72 (\3\:qbint VSS) capacitor c=4.44155e-17
C73 (\2\:n35 VSS) capacitor c=1.89205e-16
C74 (\4\:n35g VSS) capacitor c=6.64048e-17
C75 (\12\:CKb VSS) capacitor c=2.21201e-16
C76 (\3\:n35 VSS) capacitor c=7.66801e-17
C77 (\1\:SE VSS) capacitor c=2.47752e-17
C78 (\2\:SI VSS) capacitor c=7.74068e-17
C79 (\2\:SEb VSS) capacitor c=7.8411e-17
C80 (\3\:D VSS) capacitor c=1.51143e-17
C81 (\3\:CK VSS) capacitor c=2.31437e-17
C82 (\2\:mout VSS) capacitor c=3.80143e-17
C83 (\4\:mout VSS) capacitor c=3.80927e-17
C84 (\10\:CKb VSS) capacitor c=2.21463e-17
C85 (\5\:n20 VSS) capacitor c=3.73048e-17
C86 (\4\:CKbb VSS) capacitor c=6.31669e-17
C87 (\8\:CKbb VSS) capacitor c=2.45777e-17
C88 (\2\:n20 VSS) capacitor c=3.95838e-17
C89 (\1\:VDD VSS) capacitor c=4.94752e-17
C90 (\3\:Q VSS) capacitor c=7.27761e-17
C91 (\10\:VDD VSS) capacitor c=5.42941e-17
C92 (\9\:net573 VSS) capacitor c=5.56972e-17
C93 (\12\:VDD VSS) capacitor c=7.99107e-17
C94 (\3\:net0110 VSS) capacitor c=8.53421e-17
C95 (\4\:QN VSS) capacitor c=6.81951e-17
C96 (\14\:n35 VSS) capacitor c=5.41413e-17
C97 (\15\:n35g VSS) capacitor c=5.5988e-17
C98 (\6\:RTb VSS) capacitor c=7.31995e-17
C99 (\1\:ExtVDD VSS) capacitor c=2.78276e-16
C100 (\9\:n35 VSS) capacitor c=6.22363e-17
C101 (\17\:qbint VSS) capacitor c=6.84723e-17
C102 (\6\:n35g VSS) capacitor c=9.31897e-17
C103 (\8\:SEb VSS) capacitor c=5.08032e-17
C104 (\4\:n35 VSS) capacitor c=6.41853e-17
C105 (\14\:VDD VSS) capacitor c=6.09381e-17
C106 (\5\:mout VSS) capacitor c=6.55783e-17
C107 (\3\:Db VSS) capacitor c=1.93889e-16
C108 (\19\:VDD VSS) capacitor c=3.46338e-17
C109 (\14\:mout VSS) capacitor c=4.55773e-17
C110 (\17\:CKb VSS) capacitor c=2.99062e-17
C111 (\17\:VDD VSS) capacitor c=4.83231e-17
C112 (\17\:CKbb VSS) capacitor c=7.28685e-17
C113 (\12\:n20 VSS) capacitor c=6.7629e-17
C114 (\5\:Db VSS) capacitor c=2.22367e-16
C115 (\9\:n20 VSS) capacitor c=6.36354e-17
C116 (\1\:Q VSS) capacitor c=6.54344e-17
C117 (\5\:net573 VSS) capacitor c=4.31609e-17
C118 (\1\:QN VSS) capacitor c=3.92499e-17
C119 (\17\:n35 VSS) capacitor c=3.68796e-17
C120 (\11\:n35g VSS) capacitor c=2.97301e-17
C121 (\10\:RTb VSS) capacitor c=5.83059e-17
C122 (\12\:n35 VSS) capacitor c=6.37635e-17
C123 (\19\:qbint VSS) capacitor c=2.43869e-17
C124 (\9\:n35g VSS) capacitor c=8.1299e-17
C125 (\4\:SEb VSS) capacitor c=3.95357e-17
C126 (\7\:n35 VSS) capacitor c=4.17234e-17
C127 (\10\:mout VSS) capacitor c=2.32392e-17
C128 (\12\:mout VSS) capacitor c=2.62247e-17
C129 (\13\:CKb VSS) capacitor c=5.70233e-17
C130 (\15\:CKbb VSS) capacitor c=9.11333e-17
C131 (\16\:n20 VSS) capacitor c=8.2119e-17
C132 (\7\:Db VSS) capacitor c=7.8489e-17
C133 (\7\:n20 VSS) capacitor c=5.89516e-17
C134 (VDD VSS) capacitor c=4.24372e-17
C135 (\2\:CKbb VSS) capacitor c=6.47353e-17
C136 (\2\:CK VSS) capacitor c=3.70344e-17
C137 (\4\:n20 VSS) capacitor c=5.43891e-17
C138 (\2\:D VSS) capacitor c=3.58484e-17
C139 (\2\:SE VSS) capacitor c=2.50121e-17
C140 (\2\:CKb VSS) capacitor c=1.5308e-16
C141 (\3\:CKb VSS) capacitor c=8.93576e-17
C142 (\5\:CKb VSS) capacitor c=5.76797e-17
C143 (\2\:n35g VSS) capacitor c=2.90883e-17
C144 (\4\:RT VSS) capacitor c=3.78115e-17
C145 (\2\:qbint VSS) capacitor c=4.13305e-17
C146 (\6\:CKbb VSS) capacitor c=1.29582e-16
C147 (\7\:CKbb VSS) capacitor c=7.26353e-17
C148 (\2\:net573 VSS) capacitor c=1.52866e-17
C149 (\11\:n20 VSS) capacitor c=4.46389e-17
C150 (\13\:CKbb VSS) capacitor c=9.84345e-17
C151 (\14\:CKbb VSS) capacitor c=9.76079e-17
C152 (\8\:qbint VSS) capacitor c=4.58346e-17
C153 (\9\:qbint VSS) capacitor c=6.60997e-17
C154 (\14\:n20 VSS) capacitor c=5.19649e-17
C155 (\15\:n20 VSS) capacitor c=8.82111e-17
C156 (\19\:CKbb VSS) capacitor c=4.38948e-17
C157 (\15\:CKb VSS) capacitor c=6.01146e-17
C158 (\16\:CKb VSS) capacitor c=4.45341e-17
C159 (\7\:mout VSS) capacitor c=8.2704e-17
C160 (\8\:mout VSS) capacitor c=5.71549e-17
C161 (\9\:mout VSS) capacitor c=5.30418e-17
C162 (\16\:mout VSS) capacitor c=4.527e-17
C163 (\7\:SE VSS) capacitor c=5.26435e-17
C164 (\6\:SEb VSS) capacitor c=8.36785e-17
C165 (\7\:SEb VSS) capacitor c=6.96329e-17
C166 (\6\:n35 VSS) capacitor c=7.67648e-17
C167 (\19\:CKb VSS) capacitor c=3.8227e-17
C168 (\20\:CKb VSS) capacitor c=4.1869e-17
C169 (\8\:n35g VSS) capacitor c=3.40218e-17
C170 (\11\:n35 VSS) capacitor c=7.40109e-17
C171 (\15\:qbint VSS) capacitor c=8.80005e-17
C172 (\16\:qbint VSS) capacitor c=1.12149e-16
C173 (\13\:n35g VSS) capacitor c=1.02685e-16
C174 (\14\:n35g VSS) capacitor c=1.16309e-16
C175 (\5\:RTb VSS) capacitor c=4.94973e-17
C176 (\8\:RTb VSS) capacitor c=1.01992e-16
C177 (\9\:RTb VSS) capacitor c=9.17318e-17
C178 (\20\:CKbb VSS) capacitor c=9.48784e-17
C179 (\21\:CKbb VSS) capacitor c=1.00848e-16
C180 (\21\:qbint VSS) capacitor c=2.39372e-17
C181 (\22\:qbint VSS) capacitor c=3.00557e-17
C182 (\9\:RT VSS) capacitor c=1.04346e-16
C183 (\10\:RT VSS) capacitor c=1.18785e-16
C184 (\11\:RT VSS) capacitor c=5.89968e-17
C185 (\3\:QN VSS) capacitor c=3.18227e-17
C186 (\16\:n35 VSS) capacitor c=3.71648e-17
C187 (\7\:net573 VSS) capacitor c=5.7709e-17
C188 (\8\:net573 VSS) capacitor c=3.51646e-17
C189 (\3\:VDD VSS) capacitor c=4.42231e-17
C190 (\5\:VDD VSS) capacitor c=9.3079e-18
C191 (\6\:VDD VSS) capacitor c=2.25179e-16
C192 (\7\:VDD VSS) capacitor c=2.13236e-16
C193 (\9\:VDD VSS) capacitor c=3.80928e-17
C194 (\16\:VDD VSS) capacitor c=5.94309e-17
Rk57 (\3\:QN QN) resistor r=0.02948 c=0
Rk56 (\2\:QN \3\:QN) resistor r=0.1988 c=0
Rk58 (\3\:QN \5\:QN) resistor r=0.3451 c=0
Rk53 (RT \9\:RT) resistor r=0.1932 c=0
Rk54 (\9\:RT \10\:RT) resistor r=0.6407 c=0
Rk55 (RT \11\:RT) resistor r=0.006609 c=0
Rk38 (ExtVDD ExtVDD) resistor r=0.002061 c=0
Rk36 (\2\:ExtVDD ExtVDD) resistor r=0.02215 c=0
Rk39 (ExtVDD \5\:ExtVDD) resistor r=0.02014 c=0
Rk40 (ExtVDD \6\:ExtVDD) resistor r=0.1496 c=0
Rk96 (VDD VDD) resistor r=0.2356 c=0
Rk84 (\2\:VDD \3\:VDD) resistor r=0.5761 c=0
Rk85 (\3\:VDD \5\:VDD) resistor r=0.06676 c=0
Rk86 (\5\:VDD \6\:VDD) resistor r=0.05188 c=0
Rk87 (\6\:VDD \7\:VDD) resistor r=1.5221 c=0
Rk88 (\7\:VDD \9\:VDD) resistor r=0.3401 c=0
Rk89 (\3\:VDD \11\:VDD) resistor r=0.3013 c=0
Rk90 (\6\:VDD \13\:VDD) resistor r=0.3741 c=0
Rk91 (\7\:VDD \15\:VDD) resistor r=0.3661 c=0
Rk95 (\16\:VDD VDD) resistor r=0.1955 c=0
Rk92 (\9\:VDD \16\:VDD) resistor r=0.1709 c=0
Rk93 (\16\:VDD \18\:VDD) resistor r=0.2069 c=0
Rk94 (\9\:VDD \20\:VDD) resistor r=0.2389 c=0
Rk25 (SE \7\:SE) resistor r=0.0432 c=0
Rk65 (\2\:Q Q) resistor r=0.2973 c=0
Rk66 (Q \4\:Q) resistor r=0.2044 c=0
Rk67 (\2\:VSS \4\:VSS) resistor r=0.3613 c=0
Rk68 (\4\:VSS \5\:VSS) resistor r=0.2379 c=0
Rk69 (\5\:VSS \6\:VSS) resistor r=0.05932 c=0
Rk70 (\6\:VSS \7\:VSS) resistor r=0.6123 c=0
Rk71 (\7\:VSS \8\:VSS) resistor r=0.03204 c=0
Rk73 (\9\:VSS VSS) resistor r=0.1211 c=0
Rk72 (\8\:VSS \9\:VSS) resistor r=0.1759 c=0
Rk74 (VSS \10\:VSS) resistor r=0.5208 c=0
Rk75 (\10\:VSS \11\:VSS) resistor r=0.3071 c=0
Rk77 (\12\:VSS VSS) resistor r=0.1213 c=0
Rk76 (\11\:VSS \12\:VSS) resistor r=0.06428 c=0
Rk78 (VSS \14\:VSS) resistor r=0.3119 c=0
Rk79 (\5\:VSS \16\:VSS) resistor r=0.2667 c=0
Rk80 (\7\:VSS \18\:VSS) resistor r=0.1891 c=0
Rk81 (\9\:VSS \20\:VSS) resistor r=0.1942 c=0
Rk82 (\10\:VSS \22\:VSS) resistor r=0.2532 c=0
Rk83 (\11\:VSS \24\:VSS) resistor r=0.2488 c=0
Rk97 (\26\:VSS \28\:VSS) resistor r=0.3487 c=0
Rk98 (\28\:VSS \29\:VSS) resistor r=0.5654 c=0
Rk100 (\30\:VSS VSS) resistor r=0.04935 c=0
Rk99 (\29\:VSS \30\:VSS) resistor r=0.3271 c=0
Rk102 (\31\:VSS VSS) resistor r=0.1213 c=0
Rk101 (VSS \31\:VSS) resistor r=0.8929 c=0
Rk103 (VSS \33\:VSS) resistor r=0.2968 c=0
Rk104 (\29\:VSS \35\:VSS) resistor r=0.2434 c=0
Rk1 (\8\:n20 \10\:n20) resistor r=0.543 c=0
Rk2 (\10\:n20 \11\:n20) resistor r=0.2541 c=0
Rk4 (\13\:n20 \14\:n20) resistor r=0.3402 c=0
Rk5 (\13\:n20 \15\:n20) resistor r=0.2662 c=0
Rk6 (\15\:n20 \17\:n20) resistor r=0.4595 c=0
Rk3 (\13\:CKbb \14\:CKbb) resistor r=0.7511 c=0
Rk7 (\16\:CKbb \18\:CKbb) resistor r=0.5321 c=0
Rk8 (\18\:CKbb \19\:CKbb) resistor r=0.142 c=0
Rk51 (\20\:CKbb \21\:CKbb) resistor r=0.7115 c=0
Rk17 (\6\:mout \7\:mout) resistor r=0.602 c=0
Rk18 (\7\:mout \8\:mout) resistor r=0.5259 c=0
Rk19 (\8\:mout \9\:mout) resistor r=0.1904 c=0
Rk20 (\7\:mout \11\:mout) resistor r=0.1278 c=0
Rk21 (\8\:mout \13\:mout) resistor r=0.1169 c=0
Rk22 (\8\:mout \15\:mout) resistor r=0.5475 c=0
Rk23 (\9\:mout \16\:mout) resistor r=0.3936 c=0
Rk10 (\14\:CKb \15\:CKb) resistor r=0.3167 c=0
Rk11 (\15\:CKb \16\:CKb) resistor r=0.1578 c=0
Rk12 (\15\:CKb \18\:CKb) resistor r=0.1865 c=0
Rk31 (\19\:CKb \20\:CKb) resistor r=0.3714 c=0
Rk26 (\5\:SEb \6\:SEb) resistor r=0.2161 c=0
Rk27 (\6\:SEb \7\:SEb) resistor r=0.3544 c=0
Rk28 (\6\:SEb \9\:SEb) resistor r=0.3096 c=0
Rk32 (\7\:n35g \8\:n35g) resistor r=0.2733 c=0
Rk33 (\7\:n35g \10\:n35g) resistor r=0.6914 c=0
Rk44 (\12\:n35g \13\:n35g) resistor r=0.2429 c=0
Rk45 (\13\:n35g \14\:n35g) resistor r=0.5654 c=0
Rk46 (\13\:n35g \16\:n35g) resistor r=0.4319 c=0
Rk41 (\15\:qbint \16\:qbint) resistor r=0.4944 c=0
Rk42 (\16\:qbint \18\:qbint) resistor r=0.567 c=0
Rk43 (\16\:qbint \20\:qbint) resistor r=0.1463 c=0
Rk52 (\21\:qbint \22\:qbint) resistor r=0.2118 c=0
Rk47 (\5\:RTb \7\:RTb) resistor r=0.2162 c=0
Rk48 (\7\:RTb \8\:RTb) resistor r=0.4165 c=0
Rk49 (\8\:RTb \9\:RTb) resistor r=0.6885 c=0
Rk50 (\8\:RTb \11\:RTb) resistor r=0.3065 c=0
Rk61 (\6\:net573 \7\:net573) resistor r=0.2307 c=0
Rk62 (\7\:net573 \8\:net573) resistor r=0.1648 c=0
Rk63 (\7\:net573 \10\:net573) resistor r=0.2901 c=0
Rk29 (\5\:n35 \6\:n35) resistor r=0.4097 c=0
Rk30 (\6\:n35 \8\:n35) resistor r=0.2903 c=0
Rk34 (\10\:n35 \11\:n35) resistor r=0.4009 c=0
Rk35 (\11\:n35 \13\:n35) resistor r=0.3298 c=0
Rk59 (\15\:n35 \16\:n35) resistor r=0.3037 c=0
Rk60 (\16\:n35 \18\:n35) resistor r=0.2671 c=0
Rk14 (\2\:Db \4\:Db) resistor r=0.6363 c=0
Rk15 (\4\:Db \6\:Db) resistor r=1.42 c=0
Rk16 (\6\:Db \8\:Db) resistor r=0.5649 c=0
Rk64 (\2\:net0110 \4\:net0110) resistor r=0.6451 c=0
Rl19 (\2\:SI \3\:SI) resistor r=155.002 c=0
Rl18 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl53 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl40 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl43 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl42 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl41 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl9 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl7 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl8 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl22 (\3\:SE \4\:SE) resistor r=294.192 c=0
Rl24 (\5\:SE \6\:SE) resistor r=241.873 c=0
Rl21 (\2\:SE \3\:SE) resistor r=49.6369 c=0
Rl23 (\2\:SE \5\:SE) resistor r=147.714 c=0
Rl20 (\1\:SE \2\:SE) resistor r=0.767 c=0
Rl15 (\2\:D \4\:D) resistor r=115.099 c=0
Rl13 (\1\:D \2\:D) resistor r=84.3295 c=0
Rl14 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl1 (n20 \2\:n20) resistor r=123.512 c=0
Rl10 (\3\:n20 \4\:n20) resistor r=100.163 c=0
Rl12 (\4\:n20 \6\:n20) resistor r=179.184 c=0
Rl11 (\4\:n20 \5\:n20) resistor r=123.391 c=0
Rl56 (\11\:CKbb \12\:CKbb) resistor r=163.284 c=0
Rl2 (CKbb \2\:CKbb) resistor r=50.7843 c=0
Rl3 (\2\:CKbb \3\:CKbb) resistor r=68.4981 c=0
Rl4 (\2\:CKbb \4\:CKbb) resistor r=262.732 c=0
Rl48 (\5\:CKbb \6\:CKbb) resistor r=66.1349 c=0
Rl51 (\6\:CKbb \9\:CKbb) resistor r=762.322 c=0
Rl52 (\7\:CKbb \10\:CKbb) resistor r=60.7265 c=0
Rl50 (\7\:CKbb \8\:CKbb) resistor r=81.3209 c=0
Rl49 (\6\:CKbb \7\:CKbb) resistor r=462.851 c=0
Rl5 (mout \2\:mout) resistor r=24.2328 c=0
Rl6 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl57 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl25 (CKb \2\:CKb) resistor r=349.798 c=0
Rl30 (\2\:CKb \7\:CKb) resistor r=127.816 c=0
Rl27 (\3\:CKb \4\:CKb) resistor r=103.952 c=0
Rl31 (\3\:CKb \8\:CKb) resistor r=147.793 c=0
Rl26 (\2\:CKb \3\:CKb) resistor r=431.465 c=0
Rl28 (\4\:CKb \5\:CKb) resistor r=74.8465 c=0
Rl32 (\5\:CKb \9\:CKb) resistor r=132.539 c=0
Rl29 (\5\:CKb \6\:CKb) resistor r=266.239 c=0
Rl33 (\5\:CKb \10\:CKb) resistor r=4.3228 c=0
Rl16 (SEb \2\:SEb) resistor r=101.718 c=0
Rl17 (\2\:SEb \3\:SEb) resistor r=132.669 c=0
Rl36 (\3\:n35g \4\:n35g) resistor r=265.853 c=0
Rl34 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl35 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl37 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl61 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl68 (\13\:qbint \14\:qbint) resistor r=189.403 c=0
Rl66 (\11\:qbint \12\:qbint) resistor r=337.984 c=0
Rl47 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl44 (qbint \2\:qbint) resistor r=112.732 c=0
Rl46 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl45 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl62 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl65 (\8\:qbint \11\:qbint) resistor r=200.917 c=0
Rl67 (\9\:qbint \13\:qbint) resistor r=95.4293 c=0
Rl64 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl63 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl38 (RTb \2\:RTb) resistor r=112.412 c=0
Rl39 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl58 (net573 \2\:net573) resistor r=3.1216 c=0
Rl59 (\2\:net573 \3\:net573) resistor r=67.5354 c=0
Rl60 (\2\:net573 \4\:net573) resistor r=64.1263 c=0
Rl54 (n35 \2\:n35) resistor r=508.667 c=0
Rl55 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz17 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz20 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz22 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz23 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz24 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz25 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz26 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz27 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz30 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz31 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz32 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\16\:n20 \17\:n20) resistor r=75 c=0
Rz3 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz7 (\10\:mout \11\:mout) resistor r=75 c=0
Rz8 (\12\:mout \13\:mout) resistor r=75 c=0
Rz4 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz9 (\4\:SEb \5\:SEb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz19 (\5\:net573 \6\:net573) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz18 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz5 (Db \2\:Db) resistor r=75 c=0
Rz6 (\7\:Db \8\:Db) resistor r=75 c=0
Ry19 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry13 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry15 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry29 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry30 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry31 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry32 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry33 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry34 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry24 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry25 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry26 (\3\:VSS \6\:VSS) resistor r=62 c=0
Ry27 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry28 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry35 (\27\:VSS \28\:VSS) resistor r=5.6364 c=0
Ry36 (\27\:VSS \30\:VSS) resistor r=8.8571 c=0
Ry37 (\27\:VSS \31\:VSS) resistor r=5.1667 c=0
Ry1 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry2 (\12\:n20 \13\:n20) resistor r=62 c=0
Ry3 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry7 (\5\:mout \6\:mout) resistor r=62 c=0
Ry8 (\14\:mout \15\:mout) resistor r=62 c=0
Ry4 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry9 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry11 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry17 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry16 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry18 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry21 (\9\:net573 \10\:net573) resistor r=62 c=0
Ry10 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry12 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry20 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry5 (\3\:Db \4\:Db) resistor r=62 c=0
Ry6 (\5\:Db \6\:Db) resistor r=62 c=0
Ry22 (net0110 \2\:net0110) resistor r=62 c=0
Ry23 (\3\:net0110 \4\:net0110) resistor r=62 c=0
Rx12 (\2\:SI SI) resistor r=45 c=0
Rx28 (\3\:RT \9\:RT) resistor r=45 c=0
Rx29 (\1\:RT \10\:RT) resistor r=45 c=0
Rx30 (\7\:RT \11\:RT) resistor r=45 c=0
Rx7 (\3\:CK CK) resistor r=45 c=0
Rx13 (\1\:SE \7\:SE) resistor r=45 c=0
Rx9 (\3\:D D) resistor r=45 c=0
Rx1 (n20 \11\:n20) resistor r=45 c=0
Rx4 (\2\:n20 \14\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \15\:n20) resistor r=45 c=0
Rx2 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx3 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx6 (CKbb \19\:CKbb) resistor r=45 c=0
Rx24 (\12\:CKbb \20\:CKbb) resistor r=45 c=0
Rx25 (\9\:CKbb \21\:CKbb) resistor r=45 c=0
Rx10 (\4\:mout \9\:mout) resistor r=45 c=0
Rx11 (\2\:mout \16\:mout) resistor r=45 c=0
Rx8 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx16 (CKb \19\:CKb) resistor r=45 c=0
Rx17 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx14 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx18 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx21 (n35g \14\:n35g) resistor r=45 c=0
Rx20 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx26 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx27 (qbint \22\:qbint) resistor r=45 c=0
Rx22 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx23 (RTb \9\:RTb) resistor r=45 c=0
Rx32 (net573 \8\:net573) resistor r=45 c=0
Rx15 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx19 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx31 (n35 \16\:n35) resistor r=45 c=0
mn25 (\7\:Db \6\:CKb \7\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\16\:n20 \10\:CKbb n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKbb \9\:CKb \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (n6 \3\:mout \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\12\:mout \6\:n20 \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn52 (net0118 \12\:qbint \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn11 (n0 \1\:D \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.6e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn12 (Db \3\:SEb n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.32e-14 \
        ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.55e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn14 (Db \6\:SE n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=4.5e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn13 (n2 \1\:SI \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\7\:n35 \5\:CKbb \10\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn10 (\4\:SEb \5\:SE \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\19\:qbint \5\:n35g \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0134 \5\:qbint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\10\:RTb \2\:RT \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0134 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb net0118 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:net573 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(1)
mn56 (\5\:net573 \14\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp36 (\12\:n20 \8\:CKb n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp21 (\17\:CKbb \4\:CKb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.362e-13 ad=3.01e-14 ps=2.93e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.67921 \
        scb=0.00785546 scc=0.000197387 m=(1)
mp35 (n7 mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp20 (\17\:CKb \4\:CK \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.362e-13 ps=7.1e-07 pd=2.93e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\14\:mout \3\:n20 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp11 (n1 \4\:D \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.362e-13 ad=1.29e-14 ps=2.93e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.6e-07 sd=160n sca=9.66232 \
        scb=0.00784709 scc=0.000197383 m=(1)
mp12 (\3\:Db \4\:SE n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=6.55e-07 sd=160n sca=10.0927 \
        scb=0.00812618 scc=0.00019764 m=(1)
mp14 (\3\:Db SEb n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.8e-07 sb=4.5e-07 sd=160n sca=11.7854 scb=0.0102672 \
        scc=0.000210311 m=(1)
mp13 (n3 \3\:SI \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3.45e-07 sd=160n sca=13.7394 \
        scb=0.0136352 scc=0.000282236 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
mp10 (\8\:SEb \3\:SE \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.4e-07 sd=160n sca=28.6606 \
        scb=0.0317262 scc=0.00284419 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
mp45 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net234 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
PM1 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net234 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \11\:CKbb \3\:net0110 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:net573 \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=29.5361 \
        scb=0.0327981 scc=0.00307141 m=(1)
mp56 (\9\:net573 \13\:qbint \12\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.9717 \
        scb=0.0119275 scc=0.000216123 m=(1)
mp52 (net0110 \11\:qbint \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends SRDFFX1
// End of subcircuit definition.

// Generated for: spectre (May  8 14:55:57 2012 )
// Library name: gsclib045
// Cell name: ADDFX1
// View name: extracted

simulator lang=spectre

subckt ADDFX1 A B CI CO S VDD VSS
mp12 (\1\:CO \4\:COb \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.615e-14 ad=5.46e-14 ps=1.33e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12821e-07 sd=160n sca=24.8923 \
        scb=0.0283314 scc=0.00161065 m=(1)
C1 (B VSS) capacitor c=1.2222e-16
C2 (CO VSS) capacitor c=5.53574e-17
C3 (VDD VSS) capacitor c=2.22945e-16
C4 (S VSS) capacitor c=5.98885e-17
C5 (CI VSS) capacitor c=1.71996e-16
C6 (COb VSS) capacitor c=1.32321e-17
C7 (n2 VSS) capacitor c=8.98477e-17
C8 (n4 VSS) capacitor c=7.94196e-17
C9 (Sb VSS) capacitor c=4.52858e-17
C10 (n7 VSS) capacitor c=1.78033e-18
C11 (n6 VSS) capacitor c=1.50273e-18
C12 (n3 VSS) capacitor c=6.37448e-17
C13 (n1 VSS) capacitor c=1.4721e-18
C14 (n5 VSS) capacitor c=6.91224e-17
C15 (\12\:A VSS) capacitor c=9.1911e-17
C16 (\12\:B VSS) capacitor c=9.39089e-17
C17 (\10\:CI VSS) capacitor c=1.07584e-16
C18 (\7\:COb VSS) capacitor c=3.21928e-17
C19 (\9\:A VSS) capacitor c=6.52522e-17
C20 (\7\:B VSS) capacitor c=3.94173e-17
C21 (\5\:CI VSS) capacitor c=6.47777e-17
C22 (\4\:A VSS) capacitor c=6.88815e-17
C23 (\4\:B VSS) capacitor c=5.07826e-17
C24 (\4\:CI VSS) capacitor c=5.62731e-17
C25 (\1\:B VSS) capacitor c=4.08861e-17
C26 (\1\:A VSS) capacitor c=5.20741e-17
C27 (\4\:COb VSS) capacitor c=3.63097e-17
C28 (\3\:Sb VSS) capacitor c=4.99111e-17
C29 (\10\:A VSS) capacitor c=5.69726e-17
C30 (\10\:B VSS) capacitor c=8.63264e-17
C31 (\8\:CI VSS) capacitor c=4.23041e-17
C32 (\5\:COb VSS) capacitor c=6.61111e-17
C33 (\7\:A VSS) capacitor c=3.79991e-17
C34 (\9\:B VSS) capacitor c=6.39931e-17
C35 (\7\:CI VSS) capacitor c=4.08075e-17
C36 (\6\:A VSS) capacitor c=7.56648e-17
C37 (\6\:B VSS) capacitor c=8.51157e-17
C38 (\3\:CI VSS) capacitor c=4.06761e-17
C39 (\3\:B VSS) capacitor c=6.23183e-17
C40 (\3\:A VSS) capacitor c=4.50607e-17
C41 (\3\:COb VSS) capacitor c=3.50594e-17
C42 (\2\:Sb VSS) capacitor c=4.41255e-17
C43 (\11\:A VSS) capacitor c=8.51891e-17
C44 (\11\:B VSS) capacitor c=1.00296e-16
C45 (\9\:CI VSS) capacitor c=8.79442e-17
C46 (\6\:COb VSS) capacitor c=7.49243e-17
C47 (\8\:A VSS) capacitor c=5.88911e-17
C48 (\8\:B VSS) capacitor c=6.71718e-17
C49 (\6\:CI VSS) capacitor c=6.90649e-17
C50 (\5\:A VSS) capacitor c=8.54886e-17
C51 (\5\:B VSS) capacitor c=9.32063e-17
C52 (\1\:CI VSS) capacitor c=3.22405e-17
C53 (\2\:B VSS) capacitor c=6.96468e-17
C54 (\2\:A VSS) capacitor c=5.78782e-17
C55 (\1\:S VSS) capacitor c=3.16731e-17
C56 (\1\:VDD VSS) capacitor c=5.88099e-17
C57 (\7\:Sb VSS) capacitor c=1.08855e-16
C58 (\13\:VDD VSS) capacitor c=1.35571e-17
C59 (\3\:n5 VSS) capacitor c=6.86923e-17
C60 (\15\:VDD VSS) capacitor c=7.73761e-18
C61 (\12\:COb VSS) capacitor c=2.38226e-17
C62 (\17\:VDD VSS) capacitor c=1.2528e-17
C63 (\3\:n3 VSS) capacitor c=5.89506e-17
C64 (\19\:VDD VSS) capacitor c=2.73436e-17
C65 (\1\:CO VSS) capacitor c=3.3742e-17
C66 (\3\:VDD VSS) capacitor c=8.84166e-17
C67 (\3\:S VSS) capacitor c=7.42176e-17
C68 (\4\:Sb VSS) capacitor c=1.28263e-16
C69 (\3\:n4 VSS) capacitor c=8.18074e-17
C70 (\14\:COb VSS) capacitor c=1.53831e-16
C71 (\3\:n2 VSS) capacitor c=9.47729e-17
C72 (\3\:CO VSS) capacitor c=4.55275e-17
C73 (\2\:COb VSS) capacitor c=1.88135e-17
C74 (\2\:CI VSS) capacitor c=4.45433e-17
C75 (\8\:COb VSS) capacitor c=1.95741e-16
C76 (\9\:COb VSS) capacitor c=2.01744e-16
C77 (\10\:COb VSS) capacitor c=1.91402e-16
C78 (\11\:COb VSS) capacitor c=5.18265e-17
C79 (\11\:CI VSS) capacitor c=1.57591e-16
C80 (\13\:CI VSS) capacitor c=7.28932e-17
C81 (\13\:B VSS) capacitor c=1.03358e-16
C82 (\14\:B VSS) capacitor c=1.24713e-16
C83 (\15\:B VSS) capacitor c=1.2301e-16
C84 (\16\:B VSS) capacitor c=6.8993e-17
C85 (\13\:A VSS) capacitor c=1.45957e-16
C86 (\14\:A VSS) capacitor c=1.95054e-16
C87 (\15\:A VSS) capacitor c=1.98115e-16
C88 (\16\:A VSS) capacitor c=9.14367e-17
C89 (\6\:Sb VSS) capacitor c=1.73843e-16
C90 (\5\:VDD VSS) capacitor c=8.71484e-18
C91 (\11\:VDD VSS) capacitor c=2.31931e-18
Rk19 (\13\:A A) resistor r=0.002713 c=0
Rk20 (A \14\:A) resistor r=0.7122 c=0
Rk21 (\14\:A \15\:A) resistor r=0.7144 c=0
Rk22 (\15\:A \16\:A) resistor r=0.7021 c=0
Rk27 (\2\:VSS \4\:VSS) resistor r=0.3402 c=0
Rk28 (\4\:VSS \5\:VSS) resistor r=0.2812 c=0
Rk29 (\5\:VSS \6\:VSS) resistor r=0.1204 c=0
Rk30 (\6\:VSS \7\:VSS) resistor r=0.1003 c=0
Rk31 (\7\:VSS \8\:VSS) resistor r=0.3515 c=0
Rk32 (\5\:VSS \10\:VSS) resistor r=0.1087 c=0
Rk33 (\7\:VSS \12\:VSS) resistor r=0.189 c=0
Rk35 (\13\:VSS VSS) resistor r=0.1026 c=0
Rk34 (\8\:VSS \13\:VSS) resistor r=0.1988 c=0
Rk36 (\8\:VSS \15\:VSS) resistor r=0.2415 c=0
Rk37 (\13\:VSS \17\:VSS) resistor r=0.4242 c=0
Rk15 (\13\:B B) resistor r=0.4974 c=0
Rk16 (B \14\:B) resistor r=0.3454 c=0
Rk17 (\14\:B \15\:B) resistor r=0.5802 c=0
Rk18 (\15\:B \16\:B) resistor r=0.3774 c=0
Rk1 (\2\:CO CO) resistor r=0.168 c=0
Rk2 (CO \4\:CO) resistor r=0.3521 c=0
Rk38 (\2\:VDD \4\:VDD) resistor r=0.4917 c=0
Rk39 (\4\:VDD \5\:VDD) resistor r=0.3025 c=0
Rk40 (\5\:VDD \6\:VDD) resistor r=0.09898 c=0
Rk41 (\6\:VDD \7\:VDD) resistor r=0.08523 c=0
Rk42 (\7\:VDD \8\:VDD) resistor r=0.2159 c=0
Rk43 (\8\:VDD \9\:VDD) resistor r=0.1857 c=0
Rk44 (\9\:VDD \10\:VDD) resistor r=0.06513 c=0
Rk45 (\10\:VDD \11\:VDD) resistor r=0.09779 c=0
Rk47 (\12\:VDD VDD) resistor r=0.05 c=0
Rk46 (\11\:VDD \12\:VDD) resistor r=0.05256 c=0
Rk48 (\5\:VDD \14\:VDD) resistor r=0.1133 c=0
Rk49 (\7\:VDD \16\:VDD) resistor r=0.1188 c=0
Rk50 (\9\:VDD \18\:VDD) resistor r=0.1154 c=0
Rk51 (\11\:VDD \20\:VDD) resistor r=0.1706 c=0
Rk25 (\2\:S S) resistor r=0.1218 c=0
Rk26 (S \4\:S) resistor r=0.5035 c=0
Rk12 (\11\:CI CI) resistor r=0.8506 c=0
Rk13 (CI \12\:CI) resistor r=0.002725 c=0
Rk14 (CI \13\:CI) resistor r=0.364 c=0
Rk7 (\8\:COb \9\:COb) resistor r=1.1313 c=0
Rk8 (\9\:COb \10\:COb) resistor r=0.6087 c=0
Rk9 (\10\:COb \11\:COb) resistor r=0.2346 c=0
Rk10 (\9\:COb \13\:COb) resistor r=0.0716 c=0
Rk11 (\10\:COb \15\:COb) resistor r=1.0491 c=0
Rk3 (\2\:n2 \4\:n2) resistor r=0.5995 c=0
Rk6 (\2\:n4 \4\:n4) resistor r=0.3718 c=0
Rk23 (\5\:Sb \6\:Sb) resistor r=0.7375 c=0
Rk24 (\6\:Sb \8\:Sb) resistor r=0.634 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.338 c=0
Rk5 (\2\:n5 \4\:n5) resistor r=0.3676 c=0
Rl28 (\11\:A \12\:A) resistor r=150.223 c=0
Rl27 (\10\:A \11\:A) resistor r=81.8672 c=0
Rl20 (\8\:A \9\:A) resistor r=162.694 c=0
Rl19 (\7\:A \8\:A) resistor r=72.3097 c=0
Rl13 (\4\:A \5\:A) resistor r=74.2328 c=0
Rl14 (\5\:A \6\:A) resistor r=160.771 c=0
Rl4 (\1\:A \2\:A) resistor r=74.2328 c=0
Rl5 (\2\:A \3\:A) resistor r=160.771 c=0
Rl26 (\11\:B \12\:B) resistor r=116.54 c=0
Rl25 (\10\:B \11\:B) resistor r=126.234 c=0
Rl17 (\7\:B \8\:B) resistor r=28.079 c=0
Rl18 (\8\:B \9\:B) resistor r=206.925 c=0
Rl11 (\4\:B \5\:B) resistor r=28.079 c=0
Rl12 (\5\:B \6\:B) resistor r=206.925 c=0
Rl6 (\1\:B \2\:B) resistor r=28.079 c=0
Rl7 (\2\:B \3\:B) resistor r=206.925 c=0
Rl24 (\9\:CI \10\:CI) resistor r=214.401 c=0
Rl23 (\8\:CI \9\:CI) resistor r=28.8462 c=0
Rl15 (\5\:CI \6\:CI) resistor r=139.56 c=0
Rl16 (\6\:CI \7\:CI) resistor r=91.4826 c=0
Rl10 (\2\:CI \4\:CI) resistor r=129.649 c=0
Rl9 (\2\:CI \3\:CI) resistor r=123.88 c=0
Rl8 (\1\:CI \2\:CI) resistor r=3.1216 c=0
Rl22 (\6\:COb \7\:COb) resistor r=37.6365 c=0
Rl21 (\5\:COb \6\:COb) resistor r=199.969 c=0
Rl1 (COb \2\:COb) resistor r=2.0213 c=0
Rl3 (\2\:COb \4\:COb) resistor r=49.7141 c=0
Rl2 (\2\:COb \3\:COb) resistor r=113.176 c=0
Rl29 (Sb \2\:Sb) resistor r=56.8672 c=0
Rl30 (\2\:Sb \3\:Sb) resistor r=110.713 c=0
Rz9 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz10 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz11 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz12 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz13 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz1 (\3\:CO \4\:CO) resistor r=37.5 c=0
Rz14 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz15 (\3\:VDD \6\:VDD) resistor r=37.5 c=0
Rz16 (\3\:VDD \8\:VDD) resistor r=18.75 c=0
Rz17 (\3\:VDD \10\:VDD) resistor r=75 c=0
Rz18 (\3\:VDD \12\:VDD) resistor r=37.5 c=0
Rz8 (\3\:S \4\:S) resistor r=37.5 c=0
Rz6 (\14\:COb \15\:COb) resistor r=75 c=0
Rz2 (n2 \2\:n2) resistor r=75 c=0
Rz3 (\3\:n2 \4\:n2) resistor r=75 c=0
Rz4 (n4 \2\:n4) resistor r=75 c=0
Rz5 (\3\:n4 \4\:n4) resistor r=75 c=0
Rz7 (\4\:Sb \5\:Sb) resistor r=75 c=0
Ry9 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry10 (\3\:VSS \6\:VSS) resistor r=31 c=0
Ry11 (\3\:VSS \8\:VSS) resistor r=8.8571 c=0
Ry1 (\1\:CO \2\:CO) resistor r=20.6667 c=0
Ry12 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry13 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry14 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry15 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry16 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry8 (\1\:S \2\:S) resistor r=20.6667 c=0
Ry6 (\12\:COb \13\:COb) resistor r=62 c=0
Ry7 (\7\:Sb \8\:Sb) resistor r=62 c=0
Ry2 (n3 \2\:n3) resistor r=62 c=0
Ry3 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry4 (n5 \2\:n5) resistor r=62 c=0
Ry5 (\3\:n5 \4\:n5) resistor r=62 c=0
Rx10 (\11\:A \13\:A) resistor r=45 c=0
Rx11 (\8\:A \14\:A) resistor r=45 c=0
Rx12 (\5\:A \15\:A) resistor r=45 c=0
Rx13 (\2\:A \16\:A) resistor r=45 c=0
Rx6 (\11\:B \13\:B) resistor r=45 c=0
Rx7 (\8\:B \14\:B) resistor r=45 c=0
Rx8 (\5\:B \15\:B) resistor r=45 c=0
Rx9 (\2\:B \16\:B) resistor r=45 c=0
Rx3 (\9\:CI \11\:CI) resistor r=45 c=0
Rx4 (\6\:CI \12\:CI) resistor r=45 c=0
Rx5 (\1\:CI \13\:CI) resistor r=45 c=0
Rx1 (\6\:COb \8\:COb) resistor r=45 c=0
Rx2 (COb \11\:COb) resistor r=45 c=0
Rx14 (\2\:Sb \6\:Sb) resistor r=45 c=0
mn12 (\3\:CO \3\:COb \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.22e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.23846e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn2 (\3\:n2 \3\:A \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.31e-14 ad=1.93e-14 ps=9.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.33103e-07 sb=2e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn3 (n2 \3\:B \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.31e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.38103e-07 sb=2e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn4 (\14\:COb \3\:CI n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.43103e-07 sb=1.95e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn1 (\14\:COb \6\:B n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.48103e-07 sb=1.745e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn0 (n0 \6\:A \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.31e-14 ad=8.7e-15 ps=9.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.53103e-07 sb=1.64e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn7 (\3\:n4 \7\:CI \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.31e-14 ad=2.32e-14 ps=9.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.0581e-06 sb=1.435e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn6 (\3\:n4 \9\:B \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.17e-14 ad=2.32e-14 ps=1.06e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2631e-06 sb=1.23e-06 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn5 (n4 \7\:A \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.17e-14 ad=2.32e-14 ps=1.06e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5281e-06 sb=9.65e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn8 (\4\:Sb \5\:COb n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7331e-06 sb=7.6e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn11 (\4\:Sb \8\:CI n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9381e-06 sb=5.55e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn10 (n7 \10\:B n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=8.7e-15 ps=4.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 sa=2e-06 \
        sb=4.5e-07 sd=160n sca=6.83173 scb=0.00357784 scc=2.82929e-05 \
        m=(1)
mn9 (n6 \10\:A \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=8.7e-15 ps=8.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn13 (\3\:S \3\:Sb \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15962e-06 sb=1.4e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mp2 (\3\:n3 \1\:A \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.635e-14 ad=2.91e-14 ps=1.59e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35349e-07 sb=2e-06 sd=160n sca=14.1415 \
        scb=0.0126578 scc=0.000426771 m=(1)
mp3 (n3 \1\:B \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.635e-14 ad=3.44e-14 ps=1.59e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.30349e-07 sb=2e-06 sd=160n sca=13.1633 \
        scb=0.0118398 scc=0.00042523 m=(1)
mp4 (\12\:COb \4\:CI n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35349e-07 sb=1.95e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp1 (\12\:COb \4\:B n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.40349e-07 sb=1.745e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp0 (n1 \4\:A \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.62e-14 ad=1.29e-14 ps=1.55e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45349e-07 sb=1.64e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp7 (\3\:n5 \5\:CI \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.62e-14 ad=3.44e-14 ps=1.55e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05035e-06 sb=1.435e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp6 (\3\:n5 \7\:B \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=3.44e-14 ps=1.56e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25535e-06 sb=1.23e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp5 (n5 \9\:A \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.457e-14 ad=3.44e-14 ps=1.56e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48535e-06 sb=1e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp8 (\7\:Sb \7\:COb n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69035e-06 sb=7.95e-07 sd=160n sca=12.9421 \
        scb=0.0117495 scc=0.000425199 m=(1)
mp11 (\7\:Sb \10\:CI n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.89535e-06 sb=5.9e-07 sd=160n sca=13.7253 \
        scb=0.0122307 scc=0.000425663 m=(1)
mp10 (n9 \12\:B n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=1.29e-14 ps=5.5e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.99593e-06 sb=4.85e-07 sd=160n sca=14.4668 scb=0.0130588 \
        scc=0.000428492 m=(1)
mp9 (n8 \12\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.055e-14 ad=1.29e-14 ps=1.17e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.8e-07 sd=160n sca=15.7217 scb=0.0149728 \
        scc=0.00044748 m=(1)
mp13 (\1\:S Sb \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.055e-14 ad=5.46e-14 ps=1.17e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.15032e-06 sb=1.4e-07 sd=160n sca=26.7686 \
        scb=0.0307018 scc=0.00196241 m=(1)
ends ADDFX1
// End of subcircuit definition.

// Generated for: spectre (May  8 14:56:45 2012 )
// Library name: gsclib045
// Cell name: ADDHX1
// View name: extracted

simulator lang=spectre

subckt ADDHX1 A B CO S VDD VSS
mp8 (\3\:CO \4\:COb \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.585e-14 ad=5.46e-14 ps=1.83e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.20513e-07 sd=160n sca=35.0084 \
        scb=0.0365133 scc=0.00352722 m=(1)
C1 (S VSS) capacitor c=3.99054e-17
C2 (A VSS) capacitor c=5.13784e-17
C3 (CO VSS) capacitor c=5.31134e-17
C4 (VDD VSS) capacitor c=1.62939e-16
C5 (B VSS) capacitor c=9.03743e-17
C6 (COb VSS) capacitor c=2.50084e-17
C7 (n4 VSS) capacitor c=1.28943e-18
C8 (n1 VSS) capacitor c=2.65767e-17
C9 (n0 VSS) capacitor c=9.18366e-17
C10 (Sb VSS) capacitor c=4.92449e-17
C11 (\3\:n1 VSS) capacitor c=5.89877e-17
C12 (\2\:B VSS) capacitor c=1.04161e-16
C13 (\4\:A VSS) capacitor c=5.16667e-17
C14 (\3\:B VSS) capacitor c=5.40052e-17
C15 (\8\:B VSS) capacitor c=2.84416e-17
C16 (\3\:A VSS) capacitor c=6.20925e-17
C17 (\4\:COb VSS) capacitor c=4.47158e-17
C18 (\3\:Sb VSS) capacitor c=3.9651e-17
C19 (\2\:n0 VSS) capacitor c=7.75832e-17
C20 (\1\:B VSS) capacitor c=1.02365e-16
C21 (\6\:A VSS) capacitor c=2.64181e-17
C22 (\7\:B VSS) capacitor c=2.67415e-17
C23 (\6\:B VSS) capacitor c=4.15246e-17
C24 (\1\:A VSS) capacitor c=3.95687e-17
C25 (\3\:COb VSS) capacitor c=5.07611e-17
C26 (\2\:Sb VSS) capacitor c=2.62628e-17
C27 (\3\:n0 VSS) capacitor c=3.67466e-17
C28 (\4\:n1 VSS) capacitor c=3.60316e-17
C29 (\2\:n1 VSS) capacitor c=4.31328e-17
C30 (\5\:A VSS) capacitor c=4.06934e-17
C31 (\5\:B VSS) capacitor c=5.31496e-17
C32 (\2\:A VSS) capacitor c=8.14263e-17
C33 (\1\:S VSS) capacitor c=3.17145e-17
C34 (\1\:VDD VSS) capacitor c=5.76866e-17
C35 (\8\:Sb VSS) capacitor c=6.49764e-17
C36 (\7\:n0 VSS) capacitor c=1.12006e-16
C37 (\10\:VDD VSS) capacitor c=7.2928e-17
C38 (\11\:n1 VSS) capacitor c=2.09853e-17
C39 (\12\:VDD VSS) capacitor c=1.1775e-17
C40 (\9\:COb VSS) capacitor c=2.19897e-17
C41 (\14\:VDD VSS) capacitor c=6.25084e-18
C42 (\3\:CO VSS) capacitor c=3.32493e-17
C43 (\3\:VDD VSS) capacitor c=5.83125e-17
C44 (\3\:S VSS) capacitor c=3.59221e-17
C45 (\6\:Sb VSS) capacitor c=2.90335e-17
C46 (\5\:n0 VSS) capacitor c=1.48007e-16
C47 (\8\:n1 VSS) capacitor c=6.92803e-17
C48 (\5\:COb VSS) capacitor c=1.20742e-16
C49 (\1\:CO VSS) capacitor c=6.52541e-17
C50 (\2\:COb VSS) capacitor c=2.38977e-17
C51 (\4\:B VSS) capacitor c=2.90105e-17
C52 (\7\:COb VSS) capacitor c=1.16118e-16
C53 (\8\:COb VSS) capacitor c=7.55608e-17
C54 (\7\:A VSS) capacitor c=1.59448e-16
C55 (\8\:A VSS) capacitor c=1.43082e-16
C56 (\5\:n1 VSS) capacitor c=3.14875e-17
C57 (\6\:n1 VSS) capacitor c=1.44142e-16
C58 (\7\:n1 VSS) capacitor c=1.34228e-16
C59 (\10\:n1 VSS) capacitor c=1.30975e-16
C60 (\4\:n0 VSS) capacitor c=6.64718e-17
C61 (\4\:Sb VSS) capacitor c=4.56305e-17
C62 (\5\:Sb VSS) capacitor c=6.5372e-17
C63 (\5\:VDD VSS) capacitor c=2.15248e-17
C64 (\6\:VDD VSS) capacitor c=5.08388e-18
C65 (\8\:VDD VSS) capacitor c=3.48914e-18
Rk19 (\2\:S S) resistor r=0.1429 c=0
Rk20 (S \4\:S) resistor r=0.2039 c=0
Rk31 (\2\:VSS \4\:VSS) resistor r=0.5291 c=0
Rk32 (\4\:VSS \5\:VSS) resistor r=0.2912 c=0
Rk33 (\5\:VSS \6\:VSS) resistor r=0.2611 c=0
Rk35 (\7\:VSS VSS) resistor r=0.1016 c=0
Rk34 (\6\:VSS \7\:VSS) resistor r=0.09684 c=0
Rk36 (\5\:VSS \9\:VSS) resistor r=0.129 c=0
Rk37 (\7\:VSS \11\:VSS) resistor r=0.2133 c=0
Rk8 (\8\:A A) resistor r=0.06006 c=0
Rk7 (\7\:A \8\:A) resistor r=1.1293 c=0
Rk1 (\2\:CO CO) resistor r=0.4599 c=0
Rk2 (CO \4\:CO) resistor r=0.0513 c=0
Rk21 (\2\:VDD \4\:VDD) resistor r=0.5408 c=0
Rk22 (\4\:VDD \5\:VDD) resistor r=0.2159 c=0
Rk23 (\5\:VDD \6\:VDD) resistor r=0.1679 c=0
Rk24 (\6\:VDD \7\:VDD) resistor r=0.1179 c=0
Rk26 (\8\:VDD VDD) resistor r=0.08246 c=0
Rk25 (\7\:VDD \8\:VDD) resistor r=0.1179 c=0
Rk28 (\5\:VDD \11\:VDD) resistor r=0.3843 c=0
Rk29 (\6\:VDD \13\:VDD) resistor r=0.129 c=0
Rk30 (\8\:VDD \15\:VDD) resistor r=0.0884 c=0
Rk3 (B \9\:B) resistor r=0.04302 c=0
Rk4 (\6\:COb \7\:COb) resistor r=0.6944 c=0
Rk5 (\7\:COb \8\:COb) resistor r=0.3126 c=0
Rk6 (\7\:COb \10\:COb) resistor r=0.14 c=0
Rk9 (\5\:n1 \6\:n1) resistor r=0.1405 c=0
Rk10 (\6\:n1 \7\:n1) resistor r=0.7645 c=0
Rk11 (\7\:n1 \9\:n1) resistor r=0.3294 c=0
Rk12 (\6\:n1 \10\:n1) resistor r=0.5446 c=0
Rk13 (\7\:n1 \12\:n1) resistor r=0.1051 c=0
Rk14 (\4\:n0 \6\:n0) resistor r=0.4938 c=0
Rk15 (\6\:n0 \8\:n0) resistor r=0.4481 c=0
Rk16 (\4\:Sb \5\:Sb) resistor r=0.2357 c=0
Rk17 (\5\:Sb \7\:Sb) resistor r=0.1233 c=0
Rk18 (\5\:Sb \9\:Sb) resistor r=0.3607 c=0
Rl6 (\4\:A \5\:A) resistor r=99.1749 c=0
Rl7 (\5\:A \6\:A) resistor r=29.9442 c=0
Rl5 (\2\:A \3\:A) resistor r=160.771 c=0
Rl4 (\1\:A \2\:A) resistor r=31.9251 c=0
Rl11 (\2\:B \3\:B) resistor r=328.412 c=0
Rl10 (\1\:B \2\:B) resistor r=204.9 c=0
Rl16 (\5\:B \8\:B) resistor r=93.4057 c=0
Rl14 (\5\:B \6\:B) resistor r=95.3288 c=0
Rl12 (\3\:B \4\:B) resistor r=80.0028 c=0
Rl15 (\4\:B \7\:B) resistor r=78.0797 c=0
Rl13 (\4\:B \5\:B) resistor r=123.856 c=0
Rl1 (COb \2\:COb) resistor r=1.2334 c=0
Rl3 (\2\:COb \4\:COb) resistor r=37.3411 c=0
Rl2 (\2\:COb \3\:COb) resistor r=106.572 c=0
Rl9 (\3\:n1 \4\:n1) resistor r=31.9251 c=0
Rl8 (n1 \2\:n1) resistor r=37.2302 c=0
Rl17 (n0 \2\:n0) resistor r=161.538 c=0
Rl18 (\2\:n0 \3\:n0) resistor r=74.2328 c=0
Rl19 (Sb \2\:Sb) resistor r=39.6174 c=0
Rl20 (\2\:Sb \3\:Sb) resistor r=26.1559 c=0
Rz6 (\3\:S \4\:S) resistor r=37.5 c=0
Rz10 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz11 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz12 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz1 (\1\:CO \2\:CO) resistor r=37.5 c=0
Rz9 (\3\:VDD VDD) resistor r=75 c=0
Rz7 (\3\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz8 (\3\:VDD \7\:VDD) resistor r=25 c=0
Rz2 (\5\:COb \6\:COb) resistor r=75 c=0
Rz3 (\8\:n1 \9\:n1) resistor r=75 c=0
Rz4 (\5\:n0 \6\:n0) resistor r=75 c=0
Rz5 (\6\:Sb \7\:Sb) resistor r=75 c=0
Ry6 (\1\:S \2\:S) resistor r=20.6667 c=0
Ry11 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry12 (\3\:VSS \6\:VSS) resistor r=12.4 c=0
Ry1 (\3\:CO \4\:CO) resistor r=20.6667 c=0
Ry7 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry8 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry9 (\12\:VDD \13\:VDD) resistor r=31 c=0
Ry10 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry2 (\9\:COb \10\:COb) resistor r=62 c=0
Ry3 (\11\:n1 \12\:n1) resistor r=62 c=0
Ry4 (\7\:n0 \8\:n0) resistor r=62 c=0
Ry5 (\8\:Sb \9\:Sb) resistor r=62 c=0
Rx3 (\5\:A \7\:A) resistor r=45 c=0
Rx4 (\2\:A \8\:A) resistor r=45 c=0
Rx1 (\5\:B \9\:B) resistor r=45 c=0
Rx2 (COb \8\:COb) resistor r=45 c=0
Rx5 (\4\:n1 \5\:n1) resistor r=45 c=0
Rx6 (\2\:n1 \10\:n1) resistor r=45 c=0
Rx7 (\3\:n0 \4\:n0) resistor r=45 c=0
Rx8 (\2\:Sb \4\:Sb) resistor r=45 c=0
mn8 (\1\:CO \3\:COb \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.11923e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn6 (n4 \1\:A \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.305e-14 ps=8.4e-07 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.75e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn7 (\5\:COb \6\:B n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.305e-14 ad=2.03e-14 ps=4.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn1 (\8\:n1 \7\:B \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.32e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.15e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn0 (\5\:n0 \6\:A \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.32e-14 ad=3.335e-14 ps=1.67e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=9.35e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn4 (\6\:Sb n1 \5\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=2.393e-14 ps=7.5e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.3e-07 sb=6.6e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn3 (\6\:Sb \1\:B n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.393e-14 ps=4.1e-07 pd=6.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.4e-07 sb=4.5e-07 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn2 (n2 \2\:n0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=8.7e-15 ps=8.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45e-07 sb=3.45e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn5 (\3\:S \3\:Sb \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.85577e-07 sb=1.4e-07 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(1)
mp6 (\9\:COb \3\:A \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.585e-14 ad=3.44e-14 ps=1.83e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=3.05e-07 sd=160n sca=15.3248 \
        scb=0.0144711 scc=0.000289176 m=(1)
mp7 (\9\:COb \8\:B \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.495e-14 ad=3.44e-14 ps=1.38e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=1e-07 sd=160n sca=12.8165 scb=0.0106177 \
        scc=0.00024049 m=(1)
mp1 (\11\:n1 \3\:B \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=2.63e-14 ps=7.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=1.15e-06 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp0 (\7\:n0 \4\:A \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=5.052e-14 ps=7.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.37326e-07 sb=9.35e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp4 (\8\:Sb \2\:B \7\:n0 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.053e-14 ad=3.44e-14 ps=9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.17326e-07 sb=6.55e-07 sd=160n sca=13.327 \
        scb=0.0119299 scc=0.000425286 m=(1)
mp3 (\8\:Sb \3\:n1 n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.22326e-07 sb=4.5e-07 sd=160n sca=14.6061 \
        scb=0.0132457 scc=0.000429538 m=(1)
mp2 (n3 n0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=5.19e-14 \
        ad=1.29e-14 ps=1.1e-06 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.27326e-07 sb=3.45e-07 sd=160n sca=15.9702 scb=0.0153945 \
        scc=0.000454375 m=(1)
mp5 (\1\:S Sb \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.69103e-07 sb=1.4e-07 sd=160n sca=42.1543 \
        scb=0.0369591 scc=0.00437643 m=(1)
ends ADDHX1
// End of subcircuit definition.

// Generated for: spectre (May  8 14:57:31 2012 )
// Library name: gsclib045
// Cell name: AND2X1
// View name: extracted

simulator lang=spectre

subckt AND2X1 A B VDD VSS Y
mp1 (\8\:n0 \4\:B \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.33e-14 ad=3.548e-14 ps=1.37e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2e-07 sb=5.55e-07 sd=160n sca=28.7776 \
        scb=0.0317346 scc=0.0021577 m=(1)
C1 (Y VSS) capacitor c=5.39906e-17
C2 (VDD VSS) capacitor c=6.68074e-17
C3 (A VSS) capacitor c=7.98404e-17
C4 (n0 VSS) capacitor c=4.92759e-17
C5 (\1\:A VSS) capacitor c=4.91463e-17
C6 (\4\:B VSS) capacitor c=3.79444e-17
C7 (\3\:n0 VSS) capacitor c=4.0145e-17
C8 (\3\:A VSS) capacitor c=5.90945e-17
C9 (\1\:B VSS) capacitor c=5.24568e-17
C10 (\2\:n0 VSS) capacitor c=3.37586e-17
C11 (\2\:A VSS) capacitor c=6.63104e-17
C12 (\3\:B VSS) capacitor c=1.51302e-17
C13 (\1\:Y VSS) capacitor c=5.1574e-17
C14 (\1\:VDD VSS) capacitor c=4.55635e-17
C15 (\8\:n0 VSS) capacitor c=6.68434e-17
C16 (\5\:VDD VSS) capacitor c=5.77326e-18
C17 (\3\:Y VSS) capacitor c=3.03887e-17
C18 (\6\:n0 VSS) capacitor c=3.38024e-17
C19 (\2\:B VSS) capacitor c=4.60022e-17
C20 (\5\:B VSS) capacitor c=3.52401e-17
C21 (\7\:B VSS) capacitor c=3.91714e-17
C22 (\4\:A VSS) capacitor c=5.7719e-17
C23 (\4\:n0 VSS) capacitor c=7.37377e-17
C24 (\5\:n0 VSS) capacitor c=9.45846e-17
C25 (\4\:VDD VSS) capacitor c=2.24884e-17
Rk8 (\2\:Y Y) resistor r=0.3325 c=0
Rk9 (Y \4\:Y) resistor r=0.1462 c=0
Rk1 (\5\:B \6\:B) resistor r=0.001776 c=0
Rk2 (B \7\:B) resistor r=0.001658 c=0
Rk3 (\5\:B \7\:B) resistor r=0.03546 c=0
Rk14 (\4\:VSS VSS) resistor r=0.1503 c=0
Rk13 (\2\:VSS \4\:VSS) resistor r=0.3451 c=0
Rk11 (\4\:VDD VDD) resistor r=0.151 c=0
Rk10 (\2\:VDD \4\:VDD) resistor r=0.3363 c=0
Rk12 (VDD \6\:VDD) resistor r=0.06754 c=0
Rk4 (A \4\:A) resistor r=0.1436 c=0
Rk5 (\4\:n0 \5\:n0) resistor r=0.2844 c=0
Rk6 (\5\:n0 \7\:n0) resistor r=0.1371 c=0
Rk7 (\5\:n0 \9\:n0) resistor r=0.4669 c=0
Rl3 (\2\:B \4\:B) resistor r=106.246 c=0
Rl1 (\1\:B \2\:B) resistor r=74.3274 c=0
Rl2 (\2\:B \3\:B) resistor r=5.1529 c=0
Rl4 (\1\:A \2\:A) resistor r=89.5596 c=0
Rl5 (\2\:A \3\:A) resistor r=81.8672 c=0
Rl6 (n0 \2\:n0) resistor r=39.5596 c=0
Rl7 (\2\:n0 \3\:n0) resistor r=64.5595 c=0
Rz2 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz1 (\6\:n0 \7\:n0) resistor r=75 c=0
Ry2 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry1 (\8\:n0 \9\:n0) resistor r=62 c=0
Rx1 (\3\:B \6\:B) resistor r=45 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn0 (net127 \1\:B \6\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.85e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn1 (\1\:VSS \3\:A net127 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.438e-14 ps=4.1e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.8e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn2 (\3\:Y \3\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.438e-14 ad=3.64e-14 ps=9.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.32404e-07 sb=1.4e-07 sd=160n sca=11.3041 \
        scb=0.010759 scc=0.000493236 m=(1)
mp0 (\8\:n0 \1\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.548e-14 ps=1.1e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=3.45e-07 sd=160n sca=18.926 \
        scb=0.0187755 scc=0.000316918 m=(1)
mp2 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.39808e-07 sb=1.4e-07 sd=160n sca=35.5228 \
        scb=0.0370147 scc=0.0033854 m=(1)
ends AND2X1
// End of subcircuit definition.

// Generated for: spectre (May  8 14:58:19 2012 )
// Library name: gsclib045
// Cell name: AND2X2
// View name: extracted

simulator lang=spectre

subckt AND2X2 A B VDD VSS Y
mp1 (\11\:n0 \4\:B \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.44e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.7e-07 sd=160n sca=30.8503 scb=0.0332284 \
        scc=0.00283483 m=(1)
C1 (B VSS) capacitor c=4.67429e-17
C2 (Y VSS) capacitor c=6.25486e-17
C3 (VDD VSS) capacitor c=6.63474e-17
C4 (A VSS) capacitor c=8.57922e-17
C5 (net73 VSS) capacitor c=1.40724e-18
C6 (n0 VSS) capacitor c=1.68998e-16
C7 (\1\:A VSS) capacitor c=5.7916e-17
C8 (\4\:B VSS) capacitor c=2.85901e-17
C9 (\3\:A VSS) capacitor c=5.4907e-17
C10 (\1\:B VSS) capacitor c=7.19542e-17
C11 (\2\:A VSS) capacitor c=6.60103e-17
C12 (\3\:B VSS) capacitor c=1.26608e-17
C13 (\1\:VDD VSS) capacitor c=8.89585e-17
C14 (\1\:Y VSS) capacitor c=8.99968e-17
C15 (\11\:n0 VSS) capacitor c=9.03189e-17
C16 (\7\:VDD VSS) capacitor c=4.99239e-18
C17 (\3\:VDD VSS) capacitor c=2.28762e-17
C18 (\3\:Y VSS) capacitor c=4.86384e-17
C19 (\9\:n0 VSS) capacitor c=1.85754e-17
C20 (\2\:B VSS) capacitor c=4.5993e-17
C21 (\5\:B VSS) capacitor c=3.58698e-17
C22 (\4\:A VSS) capacitor c=6.50433e-17
C23 (\7\:n0 VSS) capacitor c=8.42019e-17
C24 (\8\:n0 VSS) capacitor c=8.40119e-17
Rk1 (B \5\:B) resistor r=0.09314 c=0
Rk6 (\2\:Y Y) resistor r=0.3407 c=0
Rk7 (Y \4\:Y) resistor r=0.1684 c=0
Rk10 (\1\:VDD VDD) resistor r=0.1855 c=0
Rk12 (VDD \8\:VDD) resistor r=0.101 c=0
Rk2 (A \4\:A) resistor r=0.2134 c=0
Rk15 (\1\:VSS VSS) resistor r=0.2015 c=0
Rk3 (\7\:n0 \8\:n0) resistor r=0.3649 c=0
Rk4 (\8\:n0 \10\:n0) resistor r=0.07427 c=0
Rk5 (\8\:n0 \12\:n0) resistor r=0.5036 c=0
Rl3 (\2\:B \4\:B) resistor r=24.4619 c=0
Rl1 (\1\:B \2\:B) resistor r=189.894 c=0
Rl2 (\2\:B \3\:B) resistor r=4.5402 c=0
Rl4 (\1\:A \2\:A) resistor r=133.384 c=0
Rl5 (\2\:A \3\:A) resistor r=56.461 c=0
Rz2 (\4\:Y \3\:Y) resistor r=37.5 c=0
Rz4 (VDD \3\:VDD) resistor r=75 c=0
Rz3 (\1\:VDD \3\:VDD) resistor r=18.75 c=0
Rz1 (\10\:n0 \9\:n0) resistor r=75 c=0
Ry2 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry4 (\8\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\12\:n0 \11\:n0) resistor r=62 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\7\:n0 n0) resistor r=45 c=0
mn1 (\9\:n0 \1\:B net73 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.7e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn0 (net73 \3\:A \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.36e-14 ad=8.7e-15 ps=1.41e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.65e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn2 (\3\:Y n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=5e-14 \
        ad=4.16e-14 ps=1.105e-06 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.14615e-07 sb=3.45e-07 sd=160n sca=10.3222 scb=0.00938145 \
        scc=0.000353946 m=(2)
mp0 (\11\:n0 \1\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.775e-14 ad=3.44e-14 ps=1.13e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=5.65e-07 sd=160n sca=16.7744 \
        scb=0.0157078 scc=0.000273548 m=(1)
mp2 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.618e-14 ad=6.24e-14 ps=1.095e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.41026e-07 sb=3.45e-07 sd=160n sca=23.9894 \
        scb=0.0214998 scc=0.00175538 m=(2)
ends AND2X2
// End of subcircuit definition.

// Generated for: spectre (May  8 14:59:05 2012 )
// Library name: gsclib045
// Cell name: AND4X1
// View name: extracted

simulator lang=spectre

subckt AND4X1 A B C D VDD VSS Y
mp3 (\10\:net116 \3\:D \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.02e-06 sd=160n sca=24.6667 \
        scb=0.0279468 scc=0.00158007 m=(1)
C1 (B VSS) capacitor c=7.04196e-17
C2 (Y VSS) capacitor c=2.12728e-17
C3 (C VSS) capacitor c=4.30078e-17
C4 (VDD VSS) capacitor c=1.03867e-16
C5 (D VSS) capacitor c=2.1236e-17
C6 (A VSS) capacitor c=4.72002e-17
C7 (net132 VSS) capacitor c=3.16837e-18
C8 (net116 VSS) capacitor c=6.05617e-17
C9 (net128 VSS) capacitor c=6.54738e-18
C10 (net124 VSS) capacitor c=2.75199e-18
C11 (\1\:A VSS) capacitor c=5.75914e-17
C12 (\1\:B VSS) capacitor c=5.80786e-17
C13 (\1\:C VSS) capacitor c=5.91714e-17
C14 (\3\:D VSS) capacitor c=4.79567e-17
C15 (\4\:net116 VSS) capacitor c=3.62406e-17
C16 (\3\:A VSS) capacitor c=4.30628e-17
C17 (\4\:B VSS) capacitor c=3.5428e-17
C18 (\3\:C VSS) capacitor c=3.38115e-17
C19 (\1\:D VSS) capacitor c=3.09635e-17
C20 (\3\:net116 VSS) capacitor c=3.88505e-17
C21 (\2\:A VSS) capacitor c=5.91688e-17
C22 (\3\:B VSS) capacitor c=2.57789e-17
C23 (\2\:C VSS) capacitor c=6.11922e-17
C24 (\2\:D VSS) capacitor c=6.12554e-17
C25 (\1\:Y VSS) capacitor c=5.08163e-17
C26 (\9\:VDD VSS) capacitor c=4.09373e-17
C27 (\12\:net116 VSS) capacitor c=2.1275e-17
C28 (\11\:VDD VSS) capacitor c=2.27814e-17
C29 (\10\:net116 VSS) capacitor c=4.13664e-17
C30 (\7\:VDD VSS) capacitor c=1.99252e-17
C31 (\1\:VDD VSS) capacitor c=4.51337e-17
C32 (\3\:Y VSS) capacitor c=7.61779e-17
C33 (\7\:net116 VSS) capacitor c=5.93061e-17
C34 (\2\:B VSS) capacitor c=3.85602e-17
C35 (\4\:D VSS) capacitor c=4.18785e-17
C36 (\4\:C VSS) capacitor c=4.50811e-17
C37 (\5\:B VSS) capacitor c=8.62971e-17
C38 (\4\:A VSS) capacitor c=4.33136e-17
C39 (\5\:net116 VSS) capacitor c=7.97748e-17
C40 (\6\:net116 VSS) capacitor c=1.32441e-16
C41 (\9\:net116 VSS) capacitor c=8.23155e-17
C42 (\5\:VDD VSS) capacitor c=2.19644e-18
Rk3 (\5\:B B) resistor r=0.245 c=0
Rk10 (Y \2\:Y) resistor r=0.03962 c=0
Rk11 (\2\:Y \4\:Y) resistor r=0.5007 c=0
Rk2 (\4\:C C) resistor r=0.1264 c=0
Rk12 (\2\:VDD \3\:VDD) resistor r=0.1101 c=0
Rk13 (\3\:VDD \4\:VDD) resistor r=0.09004 c=0
Rk14 (\4\:VDD \5\:VDD) resistor r=0.1301 c=0
Rk16 (\6\:VDD VDD) resistor r=0.1003 c=0
Rk15 (\5\:VDD \6\:VDD) resistor r=0.1201 c=0
Rk17 (VDD \8\:VDD) resistor r=0.2719 c=0
Rk18 (\3\:VDD \10\:VDD) resistor r=0.2732 c=0
Rk19 (\5\:VDD \12\:VDD) resistor r=0.1568 c=0
Rk1 (\4\:D D) resistor r=0.02417 c=0
Rk4 (\4\:A A) resistor r=0.07765 c=0
Rk20 (\2\:VSS \3\:VSS) resistor r=0.1101 c=0
Rk22 (\4\:VSS VSS) resistor r=0.2003 c=0
Rk21 (\3\:VSS \4\:VSS) resistor r=0.2404 c=0
Rk23 (\3\:VSS \6\:VSS) resistor r=0.2044 c=0
Rk5 (\5\:net116 \6\:net116) resistor r=0.3071 c=0
Rk6 (\6\:net116 \8\:net116) resistor r=0.4241 c=0
Rk7 (\6\:net116 \9\:net116) resistor r=0.5043 c=0
Rk8 (\9\:net116 \11\:net116) resistor r=0.2721 c=0
Rk9 (\9\:net116 \13\:net116) resistor r=0.06936 c=0
Rl5 (\1\:B \2\:B) resistor r=174.714 c=0
Rl7 (\2\:B \4\:B) resistor r=47.791 c=0
Rl6 (\2\:B \3\:B) resistor r=9.8995 c=0
Rl3 (\1\:C \2\:C) resistor r=168 c=0
Rl4 (\2\:C \3\:C) resistor r=37.2302 c=0
Rl2 (\2\:D \3\:D) resistor r=162.637 c=0
Rl1 (\1\:D \2\:D) resistor r=44.7751 c=0
Rl8 (\1\:A \2\:A) resistor r=150 c=0
Rl9 (\2\:A \3\:A) resistor r=56.8681 c=0
Rl10 (net116 \2\:net116) resistor r=120.868 c=0
Rl12 (\2\:net116 \4\:net116) resistor r=34.3295 c=0
Rl11 (\2\:net116 \3\:net116) resistor r=0.5166 c=0
Rz2 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VDD \6\:VDD) resistor r=25 c=0
Rz6 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz1 (\7\:net116 \8\:net116) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry5 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry6 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry7 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry8 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry1 (\10\:net116 \11\:net116) resistor r=62 c=0
Ry2 (\12\:net116 \13\:net116) resistor r=62 c=0
Rx3 (\3\:B \5\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:A \4\:A) resistor r=45 c=0
Rx5 (\3\:net116 \5\:net116) resistor r=45 c=0
mn3 (\7\:net116 \1\:D net132 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.667e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.75e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn2 (net132 \3\:C net128 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.667e-14 ps=7.3e-07 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=8.15e-07 sd=160n sca=10.7143 scb=0.0101371 \
        scc=0.000327098 m=(1)
mn1 (net128 \4\:B net124 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.522e-14 ad=3.19e-14 ps=5e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=5.5e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn0 (net124 \3\:A \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.727e-14 ad=1.522e-14 ps=9.5e-07 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=4e-07 sd=160n sca=10.7143 scb=0.0101371 \
        scc=0.000327098 m=(1)
mn4 (\3\:Y \4\:net116 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.728e-14 ad=3.64e-14 ps=9.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05673e-07 sb=1.4e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mp2 (\10\:net116 \1\:C \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.15e-14 ad=3.44e-14 ps=1.44e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.15e-07 sd=160n sca=14.6329 \
        scb=0.0132741 scc=0.000215448 m=(1)
mp1 (\12\:net116 \1\:B \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.15e-14 ad=3.44e-14 ps=1.44e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=5.5e-07 sd=160n sca=12.5692 \
        scb=0.0096429 scc=0.000174148 m=(1)
mp0 (\12\:net116 \1\:A \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.44e-14 ps=1.1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=3.45e-07 sd=160n sca=13.1799 \
        scb=0.0106657 scc=0.000178932 m=(1)
mp4 (\1\:Y net116 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.07179e-07 sb=1.4e-07 sd=160n sca=24.4649 \
        scb=0.024645 scc=0.00179971 m=(1)
ends AND4X1
// End of subcircuit definition.

// Generated for: spectre (May  8 14:59:52 2012 )
// Library name: gsclib045
// Cell name: AO22X1
// View name: extracted

simulator lang=spectre

subckt AO22X1 A0 A1 B0 B1 VDD VSS Y
mp0 (\5\:n3 \3\:A0 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.45e-07 sd=160n sca=24.7768 \
        scb=0.0281397 scc=0.00159433 m=(1)
C1 (A0 VSS) capacitor c=4.55445e-17
C2 (B0 VSS) capacitor c=4.7681e-17
C3 (B1 VSS) capacitor c=2.623e-17
C4 (VDD VSS) capacitor c=1.17128e-16
C5 (A1 VSS) capacitor c=2.94397e-17
C6 (n0 VSS) capacitor c=3.86517e-17
C7 (n2 VSS) capacitor c=6.05147e-18
C8 (n3 VSS) capacitor c=6.32654e-17
C9 (\4\:B0 VSS) capacitor c=5.11424e-17
C10 (\1\:B1 VSS) capacitor c=5.56833e-17
C11 (\1\:A1 VSS) capacitor c=5.41263e-17
C12 (\3\:A0 VSS) capacitor c=5.37643e-17
C13 (\3\:n0 VSS) capacitor c=4.56462e-17
C14 (\3\:B0 VSS) capacitor c=2.32873e-17
C15 (\3\:B1 VSS) capacitor c=3.29301e-17
C16 (\3\:A1 VSS) capacitor c=6.60005e-17
C17 (\1\:A0 VSS) capacitor c=4.19503e-17
C18 (\2\:n0 VSS) capacitor c=2.92401e-17
C19 (\1\:B0 VSS) capacitor c=1.9111e-17
C20 (\2\:B1 VSS) capacitor c=5.08974e-17
C21 (\2\:A1 VSS) capacitor c=5.70204e-17
C22 (\2\:A0 VSS) capacitor c=5.06711e-17
C23 (\3\:Y VSS) capacitor c=8.76838e-17
C24 (\1\:VDD VSS) capacitor c=9.12816e-17
C25 (\8\:n0 VSS) capacitor c=4.18972e-17
C26 (\3\:n3 VSS) capacitor c=6.95323e-17
C27 (\7\:VDD VSS) capacitor c=1.12661e-17
C28 (\5\:n3 VSS) capacitor c=3.622e-17
C29 (\3\:VDD VSS) capacitor c=4.33507e-17
C30 (\1\:Y VSS) capacitor c=6.62288e-17
C31 (\6\:n0 VSS) capacitor c=8.38476e-17
C32 (\2\:B0 VSS) capacitor c=3.3016e-17
C33 (\4\:A0 VSS) capacitor c=5.45822e-17
C34 (\4\:A1 VSS) capacitor c=3.7621e-17
C35 (\4\:B1 VSS) capacitor c=6.51324e-17
C36 (\5\:B0 VSS) capacitor c=6.31746e-17
C37 (\4\:n0 VSS) capacitor c=4.86233e-17
C38 (\5\:n0 VSS) capacitor c=1.1055e-16
C39 (\5\:VDD VSS) capacitor c=1.71965e-17
Rk1 (\4\:A0 A0) resistor r=0.2486 c=0
Rk6 (B0 \5\:B0) resistor r=0.1099 c=0
Rk3 (B1 \4\:B1) resistor r=0.02602 c=0
Rk17 (\2\:VSS \4\:VSS) resistor r=0.365 c=0
Rk19 (\5\:VSS VSS) resistor r=0.0446 c=0
Rk18 (\4\:VSS \5\:VSS) resistor r=0.3551 c=0
Rk21 (\5\:VSS \8\:VSS) resistor r=0.2782 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.3732 c=0
Rk13 (\4\:VDD \5\:VDD) resistor r=0.3326 c=0
Rk15 (\6\:VDD VDD) resistor r=0.0498 c=0
Rk14 (\5\:VDD \6\:VDD) resistor r=0.06737 c=0
Rk16 (\5\:VDD \8\:VDD) resistor r=0.07311 c=0
Rk2 (A1 \4\:A1) resistor r=0.02681 c=0
Rk10 (\2\:Y Y) resistor r=0.5751 c=0
Rk11 (Y \4\:Y) resistor r=0.004834 c=0
Rk7 (\4\:n0 \5\:n0) resistor r=0.2796 c=0
Rk8 (\5\:n0 \7\:n0) resistor r=0.49 c=0
Rk9 (\5\:n0 \9\:n0) resistor r=0.1947 c=0
Rk4 (\2\:n3 \4\:n3) resistor r=0.3951 c=0
Rk5 (\4\:n3 \6\:n3) resistor r=0.2726 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=161.333 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=55.7464 c=0
Rl9 (\2\:B0 \4\:B0) resistor r=171.957 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=45.0334 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=5.0163 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=156.461 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=44.9225 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=91.5405 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=106.925 c=0
Rl10 (n0 \2\:n0) resistor r=35.7713 c=0
Rl11 (\2\:n0 \3\:n0) resistor r=133.848 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz3 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz4 (\3\:VDD \6\:VDD) resistor r=37.5 c=0
Rz2 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz1 (\6\:n0 \7\:n0) resistor r=75 c=0
Ry9 (\3\:VSS VSS) resistor r=62 c=0
Ry8 (\3\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry7 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry5 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry4 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry1 (n3 \2\:n3) resistor r=62 c=0
Ry2 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry3 (\5\:n3 \6\:n3) resistor r=62 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\1\:B0 \5\:B0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx5 (\2\:n0 \4\:n0) resistor r=45 c=0
mn0 (n1 \1\:A0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.06e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn1 (\6\:n0 \3\:A1 n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=9.55e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn3 (\6\:n0 \3\:B1 n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=7.5e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn2 (n2 \3\:B0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.83e-14 ad=2.32e-14 ps=1.24e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=5.45e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn4 (\1\:Y \3\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.83e-14 ad=3.64e-14 ps=1.24e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.53077e-07 sb=1.4e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mp1 (\3\:n3 \1\:A1 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.44e-14 ps=1.45e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=5.5e-07 sd=160n sca=14.9462 \
        scb=0.0138238 scc=0.000237852 m=(1)
mp3 (\8\:n0 \1\:B1 \3\:n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=3.45e-07 sd=160n sca=12.4379 \
        scb=0.00997048 scc=0.000189166 m=(1)
mp2 (\8\:n0 \4\:B0 n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=1.4e-07 sd=160n sca=11.9066 \
        scb=0.00936839 scc=0.000188025 m=(1)
mp4 (\3\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.2631 \
        scb=0.0157178 scc=0.000443168 m=(1)
ends AO22X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:00:39 2012 )
// Library name: gsclib045
// Cell name: AOI221X1
// View name: extracted

simulator lang=spectre

subckt AOI221X1 A0 A1 B0 B1 C0 VDD VSS Y
mp0 (\3\:net108 \3\:A0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.05e-07 sd=160n sca=40.7758 \
        scb=0.038454 scc=0.00437052 m=(1)
C1 (A0 VSS) capacitor c=2.97566e-17
C2 (VDD VSS) capacitor c=5.15606e-17
C3 (Y VSS) capacitor c=4.11254e-17
C4 (net128 VSS) capacitor c=1.66661e-18
C5 (net120 VSS) capacitor c=3.08887e-18
C6 (net108 VSS) capacitor c=9.32052e-17
C7 (net111 VSS) capacitor c=7.02549e-17
C8 (\1\:C0 VSS) capacitor c=4.32573e-17
C9 (\1\:B0 VSS) capacitor c=4.78191e-17
C10 (\1\:B1 VSS) capacitor c=5.74231e-17
C11 (\1\:A1 VSS) capacitor c=5.42375e-17
C12 (\3\:A0 VSS) capacitor c=4.66029e-17
C13 (\3\:C0 VSS) capacitor c=3.80372e-17
C14 (\3\:B0 VSS) capacitor c=6.98594e-17
C15 (\4\:B1 VSS) capacitor c=5.28607e-17
C16 (\3\:A1 VSS) capacitor c=4.5035e-17
C17 (\1\:A0 VSS) capacitor c=3.60487e-17
C18 (\2\:C0 VSS) capacitor c=3.61186e-17
C19 (\2\:B0 VSS) capacitor c=5.51936e-17
C20 (\3\:B1 VSS) capacitor c=4.9841e-17
C21 (\2\:A1 VSS) capacitor c=3.81714e-17
C22 (\2\:A0 VSS) capacitor c=3.85002e-17
C23 (\4\:Y VSS) capacitor c=2.66047e-17
C24 (\3\:net111 VSS) capacitor c=6.5118e-17
C25 (\7\:VDD VSS) capacitor c=1.18851e-17
C26 (\3\:net108 VSS) capacitor c=5.76541e-17
C27 (\5\:VDD VSS) capacitor c=3.58033e-17
C28 (\1\:VDD VSS) capacitor c=4.43939e-17
C29 (\6\:Y VSS) capacitor c=2.70563e-17
C30 (\1\:Y VSS) capacitor c=7.47651e-17
C31 (\4\:A0 VSS) capacitor c=4.16641e-17
C32 (\4\:A1 VSS) capacitor c=6.14891e-17
C33 (\6\:B1 VSS) capacitor c=6.02088e-17
C34 (\7\:B1 VSS) capacitor c=4.11389e-17
C35 (\4\:B0 VSS) capacitor c=7.16203e-17
C36 (\6\:B0 VSS) capacitor c=3.23349e-17
C37 (\4\:C0 VSS) capacitor c=4.55362e-17
C38 (\6\:C0 VSS) capacitor c=3.88793e-17
C39 (\3\:Y VSS) capacitor c=8.02639e-17
C40 (\3\:VDD VSS) capacitor c=1.62283e-18
Rk11 (C0 \4\:C0) resistor r=0.002852 c=0
Rk13 (\4\:C0 \6\:C0) resistor r=0.007527 c=0
Rk12 (\5\:C0 \6\:C0) resistor r=0.002852 c=0
Rk2 (\4\:A1 A1) resistor r=0.03258 c=0
Rk18 (\2\:VSS \3\:VSS) resistor r=0.1201 c=0
Rk19 (\3\:VSS \4\:VSS) resistor r=0.2303 c=0
Rk21 (\5\:VSS VSS) resistor r=0.01709 c=0
Rk20 (\4\:VSS \5\:VSS) resistor r=0.1827 c=0
Rk22 (\3\:VSS \7\:VSS) resistor r=0.1683 c=0
Rk23 (\5\:VSS \9\:VSS) resistor r=0.2127 c=0
Rk1 (A0 \4\:A0) resistor r=0.07948 c=0
Rk7 (\4\:B0 \5\:B0) resistor r=0.001408 c=0
Rk8 (B0 \6\:B0) resistor r=0.001314 c=0
Rk9 (\4\:B0 \6\:B0) resistor r=0.04218 c=0
Rk24 (\2\:VDD \3\:VDD) resistor r=0.2303 c=0
Rk26 (\4\:VDD VDD) resistor r=0.1003 c=0
Rk25 (\3\:VDD \4\:VDD) resistor r=0.1201 c=0
Rk27 (VDD \6\:VDD) resistor r=0.3929 c=0
Rk28 (\3\:VDD \8\:VDD) resistor r=0.1563 c=0
Rk3 (\5\:B1 \6\:B1) resistor r=0.001878 c=0
Rk4 (B1 \7\:B1) resistor r=0.001784 c=0
Rk5 (\5\:B1 \7\:B1) resistor r=0.1097 c=0
Rk15 (\3\:Y Y) resistor r=0.4127 c=0
Rk14 (\2\:Y \3\:Y) resistor r=0.4174 c=0
Rk16 (Y \5\:Y) resistor r=0.03477 c=0
Rk17 (\3\:Y \7\:Y) resistor r=0.08872 c=0
Rk6 (\2\:net108 \4\:net108) resistor r=0.4022 c=0
Rk10 (\2\:net111 \4\:net111) resistor r=0.3777 c=0
Rl10 (\1\:C0 \2\:C0) resistor r=79.0433 c=0
Rl11 (\2\:C0 \3\:C0) resistor r=60.989 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=73.7687 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=62.2302 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=106.868 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=30.7692 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=41.3798 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=94.0258 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=91.1873 c=0
Rl7 (\2\:B1 \4\:B1) resistor r=60.4181 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=0.6051 c=0
Rz3 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz4 (\8\:VSS \9\:VSS) resistor r=37.5 c=0
Rz5 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Rz6 (\1\:VDD \4\:VDD) resistor r=25 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\6\:Y \7\:Y) resistor r=75 c=0
Ry6 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry7 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry8 (\5\:VDD \6\:VDD) resistor r=20.6667 c=0
Ry9 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry5 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry1 (net108 \2\:net108) resistor r=62 c=0
Ry2 (\3\:net108 \4\:net108) resistor r=62 c=0
Ry3 (net111 \2\:net111) resistor r=31 c=0
Ry4 (\3\:net111 \4\:net111) resistor r=62 c=0
Rx5 (\2\:C0 \5\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \5\:B0) resistor r=45 c=0
Rx3 (\3\:B1 \6\:B1) resistor r=45 c=0
mn0 (net128 \1\:A0 \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=2.34e-14 ps=8.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=1.03e-06 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\1\:Y \4\:B1 net120 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.82e-14 ad=8.32e-14 ps=6.6e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=5.3e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\1\:Y \3\:A1 net128 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=8.32e-14 ps=7e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.1e-07 sb=8.95e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (net120 \3\:B0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=1.82e-14 ps=8.4e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=4.15e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn4 (\6\:Y \3\:C0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=5.46e-14 ps=8.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=2.1e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mp1 (\3\:net108 \1\:A1 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.265e-14 ad=6.24e-14 ps=1.78e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1e-07 sd=160n sca=30.7421 scb=0.0237813 \
        scc=0.0030059 m=(1)
mp3 (net108 \1\:B1 \3\:net111 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=28.7609 scb=0.020281 \
        scc=0.00296496 m=(1)
mp2 (net108 \1\:B0 net111 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=30.4607 \
        scb=0.0232925 scc=0.00299608 m=(1)
mp4 (\4\:Y \1\:C0 net111 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=39.2278 \
        scb=0.0367431 scc=0.00406631 m=(1)
ends AOI221X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:01:25 2012 )
// Library name: gsclib045
// Cell name: AOI22X1
// View name: extracted

simulator lang=spectre

subckt AOI22X1 A0 A1 B0 B1 VDD VSS Y
mp0 (\5\:net89 \1\:A0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.26e-14 ad=5.46e-14 ps=1.44e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.65e-07 sd=160n sca=25.383 \
        scb=0.0290112 scc=0.00169816 m=(1)
C1 (B1 VSS) capacitor c=2.44604e-17
C2 (Y VSS) capacitor c=7.86073e-17
C3 (VDD VSS) capacitor c=8.57015e-17
C4 (A0 VSS) capacitor c=7.35516e-17
C5 (B0 VSS) capacitor c=3.48235e-17
C6 (net102 VSS) capacitor c=2.43791e-18
C7 (net89 VSS) capacitor c=5.34498e-17
C8 (\1\:B0 VSS) capacitor c=5.46265e-17
C9 (\1\:B1 VSS) capacitor c=5.68589e-17
C10 (\1\:A1 VSS) capacitor c=8.202e-17
C11 (\1\:A0 VSS) capacitor c=6.87969e-17
C12 (\3\:B0 VSS) capacitor c=4.189e-17
C13 (\3\:B1 VSS) capacitor c=5.40722e-17
C14 (\3\:A1 VSS) capacitor c=3.99751e-17
C15 (\4\:A0 VSS) capacitor c=4.32286e-17
C16 (\2\:B0 VSS) capacitor c=5.09864e-17
C17 (\2\:B1 VSS) capacitor c=5.53738e-17
C18 (\2\:A1 VSS) capacitor c=6.18703e-17
C19 (\3\:A0 VSS) capacitor c=1.69313e-17
C20 (\1\:Y VSS) capacitor c=8.59762e-17
C21 (\3\:net89 VSS) capacitor c=9.50726e-17
C22 (\5\:VDD VSS) capacitor c=4.79117e-17
C23 (\5\:net89 VSS) capacitor c=4.34788e-17
C24 (\1\:VDD VSS) capacitor c=4.60398e-17
C25 (\3\:Y VSS) capacitor c=1.06093e-16
C26 (\2\:A0 VSS) capacitor c=3.84168e-17
C27 (\4\:A1 VSS) capacitor c=4.08718e-17
C28 (\5\:A1 VSS) capacitor c=4.94804e-17
C29 (\4\:B1 VSS) capacitor c=7.18194e-17
C30 (\4\:B0 VSS) capacitor c=3.53857e-17
C31 (\3\:VDD VSS) capacitor c=3.69618e-18
Rk5 (B1 \4\:B1) resistor r=0.03079 c=0
Rk6 (\2\:Y Y) resistor r=0.2428 c=0
Rk7 (Y \4\:Y) resistor r=0.5393 c=0
Rk2 (A1 \4\:A1) resistor r=0.004076 c=0
Rk4 (\4\:A1 \5\:A1) resistor r=0.06597 c=0
Rk3 (\5\:A1 \6\:A1) resistor r=0.004196 c=0
Rk12 (\4\:VSS VSS) resistor r=0.2507 c=0
Rk11 (\2\:VSS \4\:VSS) resistor r=0.3583 c=0
Rk13 (VSS \6\:VSS) resistor r=0.2284 c=0
Rk14 (\2\:VDD \3\:VDD) resistor r=0.247 c=0
Rk16 (\4\:VDD VDD) resistor r=0.04987 c=0
Rk15 (\3\:VDD \4\:VDD) resistor r=0.05148 c=0
Rk17 (\3\:VDD \6\:VDD) resistor r=0.1285 c=0
Rk1 (A0 \5\:A0) resistor r=0.00426 c=0
Rk10 (\4\:B0 B0) resistor r=0.03383 c=0
Rk8 (\2\:net89 \4\:net89) resistor r=0.4624 c=0
Rk9 (\4\:net89 \6\:net89) resistor r=0.4119 c=0
Rl6 (\1\:B1 \2\:B1) resistor r=98.0568 c=0
Rl7 (\2\:B1 \3\:B1) resistor r=94.2107 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=171.131 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=24.7951 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=152.726 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=60.4181 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=5.013 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=144.231 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=54.9451 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz3 (\5\:VSS \6\:VSS) resistor r=37.5 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry6 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry2 (net89 \2\:net89) resistor r=20.6667 c=0
Ry3 (\3\:net89 \4\:net89) resistor r=31 c=0
Ry4 (\5\:net89 \6\:net89) resistor r=31 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \6\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (net102 \4\:A0 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.99e-14 ps=8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.1e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (\3\:Y \3\:A1 net102 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=5.46e-14 ps=7.5e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=5.5e-07 sd=160n sca=7.84363 scb=0.00546499 \
        scc=9.84911e-05 m=(1)
mn3 (\3\:Y \3\:B1 net98 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.86e-14 ad=5.46e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2.95e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (net98 \3\:B0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=2.86e-14 ps=8e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.1e-07 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mp1 (\3\:net89 \1\:A1 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.26e-14 ad=6.435e-14 ps=1.44e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.6e-07 sd=160n sca=15.7692 \
        scb=0.0144715 scc=0.000333573 m=(1)
mp3 (\1\:Y \1\:B1 \3\:net89 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.435e-14 ad=6.435e-14 ps=1.11e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=3.5e-07 sd=160n sca=14.4126 \
        scb=0.011746 scc=0.00029444 m=(1)
mp2 (\1\:Y \1\:B0 net89 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.435e-14 ps=1.06e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=1.4e-07 sd=160n sca=16.4371 \
        scb=0.0157949 scc=0.000369535 m=(1)
ends AOI22X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:02:16 2012 )
// Library name: gsclib045
// Cell name: AOI22XL
// View name: extracted

simulator lang=spectre

subckt AOI22XL A0 A1 B0 B1 VDD VSS Y
mp0 (\5\:net89 \1\:A0 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.15e-07 sd=160n sca=25.0208 \
        scb=0.0285597 scc=0.00162702 m=(1)
C1 (B1 VSS) capacitor c=6.71792e-17
C2 (Y VSS) capacitor c=8.13889e-17
C3 (A1 VSS) capacitor c=3.17764e-17
C4 (A0 VSS) capacitor c=2.3033e-17
C5 (VDD VSS) capacitor c=1.04732e-16
C6 (net98 VSS) capacitor c=3.10182e-18
C7 (net89 VSS) capacitor c=5.47903e-17
C8 (\4\:B0 VSS) capacitor c=4.41446e-17
C9 (\1\:B1 VSS) capacitor c=5.04512e-17
C10 (\1\:A1 VSS) capacitor c=6.58241e-17
C11 (\1\:A0 VSS) capacitor c=3.874e-17
C12 (\3\:B0 VSS) capacitor c=4.07835e-17
C13 (\3\:B1 VSS) capacitor c=3.55663e-17
C14 (\3\:A1 VSS) capacitor c=2.86893e-17
C15 (\4\:A0 VSS) capacitor c=5.23884e-17
C16 (\1\:B0 VSS) capacitor c=1.15583e-17
C17 (\2\:B1 VSS) capacitor c=5.78925e-17
C18 (\2\:A1 VSS) capacitor c=5.67568e-17
C19 (\3\:A0 VSS) capacitor c=5.27976e-17
C20 (\3\:Y VSS) capacitor c=3.53837e-17
C21 (\3\:net89 VSS) capacitor c=8.84435e-17
C22 (\5\:VDD VSS) capacitor c=4.7993e-17
C23 (\5\:net89 VSS) capacitor c=5.21661e-17
C24 (\1\:VDD VSS) capacitor c=4.25558e-17
C25 (\1\:Y VSS) capacitor c=1.08725e-16
C26 (\2\:B0 VSS) capacitor c=4.41809e-17
C27 (\5\:A0 VSS) capacitor c=3.00928e-17
C28 (\4\:A1 VSS) capacitor c=4.00821e-17
C29 (\4\:B1 VSS) capacitor c=5.13275e-17
C30 (\5\:B0 VSS) capacitor c=2.96057e-17
C31 (\7\:B0 VSS) capacitor c=2.04827e-17
C32 (\3\:VDD VSS) capacitor c=1.48719e-18
Rk3 (B1 \4\:B1) resistor r=0.1085 c=0
Rk4 (\2\:Y Y) resistor r=0.572 c=0
Rk5 (Y \4\:Y) resistor r=0.07986 c=0
Rk2 (A1 \4\:A1) resistor r=0.08406 c=0
Rk11 (\2\:VSS \3\:VSS) resistor r=0.05994 c=0
Rk13 (\4\:VSS VSS) resistor r=0.2005 c=0
Rk12 (\3\:VSS \4\:VSS) resistor r=0.2404 c=0
Rk14 (VSS \6\:VSS) resistor r=0.1816 c=0
Rk15 (\3\:VSS \8\:VSS) resistor r=0.1729 c=0
Rk1 (A0 \5\:A0) resistor r=0.0139 c=0
Rk6 (\5\:B0 \6\:B0) resistor r=0.004213 c=0
Rk7 (B0 \7\:B0) resistor r=0.004073 c=0
Rk8 (\5\:B0 \7\:B0) resistor r=0.04761 c=0
Rk16 (\2\:VDD \3\:VDD) resistor r=0.2479 c=0
Rk18 (\4\:VDD VDD) resistor r=0.04986 c=0
Rk17 (\3\:VDD \4\:VDD) resistor r=0.05242 c=0
Rk19 (\3\:VDD \6\:VDD) resistor r=0.2816 c=0
Rk9 (\2\:net89 \4\:net89) resistor r=0.5175 c=0
Rk10 (\4\:net89 \6\:net89) resistor r=0.2845 c=0
Rl6 (\1\:B1 \2\:B1) resistor r=160.771 c=0
Rl7 (\2\:B1 \3\:B1) resistor r=95.3867 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=231.925 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=24.2328 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=96.9565 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=177.726 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=0.6051 c=0
Rl10 (\2\:B0 \4\:B0) resistor r=132.406 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=143.945 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=0.5213 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz3 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry6 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry7 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry2 (net89 \2\:net89) resistor r=62 c=0
Ry3 (\3\:net89 \4\:net89) resistor r=62 c=0
Ry4 (\5\:net89 \6\:net89) resistor r=62 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
Rx4 (\1\:B0 \6\:B0) resistor r=45 c=0
mn0 (net106 \4\:A0 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.15e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn1 (\1\:Y \3\:A1 net106 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.1e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn3 (\1\:Y \3\:B1 net98 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.19e-14 ps=6.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.45e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (net98 \3\:B0 \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mp1 (\3\:net89 \1\:A1 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.73e-14 ps=7.5e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.1e-07 sd=160n sca=15.407 scb=0.01402 \
        scc=0.000262427 m=(1)
mp3 (\3\:Y \1\:B1 \3\:net89 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.44e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=3.45e-07 sd=160n sca=14.2109 \
        scb=0.0116139 scc=0.000225742 m=(1)
mp2 (\3\:Y \4\:B0 net89 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.15e-07 sb=1.4e-07 sd=160n sca=17.4411 \
        scb=0.0179282 scc=0.000407312 m=(1)
ends AOI22XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:03:06 2012 )
// Library name: gsclib045
// Cell name: AOI2BB1X1
// View name: extracted

simulator lang=spectre

subckt AOI2BB1X1 A0N A1N B0 VDD VSS Y
mp3 (\1\:Y n0 n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=4.40705e-07 sd=160n sca=15.9621 scb=0.0150202 \
        scc=0.000309344 m=(1)
C1 (Y VSS) capacitor c=9.42279e-17
C2 (B0 VSS) capacitor c=5.11059e-17
C3 (A1N VSS) capacitor c=2.50266e-17
C4 (VDD VSS) capacitor c=9.44019e-17
C5 (A0N VSS) capacitor c=6.26112e-17
C6 (n0 VSS) capacitor c=9.12335e-17
C7 (n2 VSS) capacitor c=1.75431e-18
C8 (\3\:A1N VSS) capacitor c=7.75483e-17
C9 (\1\:A0N VSS) capacitor c=6.92147e-17
C10 (\3\:B0 VSS) capacitor c=8.93613e-17
C11 (\1\:A1N VSS) capacitor c=2.80272e-17
C12 (\3\:A0N VSS) capacitor c=4.5907e-17
C13 (\1\:B0 VSS) capacitor c=5.93751e-17
C14 (\3\:n0 VSS) capacitor c=2.88397e-17
C15 (\4\:A1N VSS) capacitor c=1.22835e-17
C16 (\2\:A0N VSS) capacitor c=6.35302e-17
C17 (\2\:B0 VSS) capacitor c=6.54199e-17
C18 (\2\:n0 VSS) capacitor c=5.66095e-17
C19 (\4\:n0 VSS) capacitor c=5.53819e-17
C20 (\5\:VDD VSS) capacitor c=3.76739e-17
C21 (\1\:Y VSS) capacitor c=8.04762e-17
C22 (\1\:VDD VSS) capacitor c=1.88459e-17
C23 (\8\:n0 VSS) capacitor c=3.11188e-17
C24 (\3\:Y VSS) capacitor c=4.46671e-17
C25 (\2\:A1N VSS) capacitor c=4.26746e-17
C26 (\4\:B0 VSS) capacitor c=6.57927e-17
C27 (\4\:A0N VSS) capacitor c=4.61162e-17
C28 (\6\:n0 VSS) capacitor c=1.06502e-16
C29 (\7\:n0 VSS) capacitor c=8.58824e-17
C30 (\5\:A1N VSS) capacitor c=4.34788e-17
C31 (\3\:VDD VSS) capacitor c=2.88702e-18
Rk1 (\2\:Y Y) resistor r=0.6666 c=0
Rk2 (Y \4\:Y) resistor r=0.08156 c=0
Rk3 (B0 \4\:B0) resistor r=0.09846 c=0
Rk10 (\5\:A1N \6\:A1N) resistor r=0.01391 c=0
Rk11 (A1N \7\:A1N) resistor r=0.01391 c=0
Rk12 (\5\:A1N \7\:A1N) resistor r=0.02119 c=0
Rk21 (\2\:VDD \3\:VDD) resistor r=0.1552 c=0
Rk23 (\4\:VDD VDD) resistor r=0.1 c=0
Rk22 (\3\:VDD \4\:VDD) resistor r=0.1452 c=0
Rk24 (\3\:VDD \6\:VDD) resistor r=0.2213 c=0
Rk13 (\2\:VSS \4\:VSS) resistor r=0.3506 c=0
Rk14 (\4\:VSS \5\:VSS) resistor r=0.1326 c=0
Rk15 (\5\:VSS \6\:VSS) resistor r=0.1176 c=0
Rk17 (\7\:VSS VSS) resistor r=0.03965 c=0
Rk16 (\6\:VSS \7\:VSS) resistor r=0.1101 c=0
Rk19 (\5\:VSS \10\:VSS) resistor r=0.2611 c=0
Rk20 (\7\:VSS \12\:VSS) resistor r=0.1785 c=0
Rk6 (\4\:A0N A0N) resistor r=0.02396 c=0
Rk7 (\5\:n0 \6\:n0) resistor r=0.4796 c=0
Rk8 (\6\:n0 \7\:n0) resistor r=0.3662 c=0
Rk9 (\6\:n0 \9\:n0) resistor r=0.1404 c=0
Rl4 (\2\:B0 \3\:B0) resistor r=87.6365 c=0
Rl3 (\1\:B0 \2\:B0) resistor r=103.021 c=0
Rl8 (\2\:A1N \3\:A1N) resistor r=167.616 c=0
Rl7 (\1\:A1N \2\:A1N) resistor r=71.8171 c=0
Rl9 (\2\:A1N \4\:A1N) resistor r=5.1011 c=0
Rl5 (\1\:A0N \2\:A0N) resistor r=91.0764 c=0
Rl6 (\2\:A0N \3\:A0N) resistor r=106.461 c=0
Rl1 (n0 \2\:n0) resistor r=165.385 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=33.7912 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz6 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz7 (\1\:VDD \4\:VDD) resistor r=25 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz5 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry6 (\5\:VDD \6\:VDD) resistor r=31 c=0
Ry5 (\3\:VSS VSS) resistor r=62 c=0
Ry3 (\3\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry4 (\3\:VSS \6\:VSS) resistor r=31 c=0
Ry2 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx1 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx4 (\4\:A1N \6\:A1N) resistor r=45 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx3 (\2\:n0 \7\:n0) resistor r=45 c=0
mn3 (\3\:Y \3\:n0 \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=5.72692e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mn2 (\3\:Y \1\:B0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=3.67692e-07 sd=160n sca=8.22858 \
        scb=0.00610564 scc=0.00012768 m=(1)
mn0 (\8\:n0 \3\:A0N \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.755e-14 ps=8.4e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=3.75e-07 sd=160n sca=9.68855 \
        scb=0.00848242 scc=0.000213356 m=(1)
mn1 (\8\:n0 \1\:A1N \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.755e-14 ps=5.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=1.4e-07 sd=160n sca=9.68855 scb=0.00848242 \
        scc=0.000213356 m=(1)
mp2 (n2 \3\:B0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.858e-14 ad=2.34e-14 ps=1.19e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.35705e-07 sd=160n sca=14.5611 \
        scb=0.0122104 scc=0.000254242 m=(1)
mp0 (n1 \1\:A0N \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.858e-14 ad=1.29e-14 ps=1.19e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=2.45e-07 sd=160n sca=15.6375 \
        scb=0.0141102 scc=0.000376252 m=(1)
mp1 (\4\:n0 \3\:A1N n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=1.4e-07 sd=160n sca=17.3765 scb=0.017565 \
        scc=0.000461873 m=(1)
ends AOI2BB1X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:03:51 2012 )
// Library name: gsclib045
// Cell name: AOI31X1
// View name: extracted

simulator lang=spectre

subckt AOI31X1 A0 A1 A2 B0 VDD VSS Y
mp0 (net81 \3\:A0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.7e-07 sd=160n sca=18.8466 \
        scb=0.0203197 scc=0.000573038 m=(1)
C1 (Y VSS) capacitor c=1.85774e-17
C2 (A2 VSS) capacitor c=7.86189e-17
C3 (A1 VSS) capacitor c=8.2004e-17
C4 (VDD VSS) capacitor c=8.52842e-17
C5 (A0 VSS) capacitor c=5.05844e-17
C6 (B0 VSS) capacitor c=6.56714e-17
C7 (net81 VSS) capacitor c=1.00567e-16
C8 (\1\:B0 VSS) capacitor c=4.33396e-17
C9 (\1\:A2 VSS) capacitor c=5.73701e-17
C10 (\1\:A1 VSS) capacitor c=7.19411e-17
C11 (\3\:A0 VSS) capacitor c=4.54482e-17
C12 (\3\:B0 VSS) capacitor c=3.85851e-17
C13 (\3\:A2 VSS) capacitor c=6.01513e-17
C14 (\3\:A1 VSS) capacitor c=6.47379e-17
C15 (\1\:A0 VSS) capacitor c=7.37816e-17
C16 (\2\:B0 VSS) capacitor c=4.38065e-17
C17 (\2\:A2 VSS) capacitor c=6.29509e-17
C18 (\2\:A1 VSS) capacitor c=7.82413e-17
C19 (\2\:A0 VSS) capacitor c=5.75657e-17
C20 (\4\:Y VSS) capacitor c=2.2384e-17
C21 (\3\:net81 VSS) capacitor c=1.02821e-16
C22 (\7\:VDD VSS) capacitor c=7.10009e-17
C23 (\9\:VDD VSS) capacitor c=4.04035e-17
C24 (\1\:VDD VSS) capacitor c=5.14901e-17
C25 (\1\:Y VSS) capacitor c=1.2086e-16
C26 (\4\:A0 VSS) capacitor c=2.70655e-17
C27 (\4\:A1 VSS) capacitor c=4.72527e-17
C28 (\4\:A2 VSS) capacitor c=3.80121e-17
C29 (\4\:B0 VSS) capacitor c=5.32995e-17
C30 (\3\:Y VSS) capacitor c=9.13787e-17
C31 (\3\:VDD VSS) capacitor c=2.51972e-18
C32 (\5\:VDD VSS) capacitor c=1.53794e-18
Rk10 (\3\:Y Y) resistor r=0.01805 c=0
Rk8 (\2\:Y \3\:Y) resistor r=0.9703 c=0
Rk9 (\3\:Y \5\:Y) resistor r=0.2458 c=0
Rk4 (\6\:A2 A2) resistor r=0.001036 c=0
Rk5 (\4\:A2 \6\:A2) resistor r=0.05079 c=0
Rk2 (\4\:A1 A1) resistor r=0.1517 c=0
Rk11 (\2\:VSS \3\:VSS) resistor r=0.06752 c=0
Rk12 (\3\:VSS \4\:VSS) resistor r=0.233 c=0
Rk14 (\5\:VSS VSS) resistor r=0.09234 c=0
Rk13 (\4\:VSS \5\:VSS) resistor r=0.1076 c=0
Rk15 (\3\:VSS \7\:VSS) resistor r=0.2232 c=0
Rk16 (\5\:VSS \9\:VSS) resistor r=0.2143 c=0
Rk17 (\2\:VDD \3\:VDD) resistor r=0.1528 c=0
Rk18 (\3\:VDD \4\:VDD) resistor r=0.09761 c=0
Rk20 (\5\:VDD VDD) resistor r=0.04219 c=0
Rk19 (\4\:VDD \5\:VDD) resistor r=0.1076 c=0
Rk22 (\3\:VDD \8\:VDD) resistor r=0.2343 c=0
Rk23 (\5\:VDD \10\:VDD) resistor r=0.2789 c=0
Rk1 (A0 \4\:A0) resistor r=0.1111 c=0
Rk7 (\4\:B0 B0) resistor r=0.1654 c=0
Rk6 (\2\:net81 \4\:net81) resistor r=0.5322 c=0
Rl5 (\1\:A2 \2\:A2) resistor r=110.771 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=91.5405 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=175.692 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=29.5379 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=78.079 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=138.261 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=113.462 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=93.4066 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz2 (\6\:VSS \7\:VSS) resistor r=37.5 c=0
Rz3 (\8\:VSS \9\:VSS) resistor r=37.5 c=0
Rz6 (\1\:VDD VDD) resistor r=75 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Ry3 (\4\:Y \5\:Y) resistor r=31 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry5 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry6 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry7 (\9\:VDD \10\:VDD) resistor r=20.6667 c=0
Ry1 (net81 \2\:net81) resistor r=31 c=0
Ry2 (\3\:net81 \4\:net81) resistor r=31 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
mn0 (net97 \1\:A0 \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.15e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn1 (net97 \3\:A1 net93 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=1.56e-14 ps=7.5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.1e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (\1\:Y \3\:A2 net93 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.99e-14 ad=4.29e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.5e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn3 (\1\:Y \3\:B0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.29e-14 ps=8e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mp1 (net81 \1\:A1 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.65e-07 sd=160n sca=14.4531 \
        scb=0.0120361 scc=0.000241045 m=(1)
mp2 (\3\:net81 \1\:A2 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.825e-14 ps=1.1e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.6e-07 sd=160n sca=14.3825 \
        scb=0.0118943 scc=0.000239579 m=(1)
mp3 (\4\:Y \1\:B0 \3\:net81 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=5.46e-14 ps=1.13e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=1.4e-07 sd=160n sca=19.0814 \
        scb=0.0207066 scc=0.000603442 m=(1)
ends AOI31X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:04:38 2012 )
// Library name: gsclib045
// Cell name: AOI33XL
// View name: extracted

simulator lang=spectre

subckt AOI33XL A0 A1 A2 B0 B1 B2 VDD VSS Y
mp0 (net124 \3\:A0 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=3.655e-14 ps=1.31e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.165e-06 sd=160n sca=30.1692 \
        scb=0.0324471 scc=0.00278498 m=(1)
C1 (B1 VSS) capacitor c=6.50543e-17
C2 (A1 VSS) capacitor c=2.43984e-17
C3 (B2 VSS) capacitor c=2.38334e-17
C4 (A0 VSS) capacitor c=2.34647e-17
C5 (Y VSS) capacitor c=1.52516e-17
C6 (VDD VSS) capacitor c=1.35578e-16
C7 (A2 VSS) capacitor c=3.2482e-17
C8 (net153 VSS) capacitor c=8.56836e-22
C9 (net137 VSS) capacitor c=4.72564e-18
C10 (net141 VSS) capacitor c=2.36208e-18
C11 (net124 VSS) capacitor c=4.4056e-17
C12 (\1\:B0 VSS) capacitor c=3.89731e-17
C13 (\1\:B1 VSS) capacitor c=6.5389e-17
C14 (\1\:B2 VSS) capacitor c=3.33416e-17
C15 (\1\:A2 VSS) capacitor c=6.99965e-17
C16 (\1\:A1 VSS) capacitor c=5.50463e-17
C17 (\3\:A0 VSS) capacitor c=2.37436e-17
C18 (\3\:B0 VSS) capacitor c=5.97523e-17
C19 (\3\:B1 VSS) capacitor c=4.63477e-17
C20 (\3\:B2 VSS) capacitor c=6.97729e-17
C21 (\3\:A2 VSS) capacitor c=3.78089e-17
C22 (\3\:A1 VSS) capacitor c=5.9591e-17
C23 (\1\:A0 VSS) capacitor c=6.75056e-17
C24 (\2\:B0 VSS) capacitor c=6.64762e-17
C25 (\2\:B1 VSS) capacitor c=7.90526e-17
C26 (\2\:B2 VSS) capacitor c=5.92895e-17
C27 (\2\:A2 VSS) capacitor c=6.25662e-17
C28 (\2\:A1 VSS) capacitor c=6.76566e-17
C29 (\2\:A0 VSS) capacitor c=6.22191e-17
C30 (\5\:net124 VSS) capacitor c=6.94576e-17
C31 (\1\:Y VSS) capacitor c=6.0659e-17
C32 (\3\:net124 VSS) capacitor c=6.31313e-17
C33 (\8\:VDD VSS) capacitor c=1.10389e-17
C34 (\6\:VDD VSS) capacitor c=4.65568e-18
C35 (\1\:VDD VSS) capacitor c=6.64951e-17
C36 (\4\:Y VSS) capacitor c=1.28197e-16
C37 (\4\:A0 VSS) capacitor c=1.95538e-17
C38 (\4\:A1 VSS) capacitor c=2.76177e-17
C39 (\4\:A2 VSS) capacitor c=2.9359e-17
C40 (\6\:B2 VSS) capacitor c=2.60123e-17
C41 (\4\:B1 VSS) capacitor c=6.57915e-17
C42 (\4\:B0 VSS) capacitor c=7.55762e-17
C43 (\5\:B0 VSS) capacitor c=7.17837e-17
C44 (\3\:Y VSS) capacitor c=1.18241e-16
Rk7 (B1 \4\:B1) resistor r=0.1592 c=0
Rk2 (\4\:A1 A1) resistor r=0.04585 c=0
Rk4 (\4\:B2 B2) resistor r=0.005012 c=0
Rk6 (\4\:B2 \6\:B2) resistor r=0.01641 c=0
Rk5 (\5\:B2 \6\:B2) resistor r=0.005012 c=0
Rk1 (\4\:A0 A0) resistor r=0.04463 c=0
Rk13 (\2\:Y \3\:Y) resistor r=0.3216 c=0
Rk14 (\3\:Y \5\:Y) resistor r=0.9777 c=0
Rk16 (\7\:Y Y) resistor r=0.002814 c=0
Rk15 (\3\:Y \7\:Y) resistor r=0.07134 c=0
Rk23 (\2\:VDD \3\:VDD) resistor r=0.2304 c=0
Rk25 (\4\:VDD VDD) resistor r=0.1003 c=0
Rk24 (\3\:VDD \4\:VDD) resistor r=0.06998 c=0
Rk27 (VDD \7\:VDD) resistor r=0.1006 c=0
Rk28 (\3\:VDD \9\:VDD) resistor r=0.07346 c=0
Rk17 (\2\:VSS \3\:VSS) resistor r=0.05243 c=0
Rk18 (\3\:VSS \4\:VSS) resistor r=0.298 c=0
Rk20 (\5\:VSS VSS) resistor r=0.0171 c=0
Rk19 (\4\:VSS \5\:VSS) resistor r=0.2329 c=0
Rk21 (\3\:VSS \7\:VSS) resistor r=0.122 c=0
Rk22 (\5\:VSS \9\:VSS) resistor r=0.213 c=0
Rk3 (A2 \4\:A2) resistor r=0.0404 c=0
Rk10 (B0 \4\:B0) resistor r=0.001228 c=0
Rk12 (\4\:B0 \5\:B0) resistor r=0.1041 c=0
Rk11 (\5\:B0 \6\:B0) resistor r=0.001293 c=0
Rk8 (\2\:net124 \4\:net124) resistor r=0.2726 c=0
Rk9 (\4\:net124 \6\:net124) resistor r=0.3667 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=204.944 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=35.7134 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=106.461 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=141.076 c=0
Rl7 (\1\:B2 \2\:B2) resistor r=33.3841 c=0
Rl8 (\2\:B2 \3\:B2) resistor r=214.153 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=26.3736 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=223.077 c=0
Rl5 (\1\:A2 \2\:A2) resistor r=175.692 c=0
Rl6 (\2\:A2 \3\:A2) resistor r=71.8456 c=0
Rl11 (\1\:B0 \2\:B0) resistor r=102.978 c=0
Rl12 (\2\:B0 \3\:B0) resistor r=147.253 c=0
Rz1 (\4\:Y \5\:Y) resistor r=75 c=0
Rz6 (\1\:VDD VDD) resistor r=75 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=15 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=75 c=0
Rz2 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz3 (\8\:VSS \9\:VSS) resistor r=75 c=0
Ry4 (\1\:Y \2\:Y) resistor r=62 c=0
Ry5 (\6\:Y \7\:Y) resistor r=62 c=0
Ry8 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry9 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry6 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry7 (\1\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry1 (net124 \2\:net124) resistor r=62 c=0
Ry2 (\3\:net124 \4\:net124) resistor r=62 c=0
Ry3 (\5\:net124 \6\:net124) resistor r=62 c=0
Rx5 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx4 (\2\:B2 \5\:B2) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx3 (\2\:A2 \4\:A2) resistor r=45 c=0
Rx6 (\2\:B0 \6\:B0) resistor r=45 c=0
mn0 (net153 \1\:A0 \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=1.378e-14 ps=5.7e-07 pd=4.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.025e-06 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn1 (net153 \3\:A1 net149 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=1.378e-14 ps=5.9e-07 pd=4.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.8e-07 sb=8.85e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn2 (\4\:Y \3\:A2 net149 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=2.32e-14 ps=5.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75e-07 sb=6.9e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn5 (\4\:Y \3\:B2 net137 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=4.85e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn4 (net137 \3\:B1 net141 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.43e-15 ad=2.32e-14 ps=4.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=2.8e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn3 (net141 \3\:B0 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.025e-14 ad=9.43e-15 ps=8.9e-07 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=1.7e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mp1 (net124 \1\:A1 \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.655e-14 ps=1.41e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=9.5e-07 sd=160n sca=14.9994 \
        scb=0.0139145 scc=0.000209273 m=(1)
mp2 (\3\:net124 \1\:A2 \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.44e-14 ps=1.41e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=7.55e-07 sd=160n sca=12.5773 \
        scb=0.00960893 scc=0.000140232 m=(1)
mp5 (\1\:Y \1\:B2 \3\:net124 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=5.5e-07 sd=160n sca=12.38 \
        scb=0.00928483 scc=0.000139001 m=(1)
mp4 (\1\:Y \1\:B1 \5\:net124 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=3.45e-07 sd=160n sca=14.1566 \
        scb=0.012431 scc=0.000173041 m=(1)
mp3 (\6\:Y \1\:B0 \5\:net124 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=1.4e-07 sd=160n sca=23.3203 \
        scb=0.0262833 scc=0.00133399 m=(1)
ends AOI33XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:05:24 2012 )
// Library name: gsclib045
// Cell name: CLKXOR2X1
// View name: extracted

simulator lang=spectre

subckt CLKXOR2X1 A B VDD VSS Y
mp5 (\1\:Y \4\:n0 \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.79e-14 ad=5.46e-14 ps=1.9e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.03654e-07 sd=160n sca=44.1638 \
        scb=0.0392167 scc=0.00476734 m=(1)
C1 (A VSS) capacitor c=8.00895e-17
C2 (VDD VSS) capacitor c=1.11234e-16
C3 (Y VSS) capacitor c=4.65451e-17
C4 (B VSS) capacitor c=5.62075e-17
C5 (n0 VSS) capacitor c=2.31009e-17
C6 (n1 VSS) capacitor c=5.73225e-17
C7 (n2 VSS) capacitor c=5.36738e-17
C8 (net130 VSS) capacitor c=2.04336e-18
C9 (\7\:B VSS) capacitor c=3.66009e-17
C10 (\3\:n1 VSS) capacitor c=8.20754e-17
C11 (\2\:n2 VSS) capacitor c=8.55393e-17
C12 (\1\:B VSS) capacitor c=3.45616e-17
C13 (\1\:A VSS) capacitor c=4.34486e-17
C14 (\4\:n0 VSS) capacitor c=3.55243e-17
C15 (\5\:B VSS) capacitor c=4.09537e-17
C16 (\3\:B VSS) capacitor c=7.55568e-17
C17 (\3\:A VSS) capacitor c=4.29572e-17
C18 (\3\:n0 VSS) capacitor c=4.1059e-17
C19 (\6\:B VSS) capacitor c=5.5532e-17
C20 (\2\:n1 VSS) capacitor c=8.06528e-17
C21 (\4\:B VSS) capacitor c=7.42055e-17
C22 (\3\:n2 VSS) capacitor c=3.34781e-17
C23 (\2\:B VSS) capacitor c=4.08191e-17
C24 (\2\:A VSS) capacitor c=5.64424e-17
C25 (\4\:n2 VSS) capacitor c=1.30072e-17
C26 (\1\:VDD VSS) capacitor c=5.52247e-17
C27 (\8\:n0 VSS) capacitor c=1.22943e-16
C28 (\8\:n1 VSS) capacitor c=6.65993e-17
C29 (\6\:VDD VSS) capacitor c=2.75383e-17
C30 (\1\:Y VSS) capacitor c=7.9451e-17
C31 (\8\:n2 VSS) capacitor c=5.38146e-17
C32 (\5\:n0 VSS) capacitor c=1.25811e-16
C33 (\6\:n1 VSS) capacitor c=6.55325e-17
C34 (\3\:Y VSS) capacitor c=2.57719e-17
C35 (\2\:n0 VSS) capacitor c=1.93156e-17
C36 (\4\:A VSS) capacitor c=4.5403e-17
C37 (\7\:n0 VSS) capacitor c=2.3861e-16
C38 (\4\:n1 VSS) capacitor c=5.84406e-17
C39 (\5\:n1 VSS) capacitor c=1.27503e-16
C40 (\8\:B VSS) capacitor c=3.74346e-17
C41 (\9\:B VSS) capacitor c=4.43416e-17
C42 (\10\:B VSS) capacitor c=6.73304e-17
C43 (\6\:n2 VSS) capacitor c=1.15345e-16
C44 (\7\:n2 VSS) capacitor c=7.92174e-17
C45 (\4\:VDD VSS) capacitor c=4.21006e-17
C46 (\5\:VDD VSS) capacitor c=1.35036e-17
Rk3 (A \4\:A) resistor r=0.111 c=0
Rk15 (\2\:VSS \3\:VSS) resistor r=0.1128 c=0
Rk16 (\3\:VSS \4\:VSS) resistor r=0.2884 c=0
Rk18 (\5\:VSS VSS) resistor r=0.1025 c=0
Rk17 (\4\:VSS \5\:VSS) resistor r=0.1479 c=0
Rk19 (\3\:VSS \7\:VSS) resistor r=0.242 c=0
Rk20 (\5\:VSS \9\:VSS) resistor r=0.2349 c=0
Rk21 (\2\:VDD \4\:VDD) resistor r=0.4973 c=0
Rk23 (\5\:VDD VDD) resistor r=0.1166 c=0
Rk22 (\4\:VDD \5\:VDD) resistor r=0.2323 c=0
Rk24 (\5\:VDD \7\:VDD) resistor r=0.06846 c=0
Rk1 (\2\:Y Y) resistor r=0.4562 c=0
Rk2 (Y \4\:Y) resistor r=0.04518 c=0
Rk9 (\8\:B B) resistor r=0.1323 c=0
Rk10 (B \9\:B) resistor r=0.08217 c=0
Rk11 (\9\:B \10\:B) resistor r=0.2616 c=0
Rk4 (\6\:n0 \7\:n0) resistor r=0.9732 c=0
Rk5 (\7\:n0 \9\:n0) resistor r=0.8284 c=0
Rk6 (\4\:n1 \5\:n1) resistor r=0.3091 c=0
Rk7 (\5\:n1 \7\:n1) resistor r=0.2829 c=0
Rk8 (\5\:n1 \9\:n1) resistor r=0.4309 c=0
Rk12 (\5\:n2 \6\:n2) resistor r=0.03827 c=0
Rk13 (\6\:n2 \7\:n2) resistor r=0.5822 c=0
Rk14 (\6\:n2 \9\:n2) resistor r=0.5296 c=0
Rl4 (\1\:A \2\:A) resistor r=96.8456 c=0
Rl5 (\2\:A \3\:A) resistor r=110.307 c=0
Rl13 (\6\:B \7\:B) resistor r=76.2049 c=0
Rl12 (\5\:B \6\:B) resistor r=126.718 c=0
Rl9 (\3\:B \4\:B) resistor r=130.002 c=0
Rl6 (\1\:B \2\:B) resistor r=24.2328 c=0
Rl1 (n0 \2\:n0) resistor r=1.2334 c=0
Rl3 (\2\:n0 \4\:n0) resistor r=43.1104 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=87.3411 c=0
Rl10 (n1 \2\:n1) resistor r=72.7035 c=0
Rl11 (\2\:n1 \3\:n1) resistor r=140.679 c=0
Rl7 (n2 \2\:n2) resistor r=241.883 c=0
Rl8 (\2\:n2 \3\:n2) resistor r=24.2328 c=0
Rz5 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz6 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\5\:n0 \6\:n0) resistor r=75 c=0
Rz3 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz4 (\8\:n2 \9\:n2) resistor r=75 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry6 (\1\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry7 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry8 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry2 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry3 (\8\:n1 \9\:n1) resistor r=62 c=0
Ry4 (\4\:n2 \5\:n2) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx4 (\6\:B \8\:B) resistor r=45 c=0
Rx5 (\4\:B \9\:B) resistor r=45 c=0
Rx6 (\2\:B \10\:B) resistor r=45 c=0
Rx2 (n0 \7\:n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx7 (\3\:n2 \7\:n2) resistor r=45 c=0
mn5 (\3\:Y \3\:n0 \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.25e-14 ad=3.64e-14 ps=9.2e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.29519e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn0 (\6\:n1 \3\:A \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.25e-14 ad=3.915e-14 ps=9.2e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=9.7e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn4 (\5\:n0 n2 \6\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=2.32e-14 ps=8.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=6.55e-07 sd=160n sca=8.55924 scb=0.0065649 \
        scc=0.000116351 m=(1)
mn3 (\5\:n0 \3\:B net139 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.05e-07 sb=4.5e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn2 (net139 n1 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.01e-06 sb=3.45e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn1 (\8\:n2 \5\:B \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.215e-06 sb=1.4e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mp0 (\8\:n1 \1\:A \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.79e-14 ad=3.44e-14 ps=1.9e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=9.5e-07 sd=160n sca=15.6438 \
        scb=0.0148425 scc=0.000445561 m=(1)
mp4 (\8\:n0 \1\:B \8\:n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=7.45e-07 sd=160n sca=13.754 \
        scb=0.0122361 scc=0.000425664 m=(1)
mp3 (\8\:n0 \2\:n2 net130 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=3.762e-14 ps=7e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=5.25e-07 sd=160n sca=13.561 \
        scb=0.0120014 scc=0.000425312 m=(1)
mp2 (net130 \3\:n1 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.903e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=3.45e-07 sd=160n sca=14.4668 \
        scb=0.0130588 scc=0.000428492 m=(1)
mp1 (\4\:n2 \7\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=1.4e-07 sd=160n sca=17.9454 \
        scb=0.0188744 scc=0.000556907 m=(1)
ends CLKXOR2X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:06:12 2012 )
// Library name: gsclib045
// Cell name: DFFHQX1
// View name: extracted

simulator lang=spectre

subckt DFFHQX1 CK D Q VDD VSS
mp55 (\1\:Q \4\:qbint \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.405e-14 ad=5.46e-14 ps=1.12e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.30833e-07 sd=160n sca=29.0978 \
        scb=0.0329394 scc=0.00242907 m=(1)
C1 (D VSS) capacitor c=3.79633e-17
C2 (VDD VSS) capacitor c=1.57444e-16
C3 (CK VSS) capacitor c=4.49227e-17
C4 (qbint VSS) capacitor c=1.81781e-17
C5 (CKb VSS) capacitor c=2.98332e-17
C6 (n30 VSS) capacitor c=3.59565e-17
C7 (net172 VSS) capacitor c=3.17549e-18
C8 (mout VSS) capacitor c=9.77052e-17
C9 (CKbb VSS) capacitor c=5.04488e-17
C10 (n20 VSS) capacitor c=4.4832e-17
C11 (net192 VSS) capacitor c=2.98175e-18
C12 (n21 VSS) capacitor c=2.12137e-18
C13 (net123 VSS) capacitor c=5.06907e-18
C14 (net147 VSS) capacitor c=1.69422e-18
C15 (n22 VSS) capacitor c=5.79395e-18
C16 (\10\:CKb VSS) capacitor c=4.28594e-17
C17 (\1\:D VSS) capacitor c=4.60829e-17
C18 (\5\:CKbb VSS) capacitor c=6.63975e-17
C19 (\4\:CKb VSS) capacitor c=6.97562e-17
C20 (\5\:qbint VSS) capacitor c=5.9926e-17
C21 (\3\:n30 VSS) capacitor c=4.71864e-17
C22 (\3\:CK VSS) capacitor c=4.22351e-17
C23 (\4\:qbint VSS) capacitor c=5.68934e-17
C24 (\8\:CKb VSS) capacitor c=2.99928e-17
C25 (\3\:D VSS) capacitor c=6.92698e-17
C26 (\6\:CKb VSS) capacitor c=5.44589e-17
C27 (\7\:CKbb VSS) capacitor c=2.88179e-17
C28 (\3\:mout VSS) capacitor c=3.71421e-17
C29 (\3\:n20 VSS) capacitor c=4.96991e-17
C30 (\3\:CKbb VSS) capacitor c=2.69704e-17
C31 (\3\:CKb VSS) capacitor c=7.11703e-17
C32 (\8\:qbint VSS) capacitor c=5.44164e-17
C33 (\1\:CK VSS) capacitor c=4.58547e-17
C34 (\3\:qbint VSS) capacitor c=2.89848e-17
C35 (\9\:CKb VSS) capacitor c=3.92271e-17
C36 (\2\:D VSS) capacitor c=5.52871e-17
C37 (\7\:CKb VSS) capacitor c=3.92214e-17
C38 (\5\:CKb VSS) capacitor c=3.35438e-17
C39 (\6\:CKbb VSS) capacitor c=6.19267e-17
C40 (\2\:mout VSS) capacitor c=5.0257e-17
C41 (\2\:n20 VSS) capacitor c=4.0605e-17
C42 (\4\:CKbb VSS) capacitor c=4.051e-17
C43 (\2\:CKb VSS) capacitor c=6.70086e-17
C44 (\2\:CKbb VSS) capacitor c=4.54283e-17
C45 (\7\:qbint VSS) capacitor c=2.30771e-17
C46 (\2\:n30 VSS) capacitor c=4.62549e-17
C47 (\2\:CK VSS) capacitor c=3.90204e-17
C48 (\8\:CKbb VSS) capacitor c=4.37886e-17
C49 (\8\:VDD VSS) capacitor c=4.44756e-17
C50 (\8\:n20 VSS) capacitor c=3.55344e-17
C51 (\10\:VDD VSS) capacitor c=3.75964e-17
C52 (\4\:mout VSS) capacitor c=8.14631e-17
C53 (\8\:n30 VSS) capacitor c=5.01226e-17
C54 (\12\:VDD VSS) capacitor c=4.99186e-17
C55 (\14\:qbint VSS) capacitor c=9.50205e-17
C56 (\20\:CKb VSS) capacitor c=3.27976e-17
C57 (\14\:VDD VSS) capacitor c=4.4253e-17
C58 (\1\:Q VSS) capacitor c=5.65164e-17
C59 (\1\:VDD VSS) capacitor c=2.88071e-17
C60 (\10\:CKbb VSS) capacitor c=1.23096e-16
C61 (\4\:n20 VSS) capacitor c=7.83202e-17
C62 (\7\:mout VSS) capacitor c=4.69619e-17
C63 (\4\:n30 VSS) capacitor c=9.05188e-17
C64 (\11\:qbint VSS) capacitor c=7.46668e-17
C65 (\18\:CKb VSS) capacitor c=1.14883e-16
C66 (\3\:Q VSS) capacitor c=5.95396e-17
C67 (\2\:qbint VSS) capacitor c=1.69147e-17
C68 (\6\:qbint VSS) capacitor c=3.32063e-17
C69 (\4\:CK VSS) capacitor c=9.51602e-17
C70 (\9\:qbint VSS) capacitor c=7.45606e-17
C71 (\10\:qbint VSS) capacitor c=1.05324e-16
C72 (\13\:qbint VSS) capacitor c=1.16493e-16
C73 (\6\:n30 VSS) capacitor c=1.18108e-16
C74 (\7\:n30 VSS) capacitor c=8.64226e-17
C75 (\6\:mout VSS) capacitor c=7.29788e-17
C76 (\9\:mout VSS) capacitor c=5.94404e-17
C77 (\6\:n20 VSS) capacitor c=8.31854e-17
C78 (\7\:n20 VSS) capacitor c=5.60523e-17
C79 (\5\:D VSS) capacitor c=4.85548e-17
C80 (\11\:CKb VSS) capacitor c=7.12176e-17
C81 (\12\:CKb VSS) capacitor c=1.24062e-16
C82 (\13\:CKb VSS) capacitor c=9.76323e-17
C83 (\14\:CKb VSS) capacitor c=1.12222e-16
C84 (\15\:CKb VSS) capacitor c=6.85827e-17
C85 (\16\:CKb VSS) capacitor c=2.54138e-17
C86 (\17\:CKb VSS) capacitor c=1.48771e-16
C87 (\12\:CKbb VSS) capacitor c=1.97647e-16
C88 (\13\:CKbb VSS) capacitor c=1.2998e-16
C89 (\14\:CKbb VSS) capacitor c=4.32298e-17
C90 (\15\:CKbb VSS) capacitor c=6.74577e-17
C91 (\3\:VDD VSS) capacitor c=1.26931e-17
C92 (\4\:VDD VSS) capacitor c=2.95395e-17
C93 (\6\:VDD VSS) capacitor c=1.19106e-17
C94 (\7\:VDD VSS) capacitor c=1.8559e-17
Rk17 (\4\:D \5\:D) resistor r=0.01233 c=0
Rk18 (\6\:D D) resistor r=0.0125 c=0
Rk19 (\5\:D \6\:D) resistor r=0.02493 c=0
Rk33 (\2\:VSS \4\:VSS) resistor r=0.1771 c=0
Rk34 (\4\:VSS \5\:VSS) resistor r=0.3487 c=0
Rk35 (\5\:VSS \6\:VSS) resistor r=0.2031 c=0
Rk36 (\6\:VSS \7\:VSS) resistor r=0.2609 c=0
Rk37 (\7\:VSS \8\:VSS) resistor r=0.2408 c=0
Rk39 (\9\:VSS VSS) resistor r=0.1025 c=0
Rk38 (\8\:VSS \9\:VSS) resistor r=0.09771 c=0
Rk40 (\5\:VSS \11\:VSS) resistor r=0.1319 c=0
Rk41 (\7\:VSS \13\:VSS) resistor r=0.2162 c=0
Rk42 (\9\:VSS \15\:VSS) resistor r=0.2903 c=0
Rk43 (\2\:VDD \3\:VDD) resistor r=0.05754 c=0
Rk44 (\3\:VDD \4\:VDD) resistor r=0.3914 c=0
Rk45 (\4\:VDD \5\:VDD) resistor r=0.3515 c=0
Rk46 (\5\:VDD \6\:VDD) resistor r=0.1219 c=0
Rk48 (\7\:VDD VDD) resistor r=0.1025 c=0
Rk47 (\6\:VDD \7\:VDD) resistor r=0.325 c=0
Rk49 (\3\:VDD \9\:VDD) resistor r=0.357 c=0
Rk50 (\4\:VDD \11\:VDD) resistor r=0.1323 c=0
Rk51 (\6\:VDD \13\:VDD) resistor r=0.1563 c=0
Rk52 (\7\:VDD \15\:VDD) resistor r=0.2566 c=0
Rk3 (\4\:CK CK) resistor r=0.101 c=0
Rk1 (\2\:Q Q) resistor r=0.3913 c=0
Rk2 (Q \4\:Q) resistor r=0.09099 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.401 c=0
Rk5 (\10\:qbint \12\:qbint) resistor r=0.06291 c=0
Rk6 (\12\:qbint \13\:qbint) resistor r=0.6085 c=0
Rk7 (\10\:qbint \15\:qbint) resistor r=0.417 c=0
Rk20 (\11\:CKb \12\:CKb) resistor r=0.2921 c=0
Rk21 (\12\:CKb \13\:CKb) resistor r=0.6435 c=0
Rk22 (\13\:CKb \14\:CKb) resistor r=0.4535 c=0
Rk23 (\14\:CKb \15\:CKb) resistor r=0.2689 c=0
Rk24 (\13\:CKb \16\:CKb) resistor r=0.08897 c=0
Rk25 (\14\:CKb \17\:CKb) resistor r=0.7035 c=0
Rk26 (\17\:CKb \19\:CKb) resistor r=0.4767 c=0
Rk27 (\17\:CKb \21\:CKb) resistor r=0.0696 c=0
Rk8 (\5\:n30 \6\:n30) resistor r=0.5389 c=0
Rk9 (\6\:n30 \7\:n30) resistor r=0.4421 c=0
Rk10 (\6\:n30 \9\:n30) resistor r=0.1644 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.3339 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.1232 c=0
Rk13 (\6\:mout \9\:mout) resistor r=0.2346 c=0
Rk28 (\9\:CKbb \11\:CKbb) resistor r=0.4434 c=0
Rk29 (\11\:CKbb \12\:CKbb) resistor r=0.7898 c=0
Rk30 (\12\:CKbb \13\:CKbb) resistor r=0.8589 c=0
Rk31 (\12\:CKbb \14\:CKbb) resistor r=0.1406 c=0
Rk32 (\13\:CKbb \15\:CKbb) resistor r=0.3031 c=0
Rk14 (\5\:n20 \6\:n20) resistor r=0.3828 c=0
Rk15 (\6\:n20 \7\:n20) resistor r=0.3082 c=0
Rk16 (\6\:n20 \9\:n20) resistor r=0.132 c=0
Rl23 (\1\:D \2\:D) resistor r=62.6944 c=0
Rl24 (\2\:D \3\:D) resistor r=89.6174 c=0
Rl5 (\2\:CK \3\:CK) resistor r=68.4066 c=0
Rl4 (\1\:CK \2\:CK) resistor r=107.692 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2713 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=90.0987 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=34.3295 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=57.4064 c=0
Rl10 (\6\:qbint \8\:qbint) resistor r=115.099 c=0
Rl9 (\6\:qbint \7\:qbint) resistor r=2.7666 c=0
Rl26 (\9\:CKb \10\:CKb) resistor r=120.949 c=0
Rl25 (\8\:CKb \9\:CKb) resistor r=30.0511 c=0
Rl22 (\6\:CKb \7\:CKb) resistor r=47.3097 c=0
Rl19 (\4\:CKb \5\:CKb) resistor r=24.2328 c=0
Rl12 (CKb \2\:CKb) resistor r=28.6412 c=0
Rl13 (\2\:CKb \3\:CKb) resistor r=193.774 c=0
Rl6 (n30 \2\:n30) resistor r=78.8462 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=78.022 c=0
Rl17 (mout \2\:mout) resistor r=125.692 c=0
Rl18 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl20 (\5\:CKbb \6\:CKbb) resistor r=156.3 c=0
Rl21 (\6\:CKbb \7\:CKbb) resistor r=26.4372 c=0
Rl14 (\3\:CKbb \4\:CKbb) resistor r=39.9512 c=0
Rl11 (CKbb \2\:CKbb) resistor r=48.7687 c=0
Rl15 (n20 \2\:n20) resistor r=49.1749 c=0
Rl16 (\2\:n20 \3\:n20) resistor r=99.1749 c=0
Rz8 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz9 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz10 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz11 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz12 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Rz13 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz2 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz6 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz5 (\4\:n20 \5\:n20) resistor r=75 c=0
Ry8 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry9 (\3\:VSS \6\:VSS) resistor r=12.4 c=0
Ry10 (\3\:VSS \8\:VSS) resistor r=12.4 c=0
Ry11 (\8\:VDD \9\:VDD) resistor r=31 c=0
Ry12 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry13 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry14 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry2 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry6 (\20\:CKb \21\:CKb) resistor r=62 c=0
Ry3 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry4 (\4\:mout \5\:mout) resistor r=62 c=0
Ry7 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry5 (\8\:n20 \9\:n20) resistor r=62 c=0
Rx7 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\7\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (qbint \13\:qbint) resistor r=45 c=0
Rx8 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx9 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx10 (\2\:CKb \15\:CKb) resistor r=45 c=0
Rx11 (\5\:CKb \16\:CKb) resistor r=45 c=0
Rx4 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx5 (\2\:mout \9\:mout) resistor r=45 c=0
Rx12 (\4\:CKbb \13\:CKbb) resistor r=45 c=0
Rx13 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx14 (\2\:CKbb \15\:CKbb) resistor r=45 c=0
Rx6 (\2\:n20 \7\:n20) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=3.64e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.90577e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn20 (\18\:CKb \1\:CK \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=2.03e-14 ps=9.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.4e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn45 (\11\:qbint n30 \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.383e-14 ad=2.87e-14 ps=7.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.96341e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn50 (net172 \8\:qbint \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.383e-14 ad=2.05e-14 ps=7.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.83122e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn51 (\4\:n30 \3\:CKb net172 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=5.843e-14 ps=6.1e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=1.68622e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn40 (\7\:mout \3\:CKbb \4\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.843e-14 ad=3.28e-14 ps=9.8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.25e-07 sb=1.35622e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn30 (\7\:mout \3\:n20 \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.238e-14 ad=3.28e-14 ps=1.28e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.15122e-06 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn35 (net192 \3\:mout \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.238e-14 ad=2.768e-14 ps=1.28e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=8.8122e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn36 (\4\:n20 \7\:CKbb net192 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.768e-14 ad=4.408e-14 ps=6.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48e-06 sb=7.0122e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn26 (\4\:n20 \6\:CKb n21 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.408e-14 ps=5.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=4.4122e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn25 (n21 \3\:D \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.73e-14 ad=1.23e-14 ps=1.27e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=3.3622e-07 sd=160n sca=8.54927 \
        scb=0.00659983 scc=0.000133988 m=(1)
mn21 (\10\:CKbb \8\:CKb \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.73e-14 ad=2.03e-14 ps=1.27e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.33388 scb=0.00788941 \
        scc=0.00017958 m=(1)
mp20 (\20\:CKb \3\:CK \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.405e-14 ad=2.63e-14 ps=1.12e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=1.22326e-07 sd=160n sca=13.9323 \
        scb=0.0120188 scc=0.000146665 m=(1)
mp45 (\14\:qbint \3\:n30 \12\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.38e-14 ad=3.64e-14 ps=1.32e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17419e-07 sb=1.96935e-06 sd=160n sca=19.4821 \
        scb=0.0175815 scc=0.00172296 m=(1)
mp50 (net123 \5\:qbint \12\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=3.1e-14 ps=1.32e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.82419e-07 sb=1.81879e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp51 (\8\:n30 CKbb net123 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.1e-14 ad=6.975e-14 ps=8.2e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.27419e-07 sb=1.67379e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp40 (\4\:mout CKb \8\:n30 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.975e-14 ad=6.82e-14 ps=1.07e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.97419e-07 sb=1.40379e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp30 (\4\:mout n20 \10\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1412e-13 ad=6.82e-14 ps=1.78e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.06242e-06 sb=1.13879e-06 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp35 (net147 mout \10\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1412e-13 ad=1.86e-14 ps=1.78e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.33242e-06 sb=8.6879e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp36 (\8\:n20 \4\:CKb net147 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43742e-06 sb=7.6379e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp26 (\8\:n20 \5\:CKbb n22 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=4.96e-14 ps=1e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64242e-06 sb=5.5879e-07 sd=160n sca=19.3989 \
        scb=0.017551 scc=0.00172296 m=(1)
mp25 (n22 \1\:D \8\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.63e-14 ad=5.89e-14 ps=1.02e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.87742e-06 sb=3.2379e-07 sd=160n sca=20.3782 \
        scb=0.0182292 scc=0.00172385 m=(1)
mp21 (\8\:CKbb \10\:CKb \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.63e-14 ad=3.44e-14 ps=1.02e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.6e-07 sd=160n sca=27.2531 scb=0.0271167 \
        scc=0.00250214 m=(1)
ends DFFHQX1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:07:00 2012 )
// Library name: gsclib045
// Cell name: DFFNSRX1
// View name: extracted

simulator lang=spectre

subckt DFFNSRX1 CKN D Q QN RN SN VDD VSS
mp57 (\1\:QN qint \27\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.35064e-07 sd=160n sca=44.1638 \
        scb=0.0392167 scc=0.00476734 m=(1)
C1 (QN VSS) capacitor c=4.05201e-17
C2 (RN VSS) capacitor c=3.37647e-17
C3 (CKN VSS) capacitor c=8.43838e-17
C4 (D VSS) capacitor c=1.16974e-16
C5 (VDD VSS) capacitor c=3.41194e-16
C6 (SN VSS) capacitor c=2.41244e-16
C7 (Q VSS) capacitor c=8.77761e-17
C8 (qint VSS) capacitor c=4.53851e-17
C9 (qbint VSS) capacitor c=5.19693e-17
C10 (RNb VSS) capacitor c=5.81253e-17
C11 (n35 VSS) capacitor c=3.37926e-17
C12 (n42 VSS) capacitor c=6.032e-17
C13 (n40 VSS) capacitor c=6.96667e-17
C14 (CKNbb VSS) capacitor c=3.62271e-17
C15 (mout VSS) capacitor c=5.7097e-17
C16 (CKNb VSS) capacitor c=7.67512e-17
C17 (n25 VSS) capacitor c=1.01681e-16
C18 (n20 VSS) capacitor c=4.44941e-17
C19 (n30 VSS) capacitor c=2.36337e-18
C20 (n21 VSS) capacitor c=1.26516e-20
C21 (n41 VSS) capacitor c=8.82208e-17
C22 (n43 VSS) capacitor c=9.19802e-19
C23 (n26 VSS) capacitor c=4.56963e-18
C24 (n31 VSS) capacitor c=1.09643e-18
C25 (n22 VSS) capacitor c=2.59562e-18
C26 (\1\:CKN VSS) capacitor c=2.37404e-17
C27 (\7\:CKNb VSS) capacitor c=6.15578e-17
C28 (\3\:D VSS) capacitor c=5.90951e-17
C29 (\4\:CKNb VSS) capacitor c=7.70432e-17
C30 (\7\:CKNbb VSS) capacitor c=4.77008e-17
C31 (\4\:SN VSS) capacitor c=5.46709e-17
C32 (\4\:RNb VSS) capacitor c=5.61618e-17
C33 (\3\:CKNbb VSS) capacitor c=3.60505e-17
C34 (\2\:RNb VSS) capacitor c=6.91745e-17
C35 (\8\:qbint VSS) capacitor c=7.72914e-17
C36 (\1\:SN VSS) capacitor c=3.68297e-17
C37 (\1\:RN VSS) capacitor c=4.52546e-17
C38 (\7\:qbint VSS) capacitor c=3.24855e-17
C39 (\3\:CKN VSS) capacitor c=1.98699e-17
C40 (\8\:CKNb VSS) capacitor c=4.4726e-17
C41 (\1\:D VSS) capacitor c=4.41165e-17
C42 (\8\:CKNbb VSS) capacitor c=5.61801e-17
C43 (\5\:CKNb VSS) capacitor c=6.41836e-17
C44 (\4\:mout VSS) capacitor c=4.64528e-17
C45 (\6\:SN VSS) capacitor c=6.30444e-17
C46 (\3\:n20 VSS) capacitor c=3.24375e-17
C47 (\5\:RNb VSS) capacitor c=4.7666e-17
C48 (\2\:CKNb VSS) capacitor c=7.36149e-17
C49 (\9\:qbint VSS) capacitor c=4.96686e-17
C50 (\3\:SN VSS) capacitor c=4.36654e-17
C51 (\3\:n35 VSS) capacitor c=3.77354e-17
C52 (\3\:RN VSS) capacitor c=4.94149e-17
C53 (\6\:qbint VSS) capacitor c=3.47241e-17
C54 (\4\:qbint VSS) capacitor c=2.37027e-17
C55 (\3\:qint VSS) capacitor c=3.67169e-17
C56 (\2\:CKN VSS) capacitor c=2.07305e-17
C57 (\9\:CKNb VSS) capacitor c=1.85645e-17
C58 (\2\:D VSS) capacitor c=6.49813e-17
C59 (\9\:CKNbb VSS) capacitor c=5.35224e-17
C60 (\6\:CKNb VSS) capacitor c=2.15475e-17
C61 (\6\:CKNbb VSS) capacitor c=5.16657e-17
C62 (\3\:mout VSS) capacitor c=1.91683e-17
C63 (\5\:SN VSS) capacitor c=2.82243e-17
C64 (\2\:n20 VSS) capacitor c=3.82016e-17
C65 (\6\:RNb VSS) capacitor c=2.68438e-17
C66 (\5\:CKNbb VSS) capacitor c=3.59652e-17
C67 (\3\:CKNb VSS) capacitor c=2.58149e-17
C68 (\4\:CKNbb VSS) capacitor c=3.66114e-17
C69 (\2\:CKNbb VSS) capacitor c=2.78441e-17
C70 (\3\:RNb VSS) capacitor c=2.82512e-17
C71 (\10\:qbint VSS) capacitor c=2.4275e-17
C72 (\2\:SN VSS) capacitor c=3.36762e-17
C73 (\2\:n35 VSS) capacitor c=2.86284e-17
C74 (\2\:RN VSS) capacitor c=4.309e-17
C75 (\5\:qbint VSS) capacitor c=3.8832e-17
C76 (\2\:qint VSS) capacitor c=2.63215e-17
C77 (\5\:VDD VSS) capacitor c=3.77313e-17
C78 (\10\:CKNb VSS) capacitor c=1.12159e-16
C79 (\12\:CKNbb VSS) capacitor c=2.01218e-17
C80 (\7\:VDD VSS) capacitor c=4.73732e-17
C81 (\8\:n20 VSS) capacitor c=7.36849e-17
C82 (\10\:VDD VSS) capacitor c=1.23002e-17
C83 (\11\:mout VSS) capacitor c=4.34281e-17
C84 (\13\:VDD VSS) capacitor c=3.10836e-17
C85 (\9\:mout VSS) capacitor c=7.44988e-17
C86 (\4\:n35 VSS) capacitor c=4.04616e-17
C87 (\16\:VDD VSS) capacitor c=2.92174e-17
C88 (\3\:n41 VSS) capacitor c=9.55133e-17
C89 (\20\:VDD VSS) capacitor c=1.48325e-17
C90 (\11\:qbint VSS) capacitor c=7.0619e-17
C91 (\9\:RNb VSS) capacitor c=1.31643e-16
C92 (\23\:VDD VSS) capacitor c=3.9142e-17
C93 (\3\:Q VSS) capacitor c=3.96476e-17
C94 (\4\:qint VSS) capacitor c=3.77773e-17
C95 (\27\:VDD VSS) capacitor c=6.35427e-17
C96 (\1\:QN VSS) capacitor c=6.98348e-17
C97 (\1\:VDD VSS) capacitor c=1.13784e-16
C98 (\12\:CKNb VSS) capacitor c=1.18938e-16
C99 (\17\:CKNbb VSS) capacitor c=7.35535e-17
C100 (\4\:n20 VSS) capacitor c=4.33684e-17
C101 (\13\:mout VSS) capacitor c=3.89027e-17
C102 (\3\:n25 VSS) capacitor c=9.06248e-17
C103 (\15\:mout VSS) capacitor c=4.23837e-17
C104 (\8\:n35 VSS) capacitor c=6.34736e-17
C105 (\3\:n40 VSS) capacitor c=8.45616e-17
C106 (\3\:n42 VSS) capacitor c=9.55357e-17
C107 (\13\:qbint VSS) capacitor c=5.84092e-17
C108 (\11\:RNb VSS) capacitor c=1.02635e-16
C109 (\1\:Q VSS) capacitor c=8.18605e-17
C110 (\8\:qint VSS) capacitor c=4.18495e-17
C111 (\3\:qbint VSS) capacitor c=2.94008e-17
C112 (\2\:mout VSS) capacitor c=3.34968e-17
C113 (\6\:qint VSS) capacitor c=3.3545e-17
C114 (\7\:qint VSS) capacitor c=3.87928e-17
C115 (\4\:RN VSS) capacitor c=7.3984e-17
C116 (\15\:qbint VSS) capacitor c=1.15907e-16
C117 (\16\:qbint VSS) capacitor c=1.29493e-16
C118 (\17\:qbint VSS) capacitor c=8.23459e-17
C119 (\6\:n35 VSS) capacitor c=1.70281e-16
C120 (\7\:n35 VSS) capacitor c=1.86687e-16
C121 (\10\:CKNbb VSS) capacitor c=7.31511e-17
C122 (\11\:CKNbb VSS) capacitor c=1.25119e-16
C123 (\7\:RNb VSS) capacitor c=1.58634e-16
C124 (\8\:RNb VSS) capacitor c=2.07813e-16
C125 (\7\:SN VSS) capacitor c=2.89907e-16
C126 (\8\:SN VSS) capacitor c=3.89756e-17
C127 (\5\:mout VSS) capacitor c=4.42942e-17
C128 (\6\:mout VSS) capacitor c=4.98375e-17
C129 (\7\:mout VSS) capacitor c=5.58145e-17
C130 (\8\:mout VSS) capacitor c=6.98683e-17
C131 (\6\:n20 VSS) capacitor c=9.597e-17
C132 (\7\:n20 VSS) capacitor c=7.07165e-17
C133 (\14\:CKNbb VSS) capacitor c=6.63619e-17
C134 (\15\:CKNbb VSS) capacitor c=1.46593e-16
C135 (\16\:CKNbb VSS) capacitor c=2.53295e-16
C136 (\19\:CKNbb VSS) capacitor c=3.09097e-17
C137 (\20\:CKNbb VSS) capacitor c=3.91483e-17
C138 (\14\:CKNb VSS) capacitor c=7.47423e-17
C139 (\15\:CKNb VSS) capacitor c=1.39309e-16
C140 (\16\:CKNb VSS) capacitor c=1.34048e-16
C141 (\3\:VDD VSS) capacitor c=1.3416e-17
C142 (\9\:VDD VSS) capacitor c=3.73062e-17
C143 (\15\:VDD VSS) capacitor c=1.62206e-17
C144 (\19\:VDD VSS) capacitor c=1.42298e-17
C145 (\22\:VDD VSS) capacitor c=1.34936e-17
C146 (\26\:VDD VSS) capacitor c=9.87272e-18
Rk1 (\2\:QN QN) resistor r=0.3779 c=0
Rk2 (QN \4\:QN) resistor r=0.002835 c=0
Rk8 (RN \4\:RN) resistor r=0.03453 c=0
Rk36 (D \4\:D) resistor r=0.007525 c=0
Rk48 (\2\:VDD \3\:VDD) resistor r=0.06006 c=0
Rk49 (\3\:VDD \4\:VDD) resistor r=0.3419 c=0
Rk50 (\3\:VDD \6\:VDD) resistor r=0.3564 c=0
Rk51 (\4\:VDD \8\:VDD) resistor r=0.3345 c=0
Rk52 (\4\:VDD \9\:VDD) resistor r=0.3764 c=0
Rk53 (\9\:VDD \11\:VDD) resistor r=0.07476 c=0
Rk54 (\9\:VDD \12\:VDD) resistor r=0.3775 c=0
Rk55 (\12\:VDD \14\:VDD) resistor r=0.07156 c=0
Rk56 (\12\:VDD \15\:VDD) resistor r=0.4141 c=0
Rk57 (\15\:VDD \17\:VDD) resistor r=0.1036 c=0
Rk58 (\15\:VDD \18\:VDD) resistor r=0.1379 c=0
Rk59 (\18\:VDD \19\:VDD) resistor r=0.1545 c=0
Rk60 (\19\:VDD \21\:VDD) resistor r=0.04338 c=0
Rk61 (\19\:VDD \22\:VDD) resistor r=0.3376 c=0
Rk62 (\22\:VDD \24\:VDD) resistor r=0.2746 c=0
Rk63 (\22\:VDD \25\:VDD) resistor r=0.05755 c=0
Rk66 (\26\:VDD VDD) resistor r=0.1025 c=0
Rk64 (\25\:VDD \26\:VDD) resistor r=0.2484 c=0
Rk65 (\26\:VDD \28\:VDD) resistor r=0.44 c=0
Rk24 (\7\:SN SN) resistor r=1.9301 c=0
Rk25 (SN \8\:SN) resistor r=0.04356 c=0
Rk6 (Q \2\:Q) resistor r=0.4289 c=0
Rk7 (Q \4\:Q) resistor r=0.07434 c=0
Rk67 (\2\:VSS \3\:VSS) resistor r=0.06006 c=0
Rk68 (\3\:VSS \4\:VSS) resistor r=0.1404 c=0
Rk69 (\4\:VSS \5\:VSS) resistor r=0.1806 c=0
Rk70 (\5\:VSS \6\:VSS) resistor r=0.1203 c=0
Rk71 (\6\:VSS \7\:VSS) resistor r=0.275 c=0
Rk72 (\7\:VSS \8\:VSS) resistor r=0.4759 c=0
Rk73 (\8\:VSS \9\:VSS) resistor r=0.6065 c=0
Rk74 (\9\:VSS \10\:VSS) resistor r=0.3376 c=0
Rk75 (\10\:VSS \11\:VSS) resistor r=0.05755 c=0
Rk77 (\12\:VSS VSS) resistor r=0.1025 c=0
Rk76 (\11\:VSS \12\:VSS) resistor r=0.2484 c=0
Rk78 (\3\:VSS \14\:VSS) resistor r=0.3665 c=0
Rk79 (\5\:VSS \16\:VSS) resistor r=0.07476 c=0
Rk80 (\7\:VSS \18\:VSS) resistor r=0.04338 c=0
Rk81 (\9\:VSS \20\:VSS) resistor r=0.04338 c=0
Rk82 (\10\:VSS \22\:VSS) resistor r=0.3419 c=0
Rk83 (\12\:VSS \24\:VSS) resistor r=0.3844 c=0
Rk3 (\5\:qint \6\:qint) resistor r=0.1153 c=0
Rk4 (\6\:qint \7\:qint) resistor r=0.1291 c=0
Rk5 (\6\:qint \9\:qint) resistor r=0.1093 c=0
Rk9 (\12\:qbint \14\:qbint) resistor r=0.3691 c=0
Rk10 (\14\:qbint \15\:qbint) resistor r=0.1151 c=0
Rk11 (\15\:qbint \16\:qbint) resistor r=0.7243 c=0
Rk12 (\15\:qbint \17\:qbint) resistor r=0.3637 c=0
Rk20 (\7\:RNb \8\:RNb) resistor r=0.9657 c=0
Rk21 (\8\:RNb \10\:RNb) resistor r=0.7251 c=0
Rk22 (\10\:RNb \12\:RNb) resistor r=0.5107 c=0
Rk16 (\5\:n35 \6\:n35) resistor r=0.1257 c=0
Rk17 (\6\:n35 \7\:n35) resistor r=1.1889 c=0
Rk18 (\6\:n35 \9\:n35) resistor r=0.2867 c=0
Rk13 (\2\:n42 \4\:n42) resistor r=0.4286 c=0
Rk14 (\2\:n40 \4\:n40) resistor r=0.5071 c=0
Rk19 (\10\:CKNbb \11\:CKNbb) resistor r=0.5711 c=0
Rk37 (\13\:CKNbb \14\:CKNbb) resistor r=0.07809 c=0
Rk38 (\14\:CKNbb \15\:CKNbb) resistor r=0.254 c=0
Rk39 (\15\:CKNbb \16\:CKNbb) resistor r=1.4769 c=0
Rk40 (\14\:CKNbb \18\:CKNbb) resistor r=0.3983 c=0
Rk41 (\15\:CKNbb \19\:CKNbb) resistor r=0.1667 c=0
Rk42 (\19\:CKNbb \20\:CKNbb) resistor r=0.1701 c=0
Rk26 (\5\:mout \6\:mout) resistor r=0.2543 c=0
Rk27 (\6\:mout \7\:mout) resistor r=0.2923 c=0
Rk28 (\7\:mout \8\:mout) resistor r=0.2401 c=0
Rk29 (\8\:mout \10\:mout) resistor r=0.2616 c=0
Rk30 (\6\:mout \12\:mout) resistor r=0.0876 c=0
Rk31 (\7\:mout \14\:mout) resistor r=0.1206 c=0
Rk32 (\8\:mout \16\:mout) resistor r=0.133 c=0
Rk43 (\11\:CKNb \13\:CKNb) resistor r=0.5735 c=0
Rk44 (\13\:CKNb \14\:CKNb) resistor r=0.3472 c=0
Rk45 (\14\:CKNb \15\:CKNb) resistor r=0.3974 c=0
Rk46 (\15\:CKNb \16\:CKNb) resistor r=0.9578 c=0
Rk23 (\2\:n25 \4\:n25) resistor r=0.5661 c=0
Rk33 (\5\:n20 \6\:n20) resistor r=0.2999 c=0
Rk34 (\6\:n20 \7\:n20) resistor r=0.3682 c=0
Rk35 (\6\:n20 \9\:n20) resistor r=0.4464 c=0
Rk15 (\2\:n41 \4\:n41) resistor r=0.502 c=0
Rl9 (\1\:RN \2\:RN) resistor r=96.8456 c=0
Rl10 (\2\:RN \3\:RN) resistor r=98.7687 c=0
Rl41 (\1\:CKN \2\:CKN) resistor r=87.2302 c=0
Rl42 (\2\:CKN \3\:CKN) resistor r=39.1533 c=0
Rl38 (\2\:D \3\:D) resistor r=125.722 c=0
Rl37 (\1\:D \2\:D) resistor r=43.7849 c=0
Rl29 (\4\:SN \6\:SN) resistor r=140.385 c=0
Rl28 (\4\:SN \5\:SN) resistor r=73.7687 c=0
Rl13 (\1\:SN \2\:SN) resistor r=29.5379 c=0
Rl14 (\2\:SN \3\:SN) resistor r=69.9225 c=0
Rl1 (qint \2\:qint) resistor r=37.6944 c=0
Rl2 (\2\:qint \3\:qint) resistor r=26.1559 c=0
Rl15 (\8\:qbint \9\:qbint) resistor r=125.584 c=0
Rl16 (\9\:qbint \10\:qbint) resistor r=56.9251 c=0
Rl7 (\5\:qbint \6\:qbint) resistor r=24.848 c=0
Rl3 (qbint \2\:qbint) resistor r=81.4873 c=0
Rl6 (\2\:qbint \5\:qbint) resistor r=11.259 c=0
Rl8 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl5 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl4 (\2\:qbint \3\:qbint) resistor r=133.209 c=0
Rl17 (RNb \2\:RNb) resistor r=132.258 c=0
Rl24 (\4\:RNb \5\:RNb) resistor r=140.385 c=0
Rl25 (\4\:RNb \6\:RNb) resistor r=72.3097 c=0
Rl18 (\2\:RNb \3\:RNb) resistor r=94.48 c=0
Rl11 (n35 \2\:n35) resistor r=39.1533 c=0
Rl12 (\2\:n35 \3\:n35) resistor r=71.8456 c=0
Rl36 (\8\:CKNbb \9\:CKNbb) resistor r=79.5379 c=0
Rl33 (\6\:CKNbb \7\:CKNbb) resistor r=61.4557 c=0
Rl22 (\3\:CKNbb \4\:CKNbb) resistor r=24.2328 c=0
Rl23 (\4\:CKNbb \5\:CKNbb) resistor r=67.7945 c=0
Rl19 (CKNbb \2\:CKNbb) resistor r=24.2328 c=0
Rl30 (mout \2\:mout) resistor r=78.5603 c=0
Rl32 (\2\:mout \4\:mout) resistor r=97.7911 c=0
Rl31 (\2\:mout \3\:mout) resistor r=4.3144 c=0
Rl39 (\7\:CKNb \8\:CKNb) resistor r=187.381 c=0
Rl34 (\4\:CKNb \5\:CKNb) resistor r=202.895 c=0
Rl20 (CKNb \2\:CKNb) resistor r=170.285 c=0
Rl40 (\8\:CKNb \9\:CKNb) resistor r=46.8456 c=0
Rl35 (\5\:CKNb \6\:CKNb) resistor r=46.8456 c=0
Rl21 (\2\:CKNb \3\:CKNb) resistor r=126.436 c=0
Rl26 (n20 \2\:n20) resistor r=85.7713 c=0
Rl27 (\2\:n20 \3\:n20) resistor r=26.1559 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz18 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz19 (\1\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz20 (\1\:VDD \12\:VDD) resistor r=9.375 c=0
Rz21 (\1\:VDD \18\:VDD) resistor r=25 c=0
Rz22 (\1\:VDD \25\:VDD) resistor r=9.375 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz23 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz24 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz25 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz26 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz27 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz28 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz2 (\8\:qint \9\:qint) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz10 (\11\:RNb \12\:RNb) resistor r=75 c=0
Rz9 (\8\:n35 \9\:n35) resistor r=75 c=0
Rz5 (n42 \2\:n42) resistor r=75 c=0
Rz6 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz7 (n40 \2\:n40) resistor r=75 c=0
Rz8 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz16 (\17\:CKNbb \18\:CKNbb) resistor r=75 c=0
Rz13 (\13\:mout \14\:mout) resistor r=75 c=0
Rz14 (\15\:mout \16\:mout) resistor r=75 c=0
Rz17 (\12\:CKNb \13\:CKNb) resistor r=75 c=0
Rz11 (n25 \2\:n25) resistor r=75 c=0
Rz12 (\3\:n25 \4\:n25) resistor r=75 c=0
Rz15 (\4\:n20 \5\:n20) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry14 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry15 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry16 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry17 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry18 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry19 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry20 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry21 (\27\:VDD \28\:VDD) resistor r=62 c=0
Ry3 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry22 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry23 (\1\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry24 (\1\:VSS \6\:VSS) resistor r=20.6667 c=0
Ry25 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry26 (\1\:VSS \11\:VSS) resistor r=7.75 c=0
Ry2 (\4\:qint \5\:qint) resistor r=62 c=0
Ry4 (\11\:qbint \12\:qbint) resistor r=62 c=0
Ry8 (\9\:RNb \10\:RNb) resistor r=62 c=0
Ry7 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry12 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry9 (\9\:mout \10\:mout) resistor r=62 c=0
Ry10 (\11\:mout \12\:mout) resistor r=62 c=0
Ry13 (\10\:CKNb \11\:CKNb) resistor r=62 c=0
Ry11 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry5 (n41 \2\:n41) resistor r=62 c=0
Ry6 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx2 (\2\:RN \4\:RN) resistor r=45 c=0
Rx21 (\2\:CKN CKN) resistor r=45 c=0
Rx14 (\2\:D \4\:D) resistor r=45 c=0
Rx10 (\5\:SN \7\:SN) resistor r=45 c=0
Rx11 (\2\:SN \8\:SN) resistor r=45 c=0
Rx1 (\2\:qint \7\:qint) resistor r=45 c=0
Rx3 (\5\:qbint \16\:qbint) resistor r=45 c=0
Rx4 (\10\:qbint \17\:qbint) resistor r=45 c=0
Rx8 (\6\:RNb \7\:RNb) resistor r=45 c=0
Rx9 (\3\:RNb \8\:RNb) resistor r=45 c=0
Rx5 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx6 (\2\:CKNbb \10\:CKNbb) resistor r=45 c=0
Rx7 (\4\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx15 (\5\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx16 (\9\:CKNbb \19\:CKNbb) resistor r=45 c=0
Rx17 (\6\:CKNbb \20\:CKNbb) resistor r=45 c=0
Rx12 (\3\:mout \5\:mout) resistor r=45 c=0
Rx18 (\9\:CKNb \14\:CKNb) resistor r=45 c=0
Rx19 (\6\:CKNb \15\:CKNb) resistor r=45 c=0
Rx20 (\3\:CKNb \16\:CKNb) resistor r=45 c=0
Rx13 (\2\:n20 \7\:n20) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.36635e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\8\:qint \4\:qbint \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn55 (\1\:Q \6\:qbint \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.56154e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mn22 (\11\:RNb \3\:RN \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.537e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn45 (\13\:qbint \3\:n35 \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.39e-14 ad=2.03e-14 ps=1.43e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.2e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn50 (\3\:n42 \3\:SN \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.39e-14 ad=2.392e-14 ps=1.43e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=5.55e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn52 (\3\:n40 \9\:qbint \3\:n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.32e-14 ps=6.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn51 (\3\:n40 RNb n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=1.4e-07 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn53 (n40 CKNbb \8\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.8e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn40 (\8\:n35 \2\:CKNb \15\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.537e-14 ad=2.32e-14 ps=6.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn31 (\3\:n25 \5\:RNb \13\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=2.03e-14 ps=6.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.625e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn26 (\4\:n20 \8\:CKNbb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.305e-14 ad=2.32e-14 ps=4.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.265e-06 sb=5e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn32 (\13\:mout \3\:n20 n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.61e-14 ps=6.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.4e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn30 (n25 \6\:SN \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.05e-14 ad=2.32e-14 ps=1.54e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.195e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn35 (n30 \4\:mout \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.05e-14 ad=2.61e-14 ps=1.54e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=9.3e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn36 (\4\:n20 \5\:CKNb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=2.32e-14 ps=6.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=7.05e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn25 (n21 \1\:D \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.33e-14 ad=1.305e-14 ps=1.54e-06 pd=4.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-06 sb=3.65e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn21 (\17\:CKNbb \8\:CKNb \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.33e-14 ad=2.03e-14 ps=1.54e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.625e-06 sb=1.4e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn20 (\12\:CKNb \3\:CKN \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mp56 (\4\:qint \7\:qbint \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=49.4198 \
        scb=0.0326741 scc=0.00592591 m=(1)
mp55 (\3\:Q qbint \23\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.54359e-07 sd=160n sca=18.7372 \
        scb=0.0160946 scc=0.00159617 m=(1)
mp22 (\9\:RNb \1\:RN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.762e-14 ps=1.1e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75e-07 sd=160n sca=11.0038 \
        scb=0.00893072 scc=0.000173706 m=(1)
mp45 (\11\:qbint n35 \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.07e-13 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.99186e-07 sd=160n sca=31.508 \
        scb=0.0252524 scc=0.00399199 m=(1)
mp50 (\3\:n41 \1\:SN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.07e-13 ad=4.3e-14 ps=1.9e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.62442e-07 sb=5.2e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp52 (\3\:n41 \8\:qbint n43 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.3e-14 ps=5.5e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.07442e-07 sb=2.75e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp51 (n43 \2\:RNb \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.835e-14 ad=1.29e-14 ps=1.8e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.12442e-07 sb=1.7e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp53 (n41 CKNb \4\:n35 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=28.4541 \
        scb=0.0241553 scc=0.00347654 m=(1)
mp40 (\4\:n35 \3\:CKNbb \9\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.548e-14 ps=7.1e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=28.4541 \
        scb=0.0241553 scc=0.00347654 m=(1)
mp31 (n26 \4\:RNb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.078e-14 ad=3.87e-14 ps=1.63e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-07 sb=1.02535e-06 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp32 (\11\:mout n20 n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.44e-14 ps=7.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=8.00349e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp30 (\11\:mout \4\:SN \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.965e-14 ad=3.44e-14 ps=1.71e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=5.95349e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp35 (n31 mout \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.965e-14 ad=1.827e-14 ps=1.71e-06 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.72326e-07 sb=9e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp36 (\8\:n20 \7\:CKNbb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.827e-14 ad=3.44e-14 ps=6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.02326e-07 sb=7.7e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp26 (\8\:n20 \4\:CKNb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.07326e-07 sb=5.65e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp25 (n22 \3\:D \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.02733e-06 sb=3.45e-07 sd=160n sca=11.4924 \
        scb=0.00977085 scc=0.000239291 m=(1)
mp21 (\12\:CKNbb \7\:CKNb \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23233e-06 sb=1.4e-07 sd=160n sca=12.0329 \
        scb=0.00996522 scc=0.000239356 m=(1)
mp20 (\10\:CKNb \1\:CKN \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=21.5355 \
        scb=0.0237969 scc=0.00114597 m=(1)
ends DFFNSRX1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:07:48 2012 )
// Library name: gsclib045
// Cell name: DFFRHQX1
// View name: extracted

simulator lang=spectre

subckt DFFRHQX1 CK D Q RN VDD VSS
mp55 (\1\:Q qbint \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.61346e-07 sd=160n sca=30.3965 \
        scb=0.0339368 scc=0.00268693 m=(1)
C1 (CK VSS) capacitor c=5.00788e-17
C2 (Q VSS) capacitor c=4.50174e-17
C3 (D VSS) capacitor c=4.62092e-17
C4 (VDD VSS) capacitor c=2.31293e-16
C5 (qbint VSS) capacitor c=5.37814e-17
C6 (CKb VSS) capacitor c=4.96753e-17
C7 (n35 VSS) capacitor c=1.23531e-18
C8 (n30 VSS) capacitor c=5.82218e-17
C9 (n40 VSS) capacitor c=1.30342e-18
C10 (mout VSS) capacitor c=5.20369e-17
C11 (CKbb VSS) capacitor c=2.56084e-17
C12 (n20 VSS) capacitor c=4.81152e-17
C13 (n21 VSS) capacitor c=1.23445e-18
C14 (n41 VSS) capacitor c=1.08267e-18
C15 (n26 VSS) capacitor c=1.20453e-16
C16 (n22 VSS) capacitor c=9.87314e-20
C17 (\8\:CKb VSS) capacitor c=2.82409e-17
C18 (\1\:D VSS) capacitor c=1.1127e-16
C19 (\6\:CKbb VSS) capacitor c=6.99395e-17
C20 (\5\:CKb VSS) capacitor c=3.60193e-17
C21 (\1\:RN VSS) capacitor c=1.39482e-16
C22 (\3\:CKb VSS) capacitor c=3.7618e-17
C23 (\3\:CKbb VSS) capacitor c=9.26319e-17
C24 (\4\:qbint VSS) capacitor c=8.63522e-17
C25 (\2\:RN VSS) capacitor c=1.02731e-16
C26 (\3\:n30 VSS) capacitor c=5.7454e-17
C27 (\1\:CK VSS) capacitor c=3.33344e-17
C28 (\10\:CKb VSS) capacitor c=4.59354e-17
C29 (\3\:D VSS) capacitor c=7.18658e-17
C30 (\7\:CKb VSS) capacitor c=6.928e-17
C31 (\4\:CKbb VSS) capacitor c=4.19606e-17
C32 (\3\:mout VSS) capacitor c=5.36544e-17
C33 (\5\:RN VSS) capacitor c=7.05954e-17
C34 (\3\:n20 VSS) capacitor c=4.81143e-17
C35 (\6\:qbint VSS) capacitor c=5.82e-17
C36 (\4\:RN VSS) capacitor c=8.05408e-17
C37 (\3\:CK VSS) capacitor c=4.66865e-17
C38 (\3\:qbint VSS) capacitor c=3.22106e-17
C39 (\9\:CKb VSS) capacitor c=5.12877e-17
C40 (\2\:D VSS) capacitor c=6.76906e-17
C41 (\7\:CKbb VSS) capacitor c=5.18041e-17
C42 (\6\:CKb VSS) capacitor c=4.58332e-17
C43 (\5\:CKbb VSS) capacitor c=3.74601e-17
C44 (\2\:mout VSS) capacitor c=6.15925e-17
C45 (\2\:n20 VSS) capacitor c=4.59956e-17
C46 (\4\:CKb VSS) capacitor c=3.11607e-17
C47 (\2\:CKbb VSS) capacitor c=7.36418e-17
C48 (\2\:CKb VSS) capacitor c=5.63715e-17
C49 (\5\:qbint VSS) capacitor c=7.84089e-17
C50 (\3\:RN VSS) capacitor c=5.22729e-17
C51 (\2\:n30 VSS) capacitor c=4.21411e-17
C52 (\2\:CK VSS) capacitor c=4.75887e-17
C53 (\2\:qbint VSS) capacitor c=3.50794e-17
C54 (\12\:CKbb VSS) capacitor c=3.53547e-17
C55 (\1\:VDD VSS) capacitor c=8.2798e-17
C56 (\4\:n20 VSS) capacitor c=1.20316e-16
C57 (\11\:VDD VSS) capacitor c=5.90544e-17
C58 (\3\:n26 VSS) capacitor c=1.02851e-16
C59 (\13\:VDD VSS) capacitor c=6.82052e-17
C60 (\8\:mout VSS) capacitor c=1.12164e-16
C61 (\4\:n30 VSS) capacitor c=1.0467e-16
C62 (\15\:VDD VSS) capacitor c=9.08929e-17
C63 (\11\:qbint VSS) capacitor c=8.25328e-17
C64 (\17\:VDD VSS) capacitor c=7.45369e-17
C65 (\20\:CKb VSS) capacitor c=3.61536e-17
C66 (\19\:VDD VSS) capacitor c=7.39729e-17
C67 (\1\:Q VSS) capacitor c=3.36917e-17
C68 (\4\:VDD VSS) capacitor c=1.66356e-17
C69 (\15\:CKbb VSS) capacitor c=1.61405e-17
C70 (\8\:n20 VSS) capacitor c=6.08683e-17
C71 (\6\:mout VSS) capacitor c=6.02739e-17
C72 (\8\:n30 VSS) capacitor c=3.30765e-17
C73 (\13\:qbint VSS) capacitor c=3.8109e-17
C74 (\17\:CKb VSS) capacitor c=1.04744e-16
C75 (\3\:Q VSS) capacitor c=7.06652e-17
C76 (\4\:CK VSS) capacitor c=4.09023e-17
C77 (\7\:qbint VSS) capacitor c=7.02619e-17
C78 (\8\:qbint VSS) capacitor c=1.4894e-16
C79 (\9\:qbint VSS) capacitor c=1.80241e-16
C80 (\10\:qbint VSS) capacitor c=1.46145e-16
C81 (\6\:RN VSS) capacitor c=7.10306e-17
C82 (\8\:RN VSS) capacitor c=6.81756e-17
C83 (\6\:n30 VSS) capacitor c=1.41235e-16
C84 (\7\:n30 VSS) capacitor c=1.1151e-16
C85 (\4\:mout VSS) capacitor c=1.00302e-16
C86 (\5\:mout VSS) capacitor c=1.27681e-16
C87 (\6\:n20 VSS) capacitor c=1.68451e-16
C88 (\7\:n20 VSS) capacitor c=1.38975e-16
C89 (\4\:D VSS) capacitor c=7.24846e-17
C90 (\11\:CKb VSS) capacitor c=1.64179e-16
C91 (\12\:CKb VSS) capacitor c=3.4192e-16
C92 (\13\:CKb VSS) capacitor c=2.30396e-16
C93 (\14\:CKb VSS) capacitor c=8.59568e-17
C94 (\15\:CKb VSS) capacitor c=2.71408e-16
C95 (\16\:CKb VSS) capacitor c=2.38697e-16
C96 (\19\:CKb VSS) capacitor c=7.46957e-17
C97 (\8\:CKbb VSS) capacitor c=3.5925e-17
C98 (\9\:CKbb VSS) capacitor c=2.69675e-16
C99 (\10\:CKbb VSS) capacitor c=1.36761e-16
C100 (\11\:CKbb VSS) capacitor c=6.80065e-17
C101 (\14\:CKbb VSS) capacitor c=1.82136e-16
C102 (\17\:CKbb VSS) capacitor c=7.8511e-17
C103 (\3\:VDD VSS) capacitor c=3.44399e-17
C104 (\6\:VDD VSS) capacitor c=3.86422e-17
C105 (\7\:VDD VSS) capacitor c=4.50475e-17
C106 (\8\:VDD VSS) capacitor c=1.45096e-17
C107 (\10\:VDD VSS) capacitor c=7.13081e-18
Rk3 (\4\:CK CK) resistor r=0.05341 c=0
Rk1 (Q \2\:Q) resistor r=0.07294 c=0
Rk2 (Q \4\:Q) resistor r=0.4479 c=0
Rk38 (\2\:VSS \3\:VSS) resistor r=0.2514 c=0
Rk39 (\3\:VSS \5\:VSS) resistor r=0.2052 c=0
Rk40 (\5\:VSS \6\:VSS) resistor r=0.2382 c=0
Rk41 (\6\:VSS \7\:VSS) resistor r=0.1678 c=0
Rk42 (\3\:VSS \8\:VSS) resistor r=0.2508 c=0
Rk43 (\8\:VSS \9\:VSS) resistor r=0.1976 c=0
Rk44 (\9\:VSS \10\:VSS) resistor r=0.3092 c=0
Rk46 (\11\:VSS VSS) resistor r=0.1035 c=0
Rk45 (\10\:VSS \11\:VSS) resistor r=0.1494 c=0
Rk47 (\6\:VSS \13\:VSS) resistor r=0.2097 c=0
Rk48 (\7\:VSS \15\:VSS) resistor r=0.2281 c=0
Rk49 (\9\:VSS \17\:VSS) resistor r=0.2308 c=0
Rk50 (\11\:VSS \19\:VSS) resistor r=0.309 c=0
Rk22 (D \4\:D) resistor r=0.1047 c=0
Rk51 (\2\:VDD \3\:VDD) resistor r=0.7586 c=0
Rk52 (\3\:VDD \5\:VDD) resistor r=0.05305 c=0
Rk53 (\5\:VDD \6\:VDD) resistor r=0.1545 c=0
Rk54 (\6\:VDD \7\:VDD) resistor r=0.4383 c=0
Rk55 (\7\:VDD \8\:VDD) resistor r=0.243 c=0
Rk56 (\8\:VDD \9\:VDD) resistor r=0.07588 c=0
Rk58 (\10\:VDD VDD) resistor r=0.1035 c=0
Rk57 (\9\:VDD \10\:VDD) resistor r=0.1494 c=0
Rk59 (\3\:VDD \12\:VDD) resistor r=0.3115 c=0
Rk60 (\6\:VDD \14\:VDD) resistor r=0.3676 c=0
Rk61 (\7\:VDD \16\:VDD) resistor r=0.4013 c=0
Rk62 (\8\:VDD \18\:VDD) resistor r=0.3386 c=0
Rk63 (\10\:VDD \20\:VDD) resistor r=0.3605 c=0
Rk9 (\6\:RN \7\:RN) resistor r=0.00567 c=0
Rk10 (RN \8\:RN) resistor r=0.00567 c=0
Rk11 (\6\:RN \8\:RN) resistor r=0.06642 c=0
Rk4 (\7\:qbint \8\:qbint) resistor r=0.3386 c=0
Rk5 (\8\:qbint \9\:qbint) resistor r=0.5369 c=0
Rk6 (\9\:qbint \10\:qbint) resistor r=0.9141 c=0
Rk7 (\8\:qbint \12\:qbint) resistor r=0.3894 c=0
Rk8 (\9\:qbint \14\:qbint) resistor r=0.1112 c=0
Rk23 (\11\:CKb \12\:CKb) resistor r=1.1591 c=0
Rk24 (\12\:CKb \13\:CKb) resistor r=1.3824 c=0
Rk25 (\13\:CKb \14\:CKb) resistor r=0.3979 c=0
Rk26 (\13\:CKb \15\:CKb) resistor r=0.5539 c=0
Rk27 (\15\:CKb \16\:CKb) resistor r=1.3763 c=0
Rk28 (\16\:CKb \18\:CKb) resistor r=0.461 c=0
Rk29 (\15\:CKb \19\:CKb) resistor r=0.4123 c=0
Rk30 (\16\:CKb \21\:CKb) resistor r=0.1996 c=0
Rk12 (\5\:n30 \6\:n30) resistor r=0.6402 c=0
Rk13 (\6\:n30 \7\:n30) resistor r=0.6152 c=0
Rk14 (\6\:n30 \9\:n30) resistor r=0.08583 c=0
Rk15 (\4\:mout \5\:mout) resistor r=0.5031 c=0
Rk16 (\5\:mout \7\:mout) resistor r=0.2002 c=0
Rk17 (\5\:mout \9\:mout) resistor r=0.4231 c=0
Rk31 (\8\:CKbb \9\:CKbb) resistor r=0.06918 c=0
Rk32 (\9\:CKbb \10\:CKbb) resistor r=1.0875 c=0
Rk33 (\10\:CKbb \11\:CKbb) resistor r=0.252 c=0
Rk34 (\11\:CKbb \13\:CKbb) resistor r=0.2478 c=0
Rk35 (\9\:CKbb \14\:CKbb) resistor r=1.1807 c=0
Rk36 (\10\:CKbb \16\:CKbb) resistor r=0.07674 c=0
Rk37 (\11\:CKbb \17\:CKbb) resistor r=0.3146 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.676 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.7869 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.2139 c=0
Rk18 (\2\:n26 \4\:n26) resistor r=0.5797 c=0
Rl3 (\1\:CK \2\:CK) resistor r=96.8456 c=0
Rl4 (\2\:CK \3\:CK) resistor r=154.538 c=0
Rl25 (\1\:D \2\:D) resistor r=168.257 c=0
Rl26 (\2\:D \3\:D) resistor r=111.459 c=0
Rl15 (\1\:RN \2\:RN) resistor r=367.561 c=0
Rl18 (\1\:RN \5\:RN) resistor r=207.692 c=0
Rl16 (\2\:RN \3\:RN) resistor r=40.8576 c=0
Rl17 (\3\:RN \4\:RN) resistor r=138.31 c=0
Rl7 (\4\:qbint \5\:qbint) resistor r=127.926 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=53.079 c=0
Rl1 (qbint \2\:qbint) resistor r=106.867 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=26.098 c=0
Rl27 (\8\:CKb \9\:CKb) resistor r=26.1559 c=0
Rl28 (\9\:CKb \10\:CKb) resistor r=187.694 c=0
Rl22 (\5\:CKb \6\:CKb) resistor r=42.3077 c=0
Rl23 (\6\:CKb \7\:CKb) resistor r=141.209 c=0
Rl12 (\3\:CKb \4\:CKb) resistor r=35.3072 c=0
Rl9 (CKb \2\:CKb) resistor r=51.098 c=0
Rl5 (n30 \2\:n30) resistor r=60.6757 c=0
Rl6 (\2\:n30 \3\:n30) resistor r=149.175 c=0
Rl19 (mout \2\:mout) resistor r=133.848 c=0
Rl20 (\2\:mout \3\:mout) resistor r=45.3867 c=0
Rl24 (\6\:CKbb \7\:CKbb) resistor r=71.8456 c=0
Rl21 (\4\:CKbb \5\:CKbb) resistor r=29.5379 c=0
Rl10 (CKbb \2\:CKbb) resistor r=55.3008 c=0
Rl11 (\2\:CKbb \3\:CKbb) resistor r=174.543 c=0
Rl13 (n20 \2\:n20) resistor r=56.4615 c=0
Rl14 (\2\:n20 \3\:n20) resistor r=124.527 c=0
Rz1 (\3\:Q \4\:Q) resistor r=37.5 c=0
Rz8 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz9 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz10 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz11 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz12 (\18\:VSS \19\:VSS) resistor r=37.5 c=0
Rz13 (\4\:VDD \5\:VDD) resistor r=6.25 c=0
Rz14 (\4\:VDD \9\:VDD) resistor r=12.5 c=0
Rz2 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz6 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz3 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz7 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry10 (\4\:VSS \5\:VSS) resistor r=12.4 c=0
Ry11 (\4\:VSS \7\:VSS) resistor r=20.6667 c=0
Ry12 (\4\:VSS \8\:VSS) resistor r=15.5 c=0
Ry13 (\4\:VSS \10\:VSS) resistor r=10.3333 c=0
Ry14 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry15 (\11\:VDD \12\:VDD) resistor r=31 c=0
Ry16 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry17 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry18 (\17\:VDD \18\:VDD) resistor r=31 c=0
Ry19 (\19\:VDD \20\:VDD) resistor r=20.6667 c=0
Ry2 (\11\:qbint \12\:qbint) resistor r=62 c=0
Ry8 (\20\:CKb \21\:CKb) resistor r=62 c=0
Ry3 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\12\:CKbb \13\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry5 (n26 \2\:n26) resistor r=31 c=0
Ry6 (\3\:n26 \4\:n26) resistor r=31 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx8 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\3\:RN \7\:RN) resistor r=45 c=0
Rx2 (\5\:qbint \7\:qbint) resistor r=45 c=0
Rx3 (\2\:qbint \10\:qbint) resistor r=45 c=0
Rx9 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx10 (\6\:CKb \12\:CKb) resistor r=45 c=0
Rx11 (\4\:CKb \14\:CKb) resistor r=45 c=0
Rx12 (\2\:CKb \19\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx13 (\5\:CKbb \8\:CKbb) resistor r=45 c=0
Rx14 (\2\:CKbb \14\:CKbb) resistor r=45 c=0
Rx15 (\7\:CKbb \17\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \7\:n20) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.85e-07 sd=160n sca=9.32128 scb=0.00786794 \
        scc=0.000232361 m=(1)
mn20 (\17\:CKb \3\:CK \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.393e-14 ps=9e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.65e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn46 (\13\:qbint n30 n35 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.53e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23415e-07 sb=1.98037e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn45 (n35 \4\:RN \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.733e-14 ad=1.23e-14 ps=1.19e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.28415e-07 sb=1.89073e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn50 (n40 \6\:qbint \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.733e-14 ad=1.23e-14 ps=1.19e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.38415e-07 sb=1.68073e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn51 (\8\:n30 CKb n40 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.715e-14 ps=5.3e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.43415e-07 sb=1.57573e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn40 (\8\:n30 CKbb \6\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=4.715e-14 ps=8.5e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.18415e-07 sb=1.30073e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn30 (\6\:mout \3\:n20 \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.92e-14 ad=4.51e-14 ps=1.24e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.08341e-06 sb=1.03573e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn35 (n27 \5\:RN \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.92e-14 ad=3.28e-14 ps=1.24e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31841e-06 sb=8.00732e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn36 (n25 \3\:mout n27 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=1.23e-14 ps=7.3e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52341e-06 sb=5.95732e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn37 (\8\:n20 \4\:CKbb n25 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.305e-14 ps=5.3e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.62841e-06 sb=4.90732e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn26 (\8\:n20 \7\:CKb n21 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.305e-14 ps=5.3e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.88341e-06 sb=2.35732e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn25 (n21 \3\:D \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.04e-14 ad=1.23e-14 ps=8.1e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.98549e-06 sb=1.30732e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn21 (\15\:CKbb \10\:CKb \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mp20 (\20\:CKb \1\:CK \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.69e-14 ps=1.16e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.25116e-07 sd=160n sca=13.8096 \
        scb=0.0118363 scc=0.000162518 m=(1)
mp46 (\11\:qbint \3\:n30 \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.66e-14 ad=5.735e-14 ps=9.5e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.50323e-07 sb=1.65597e-06 sd=160n sca=12.8747 \
        scb=0.0114137 scc=0.000458937 m=(1)
mp45 (\11\:qbint \2\:RN \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=6.045e-14 ad=5.735e-14 ps=1.01e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.80323e-07 sb=1.42597e-06 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp50 (n41 \4\:qbint \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=2.015e-14 ps=1.01e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.20323e-07 sb=1.18597e-06 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp51 (\4\:n30 \3\:CKbb n41 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=2.015e-14 ad=6.355e-14 ps=7.5e-07 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.30323e-07 sb=1.07597e-06 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp40 (\4\:n30 \3\:CKb \8\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.51e-14 ad=6.355e-14 ps=1.04e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.80323e-07 sb=8.25968e-07 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp30 (\8\:mout n20 \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=6.51e-14 ps=1e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.23532e-06 sb=5.70968e-07 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp35 (\3\:n26 \1\:RN \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=4.96e-14 ps=1e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47032e-06 sb=3.35968e-07 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp36 (\3\:n26 mout \11\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.06e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.67532e-06 sb=1.30968e-07 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp37 (\4\:n20 \5\:CKb n26 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.145e-14 ad=4.96e-14 ps=9.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65968e-07 sb=6.00726e-07 sd=160n sca=13.271 \
        scb=0.0115865 scc=0.00045901 m=(1)
mp26 (\4\:n20 \6\:CKbb n22 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.70968e-07 sb=3.95726e-07 sd=160n sca=14.4949 \
        scb=0.0127984 scc=0.000462551 m=(1)
mp25 (n22 \1\:D \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=1.86e-14 ps=1e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.75968e-07 sb=2.90726e-07 sd=160n sca=15.7848 \
        scb=0.014788 scc=0.000483319 m=(1)
mp21 (\12\:CKbb \8\:CKb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.415e-14 ad=2.63e-14 ps=1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=1.22326e-07 sd=160n sca=27.6163 \
        scb=0.0324392 scc=0.00204694 m=(1)
ends DFFRHQX1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:08:34 2012 )
// Library name: gsclib045
// Cell name: DFFRX4
// View name: extracted

simulator lang=spectre

subckt DFFRX4 CK D Q QN RN VDD VSS
mp20 (\15\:CKb \1\:CK \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=2.63e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.22326e-07 sd=160n sca=29.2967 \
        scb=0.0344712 scc=0.00236568 m=(1)
C1 (Q VSS) capacitor c=3.03703e-17
C2 (RN VSS) capacitor c=2.15474e-16
C3 (VDD VSS) capacitor c=3.01598e-16
C4 (D VSS) capacitor c=5.70182e-17
C5 (QN VSS) capacitor c=3.584e-17
C6 (CK VSS) capacitor c=1.98194e-17
C7 (CKb VSS) capacitor c=4.42058e-17
C8 (CKbb VSS) capacitor c=6.11451e-17
C9 (n21 VSS) capacitor c=4.54287e-19
C10 (n20 VSS) capacitor c=6.76173e-17
C11 (mout VSS) capacitor c=3.61906e-17
C12 (n30 VSS) capacitor c=1.24304e-16
C13 (n40 VSS) capacitor c=1.13137e-18
C14 (qbint VSS) capacitor c=5.46554e-17
C15 (23 VSS) capacitor c=1.66234e-18
C16 (qint VSS) capacitor c=2.48446e-16
C17 (n26 VSS) capacitor c=8.18099e-17
C18 (n41 VSS) capacitor c=5.56498e-19
C19 (\21\:qbint VSS) capacitor c=4.36485e-17
C20 (\4\:qbint VSS) capacitor c=2.60357e-16
C21 (\3\:qbint VSS) capacitor c=4.00152e-17
C22 (\5\:CKbb VSS) capacitor c=9.05619e-17
C23 (\7\:CKb VSS) capacitor c=6.59444e-17
C24 (\1\:RN VSS) capacitor c=4.92177e-17
C25 (\5\:CKb VSS) capacitor c=5.51326e-17
C26 (\4\:D VSS) capacitor c=6.81449e-17
C27 (\1\:CK VSS) capacitor c=2.97721e-17
C28 (\19\:qbint VSS) capacitor c=2.24273e-17
C29 (\9\:RN VSS) capacitor c=5.70004e-17
C30 (\5\:n30 VSS) capacitor c=4.25644e-17
C31 (\7\:n30 VSS) capacitor c=4.60774e-17
C32 (\4\:RN VSS) capacitor c=4.48686e-17
C33 (\9\:CKb VSS) capacitor c=3.81685e-17
C34 (\6\:CKbb VSS) capacitor c=9.67931e-17
C35 (\4\:n20 VSS) capacitor c=3.48874e-17
C36 (\3\:RN VSS) capacitor c=7.25932e-17
C37 (\4\:mout VSS) capacitor c=8.32581e-17
C38 (\3\:CKbb VSS) capacitor c=4.34937e-17
C39 (\4\:CKb VSS) capacitor c=7.84119e-17
C40 (\1\:D VSS) capacitor c=7.64406e-17
C41 (\3\:CKb VSS) capacitor c=4.3208e-17
C42 (\3\:CK VSS) capacitor c=2.51625e-17
C43 (\20\:qbint VSS) capacitor c=3.37664e-17
C44 (\5\:RN VSS) capacitor c=4.58286e-16
C45 (\2\:qbint VSS) capacitor c=4.39217e-17
C46 (\10\:CKb VSS) capacitor c=4.72532e-17
C47 (\8\:CKb VSS) capacitor c=2.48953e-17
C48 (\3\:n20 VSS) capacitor c=3.42157e-17
C49 (\2\:RN VSS) capacitor c=6.91586e-17
C50 (\7\:CKbb VSS) capacitor c=5.39594e-17
C51 (\3\:mout VSS) capacitor c=5.37367e-17
C52 (\4\:CKbb VSS) capacitor c=2.29019e-17
C53 (\6\:CKb VSS) capacitor c=2.36448e-17
C54 (\2\:CKbb VSS) capacitor c=4.81423e-17
C55 (\3\:D VSS) capacitor c=2.78777e-17
C56 (\2\:CKb VSS) capacitor c=2.01624e-17
C57 (\2\:CK VSS) capacitor c=2.42492e-17
C58 (\16\:qint VSS) capacitor c=3.28699e-17
C59 (\1\:Q VSS) capacitor c=1.51804e-16
C60 (\30\:VDD VSS) capacitor c=6.00913e-17
C61 (\10\:n30 VSS) capacitor c=7.63399e-17
C62 (\9\:mout VSS) capacitor c=2.91479e-17
C63 (\34\:VDD VSS) capacitor c=1.8301e-17
C64 (\36\:VDD VSS) capacitor c=1.70149e-17
C65 (\3\:n26 VSS) capacitor c=6.78001e-17
C66 (\7\:n20 VSS) capacitor c=9.44812e-17
C67 (\38\:VDD VSS) capacitor c=1.56535e-17
C68 (\15\:CKbb VSS) capacitor c=6.02472e-17
C69 (\15\:CKb VSS) capacitor c=8.78062e-17
C70 (\18\:VDD VSS) capacitor c=3.67124e-17
C71 (\1\:VDD VSS) capacitor c=8.9707e-17
C72 (\19\:qint VSS) capacitor c=4.64356e-17
C73 (\1\:QN VSS) capacitor c=1.00028e-16
C74 (\32\:qbint VSS) capacitor c=9.91982e-17
C75 (\12\:n30 VSS) capacitor c=2.88362e-17
C76 (\5\:mout VSS) capacitor c=8.87601e-17
C77 (\9\:n20 VSS) capacitor c=2.9299e-17
C78 (\12\:CKbb VSS) capacitor c=2.63222e-17
C79 (\17\:CKb VSS) capacitor c=8.25602e-17
C80 (\2\:D VSS) capacitor c=4.41523e-17
C81 (\2\:n20 VSS) capacitor c=2.7619e-17
C82 (\4\:n30 VSS) capacitor c=2.97312e-17
C83 (\4\:CK VSS) capacitor c=6.79129e-17
C84 (\5\:D VSS) capacitor c=5.72184e-17
C85 (\8\:CKbb VSS) capacitor c=5.57153e-17
C86 (\9\:CKbb VSS) capacitor c=7.27577e-17
C87 (\10\:CKbb VSS) capacitor c=1.12459e-16
C88 (\11\:CKbb VSS) capacitor c=6.39622e-17
C89 (\14\:CKbb VSS) capacitor c=4.83259e-17
C90 (\5\:n20 VSS) capacitor c=8.58809e-17
C91 (\6\:n20 VSS) capacitor c=5.2973e-17
C92 (\7\:mout VSS) capacitor c=1.05899e-16
C93 (\8\:mout VSS) capacitor c=1.08576e-16
C94 (\11\:CKb VSS) capacitor c=1.12233e-16
C95 (\12\:CKb VSS) capacitor c=1.3544e-16
C96 (\13\:CKb VSS) capacitor c=1.19432e-16
C97 (\14\:CKb VSS) capacitor c=7.18718e-17
C98 (\8\:n30 VSS) capacitor c=1.11802e-16
C99 (\9\:n30 VSS) capacitor c=1.01706e-16
C100 (\13\:RN VSS) capacitor c=7.68421e-17
C101 (\22\:qbint VSS) capacitor c=3.66044e-17
C102 (\23\:qbint VSS) capacitor c=2.00073e-16
C103 (\25\:qbint VSS) capacitor c=5.0758e-17
C104 (\4\:Q VSS) capacitor c=1.04572e-16
C105 (\5\:QN VSS) capacitor c=1.35776e-16
C106 (\30\:qbint VSS) capacitor c=1.63846e-16
C107 (\31\:qbint VSS) capacitor c=1.73871e-16
C108 (\34\:qbint VSS) capacitor c=4.75203e-17
C109 (\18\:qint VSS) capacitor c=3.48084e-17
C110 (\21\:qint VSS) capacitor c=4.12058e-17
C111 (\3\:VDD VSS) capacitor c=4.47191e-16
C112 (\13\:VDD VSS) capacitor c=9.00273e-18
C113 (\14\:VDD VSS) capacitor c=1.32907e-17
C114 (\16\:VDD VSS) capacitor c=1.47308e-17
Rk34 (\1\:Q Q) resistor r=0.02269 c=0
Rk35 (Q \4\:Q) resistor r=0.1695 c=0
Rk25 (\5\:RN RN) resistor r=1.0104 c=0
Rk27 (RN \13\:RN) resistor r=0.4493 c=0
Rk71 (\2\:VDD \3\:VDD) resistor r=0.1178 c=0
Rk80 (\3\:VDD \12\:VDD) resistor r=0.3009 c=0
Rk81 (\12\:VDD \13\:VDD) resistor r=0.07163 c=0
Rk82 (\13\:VDD \14\:VDD) resistor r=0.2461 c=0
Rk83 (\14\:VDD \15\:VDD) resistor r=0.1795 c=0
Rk84 (\15\:VDD \16\:VDD) resistor r=0.1529 c=0
Rk86 (\17\:VDD VDD) resistor r=0.1004 c=0
Rk85 (\16\:VDD \17\:VDD) resistor r=0.1981 c=0
Rk87 (VDD \19\:VDD) resistor r=0.3591 c=0
Rk93 (\3\:VDD \31\:VDD) resistor r=0.3386 c=0
Rk95 (\13\:VDD \35\:VDD) resistor r=0.04335 c=0
Rk96 (\14\:VDD \37\:VDD) resistor r=0.04335 c=0
Rk97 (\16\:VDD \39\:VDD) resistor r=0.0744 c=0
Rk2 (D \5\:D) resistor r=0.1358 c=0
Rk41 (\5\:QN QN) resistor r=0.0313 c=0
Rk40 (\1\:QN \5\:QN) resistor r=0.2838 c=0
Rk1 (\4\:CK CK) resistor r=0.03605 c=0
Rk54 (\1\:VSS \8\:VSS) resistor r=0.2071 c=0
Rk55 (\8\:VSS \9\:VSS) resistor r=0.1469 c=0
Rk56 (\9\:VSS \10\:VSS) resistor r=0.47 c=0
Rk57 (\10\:VSS \11\:VSS) resistor r=0.3833 c=0
Rk58 (\11\:VSS \12\:VSS) resistor r=0.04999 c=0
Rk60 (\13\:VSS VSS) resistor r=0.2913 c=0
Rk59 (\12\:VSS \13\:VSS) resistor r=0.11 c=0
Rk66 (\9\:VSS \24\:VSS) resistor r=0.04335 c=0
Rk67 (\10\:VSS \26\:VSS) resistor r=0.2745 c=0
Rk68 (\12\:VSS \28\:VSS) resistor r=0.3267 c=0
Rk69 (\13\:VSS \30\:VSS) resistor r=0.3389 c=0
Rk70 (VSS \32\:VSS) resistor r=0.1479 c=0
Rk16 (\11\:CKb \12\:CKb) resistor r=0.6407 c=0
Rk17 (\12\:CKb \13\:CKb) resistor r=0.7242 c=0
Rk18 (\13\:CKb \14\:CKb) resistor r=0.3675 c=0
Rk19 (\14\:CKb \16\:CKb) resistor r=0.2937 c=0
Rk20 (\16\:CKb \18\:CKb) resistor r=0.4952 c=0
Rk3 (\8\:CKbb \9\:CKbb) resistor r=0.1893 c=0
Rk4 (\9\:CKbb \10\:CKbb) resistor r=0.5888 c=0
Rk5 (\10\:CKbb \11\:CKbb) resistor r=0.3129 c=0
Rk6 (\11\:CKbb \13\:CKbb) resistor r=0.1099 c=0
Rk7 (\10\:CKbb \14\:CKbb) resistor r=0.1589 c=0
Rk8 (\11\:CKbb \16\:CKbb) resistor r=0.3577 c=0
Rk10 (\5\:n20 \6\:n20) resistor r=0.3886 c=0
Rk11 (\6\:n20 \8\:n20) resistor r=0.4402 c=0
Rk12 (\6\:n20 \10\:n20) resistor r=0.09494 c=0
Rk13 (\6\:mout \7\:mout) resistor r=0.4457 c=0
Rk14 (\7\:mout \8\:mout) resistor r=0.5264 c=0
Rk15 (\7\:mout \10\:mout) resistor r=0.08508 c=0
Rk21 (\8\:n30 \9\:n30) resistor r=0.6092 c=0
Rk22 (\9\:n30 \11\:n30) resistor r=0.3959 c=0
Rk23 (\9\:n30 \13\:n30) resistor r=0.06376 c=0
Rk28 (\22\:qbint \23\:qbint) resistor r=0.249 c=0
Rk30 (\23\:qbint \25\:qbint) resistor r=0.2635 c=0
Rk44 (\30\:qbint \31\:qbint) resistor r=0.9752 c=0
Rk45 (\31\:qbint \33\:qbint) resistor r=0.907 c=0
Rk46 (\31\:qbint \34\:qbint) resistor r=0.2455 c=0
Rk47 (\17\:qint \18\:qint) resistor r=0.1135 c=0
Rk48 (\18\:qint \20\:qint) resistor r=0.303 c=0
Rk49 (\18\:qint \21\:qint) resistor r=0.2316 c=0
Rk9 (\2\:n26 \4\:n26) resistor r=0.2129 c=0
Rl35 (\5\:RN \9\:RN) resistor r=37.2302 c=0
Rl26 (\5\:RN \4\:RN) resistor r=26.9231 c=0
Rl15 (\2\:RN \1\:RN) resistor r=49.9772 c=0
Rl16 (\2\:RN \3\:RN) resistor r=97.872 c=0
Rl8 (\2\:D \4\:D) resistor r=66.0479 c=0
Rl6 (\1\:D \2\:D) resistor r=161.847 c=0
Rl7 (\2\:D \3\:D) resistor r=8.149 c=0
Rl1 (\1\:CK \2\:CK) resistor r=85.3072 c=0
Rl2 (\2\:CK \3\:CK) resistor r=60.3072 c=0
Rl9 (\4\:CKb \5\:CKb) resistor r=172.924 c=0
Rl4 (CKb \3\:CKb) resistor r=171.154 c=0
Rl23 (\9\:CKb \10\:CKb) resistor r=56.461 c=0
Rl20 (\7\:CKb \8\:CKb) resistor r=26.1559 c=0
Rl10 (\5\:CKb \6\:CKb) resistor r=24.2328 c=0
Rl3 (CKb \2\:CKb) resistor r=35.7713 c=0
Rl21 (\5\:CKbb \6\:CKbb) resistor r=206.824 c=0
Rl22 (\6\:CKbb \7\:CKbb) resistor r=266.382 c=0
Rl11 (\3\:CKbb \4\:CKbb) resistor r=54.9442 c=0
Rl5 (CKbb \2\:CKbb) resistor r=26.1559 c=0
Rl17 (n20 \2\:n20) resistor r=126.898 c=0
Rl19 (\2\:n20 \4\:n20) resistor r=38.4366 c=0
Rl18 (\2\:n20 \3\:n20) resistor r=39.317 c=0
Rl12 (mout \2\:mout) resistor r=37.3411 c=0
Rl14 (\2\:mout \4\:mout) resistor r=121.957 c=0
Rl13 (\2\:mout \3\:mout) resistor r=0.6051 c=0
Rl30 (\4\:n30 n30) resistor r=85.0055 c=0
Rl31 (\4\:n30 \5\:n30) resistor r=35.772 c=0
Rl33 (\4\:n30 \7\:n30) resistor r=100.426 c=0
Rl65 (\20\:qbint \21\:qbint) resistor r=55.0021 c=0
Rl64 (\20\:qbint \19\:qbint) resistor r=36.7742 c=0
Rl24 (\2\:qbint qbint) resistor r=119.231 c=0
Rl25 (\2\:qbint \3\:qbint) resistor r=26.3736 c=0
Rz22 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz24 (\3\:VDD \1\:VDD) resistor r=5.7692 c=0
Rz25 (\12\:VDD \1\:VDD) resistor r=12.5 c=0
Rz26 (\15\:VDD \1\:VDD) resistor r=18.75 c=0
Rz27 (\17\:VDD \1\:VDD) resistor r=25 c=0
Rz17 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz18 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz19 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz20 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz21 (\32\:VSS \31\:VSS) resistor r=75 c=0
Rz4 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz1 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz2 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz3 (\5\:mout \6\:mout) resistor r=75 c=0
Rz5 (\13\:n30 \12\:n30) resistor r=75 c=0
Rz10 (\33\:qbint \32\:qbint) resistor r=75 c=0
Rz11 (\20\:qint \19\:qint) resistor r=75 c=0
Ry19 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry25 (\31\:VDD \30\:VDD) resistor r=31 c=0
Ry27 (\35\:VDD \34\:VDD) resistor r=62 c=0
Ry28 (\37\:VDD \36\:VDD) resistor r=62 c=0
Ry29 (\39\:VDD \38\:VDD) resistor r=62 c=0
Ry18 (VSS \3\:VSS) resistor r=62 c=0
Ry15 (\1\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry16 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry17 (\11\:VSS \3\:VSS) resistor r=7.75 c=0
Ry6 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry1 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry4 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry5 (\9\:mout \10\:mout) resistor r=62 c=0
Ry7 (\11\:n30 \10\:n30) resistor r=62 c=0
Ry14 (\17\:qint \16\:qint) resistor r=20.6667 c=0
Ry2 (n26 \2\:n26) resistor r=62 c=0
Ry3 (\3\:n26 \4\:n26) resistor r=62 c=0
Rx15 (\13\:RN \2\:RN) resistor r=45 c=0
Rx2 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx8 (\10\:CKb \11\:CKb) resistor r=45 c=0
Rx9 (\8\:CKb \12\:CKb) resistor r=45 c=0
Rx10 (\6\:CKb \13\:CKb) resistor r=45 c=0
Rx11 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx3 (\7\:CKbb \8\:CKbb) resistor r=45 c=0
Rx4 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx5 (\2\:CKbb \14\:CKbb) resistor r=45 c=0
Rx6 (\3\:n20 \5\:n20) resistor r=45 c=0
Rx7 (\3\:mout \8\:mout) resistor r=45 c=0
Rx12 (\8\:n30 n30) resistor r=45 c=0
Rx16 (\22\:qbint \4\:qbint) resistor r=45 c=0
Rx17 (\25\:qbint \2\:qbint) resistor r=45 c=0
Rx18 (\30\:qbint \20\:qbint) resistor r=45 c=0
Rx19 (\34\:qbint \4\:qbint) resistor r=45 c=0
Rx20 (\21\:qint qint) resistor r=45 c=0
mn20 (\17\:CKb \3\:CK \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.52e-14 ad=2.03e-14 ps=1.34e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn21 (\12\:CKbb \3\:CKb \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn25 (n21 \1\:D \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=8.7e-15 ps=6.3e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.70414e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn26 (\9\:n20 \4\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.62448e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn30 (\5\:mout \4\:n20 \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.843e-14 ad=2.755e-14 ps=8.2e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=1.05552e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn37 (\9\:n20 \3\:CKbb n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.233e-14 ad=2.32e-14 ps=4.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.46897e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn36 (n25 \4\:mout n27 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=1.233e-14 ps=4.1e-07 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.37034e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn35 (n27 \3\:RN \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.843e-14 ad=8.7e-15 ps=8.2e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.29069e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn40 (\12\:n30 \6\:CKbb \5\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.755e-14 ad=3.118e-14 ps=6.7e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26e-06 sb=8.77241e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn51 (\12\:n30 \9\:CKb n40 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.668e-14 ad=3.118e-14 ps=5.2e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52e-06 sb=6.8e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn50 (n40 qbint \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.083e-14 ad=1.668e-14 ps=1.45e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.68e-06 sb=5.58621e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn45_1__rcx (22 \4\:RN \23\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.083e-14 ad=1.743e-14 ps=1.45e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.78049e-07 sb=1.08463e-06 sd=160n sca=7.89176 \
        scb=0.00548188 scc=8.67374e-05 m=(1)
mn46_1__rcx (\32\:qbint \7\:n30 22 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=1.743e-14 ad=3.28e-14 ps=5.8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9439e-07 sb=9.99024e-07 sd=160n sca=7.89176 \
        scb=0.00548188 scc=8.67374e-05 m=(1)
mn46 (\32\:qbint \5\:n30 23 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.28e-14 ps=5.3e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6439e-07 sb=8.64024e-07 sd=160n sca=7.89176 \
        scb=0.00548188 scc=8.67374e-05 m=(1)
mn45 (23 \9\:RN \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.955e-14 ad=1.23e-14 ps=1.6e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.51463e-07 sb=7.94878e-07 sd=160n sca=7.89176 \
        scb=0.00548188 scc=8.67374e-05 m=(1)
mn55_1__rcx (\4\:Q \4\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=9.159e-14 ad=4.16e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.60769e-07 sb=1.965e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn57_1__rcx (\1\:QN qint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.268e-14 ad=4.16e-14 ps=1.4425e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27423e-06 sb=1.025e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn56 (\19\:qint \19\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.85e-14 ad=3.64e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.94519e-06 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mp21 (\15\:CKbb CKb \38\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.553e-14 ad=2.63e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=6.63488e-07 sd=160n sca=16.9238 \
        scb=0.0162651 scc=0.000960412 m=(1)
mp25 (n22 \4\:D \38\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.553e-14 ad=1.29e-14 ps=1.7e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.42326e-07 sb=4.43488e-07 sd=160n sca=15.9472 \
        scb=0.0155426 scc=0.000959336 m=(1)
mp26 (\7\:n20 CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.47326e-07 sb=3.38488e-07 sd=160n sca=15.6925 \
        scb=0.0154666 scc=0.00095932 m=(1)
mp37 (\7\:n20 \5\:CKb \3\:n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.52326e-07 sb=1.33488e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp36 (n26 mout \36\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.085e-14 ad=3.762e-14 ps=1.58e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2e-06 sd=160n sca=16.037 scb=0.0158964 \
        scc=0.00103899 m=(1)
mp35 (n26 \1\:RN \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.04e-14 ad=3.762e-14 ps=1.66e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.2e-07 sb=2e-06 sd=160n sca=16.037 scb=0.0158964 \
        scc=0.00103899 m=(1)
mp30 (\9\:mout n20 \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.04e-14 ad=3.762e-14 ps=1.66e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.15e-07 sb=2e-06 sd=160n sca=16.037 scb=0.0158964 \
        scc=0.00103899 m=(1)
mp40 (\10\:n30 \7\:CKb \9\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=2e-06 sd=160n sca=16.037 scb=0.0158964 \
        scc=0.00103899 m=(1)
mp51 (\10\:n30 \5\:CKbb n41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.365e-14 ad=3.44e-14 ps=6.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=2e-06 sd=160n sca=16.037 scb=0.0158964 \
        scc=0.00103899 m=(1)
mp50 (n41 \3\:qbint \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.787e-14 ad=2.365e-14 ps=1.07e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.095e-06 sb=2e-06 sd=160n sca=16.037 scb=0.0158964 \
        scc=0.00103899 m=(1)
mp45 (\23\:qbint \5\:RN \3\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.774e-14 ad=4.96e-14 ps=1.085e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.77339e-07 sb=2e-06 sd=160n sca=14.1869 \
        scb=0.0131869 scc=0.000739194 m=(2)
mp46_1__rcx (\23\:qbint n30 \30\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.96e-14 ad=4.96e-14 ps=9.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.18234e-06 sb=2e-06 sd=160n sca=14.1869 \
        scb=0.0131869 scc=0.000739194 m=(2)
mp55_1__rcx (\1\:Q \4\:qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.315e-14 ad=6.63e-14 ps=1.11e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.34718e-06 sb=1.82e-06 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(4)
mp57_1__rcx (\5\:QN qint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.435e-14 ad=6.24e-14 ps=1.11e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.73308e-06 sb=9.6e-07 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(4)
mp56 (\16\:qint \21\:qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.95487e-06 sb=1.4e-07 sd=160n sca=26.0565 \
        scb=0.024857 scc=0.00213457 m=(1)
ends DFFRX4
// End of subcircuit definition.

// Generated for: spectre (May  8 15:09:25 2012 )
// Library name: gsclib045
// Cell name: DFFSHQX1
// View name: extracted

simulator lang=spectre

subckt DFFSHQX1 CK D Q SN VDD VSS
mp55 (\1\:Q \4\:qbint \21\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=44.1638 \
        scb=0.0392167 scc=0.00476734 m=(1)
C1 (SN VSS) capacitor c=1.78865e-16
C2 (CK VSS) capacitor c=3.36381e-17
C3 (VDD VSS) capacitor c=2.65602e-16
C4 (D VSS) capacitor c=6.98427e-17
C5 (qbint VSS) capacitor c=9.38395e-18
C6 (n35 VSS) capacitor c=2.32505e-17
C7 (n40 VSS) capacitor c=5.19831e-18
C8 (CKb VSS) capacitor c=3.84804e-17
C9 (mout VSS) capacitor c=4.74914e-17
C10 (CKbb VSS) capacitor c=5.23064e-17
C11 (n25 VSS) capacitor c=6.01809e-20
C12 (n20 VSS) capacitor c=3.75535e-17
C13 (n30 VSS) capacitor c=1.58851e-18
C14 (n41 VSS) capacitor c=6.55348e-17
C15 (n31 VSS) capacitor c=1.20402e-18
C16 (n22 VSS) capacitor c=3.29151e-18
C17 (\3\:CK VSS) capacitor c=5.03337e-17
C18 (\3\:D VSS) capacitor c=7.64536e-17
C19 (\5\:CKbb VSS) capacitor c=9.30758e-17
C20 (\10\:CKb VSS) capacitor c=7.25894e-17
C21 (\3\:mout VSS) capacitor c=8.15035e-17
C22 (\4\:SN VSS) capacitor c=5.6784e-17
C23 (\7\:CKb VSS) capacitor c=1.18194e-17
C24 (\9\:CKb VSS) capacitor c=2.73519e-17
C25 (\3\:CKbb VSS) capacitor c=6.31702e-17
C26 (\5\:qbint VSS) capacitor c=5.92819e-17
C27 (\1\:SN VSS) capacitor c=5.44405e-17
C28 (\4\:n35 VSS) capacitor c=3.77059e-17
C29 (\4\:qbint VSS) capacitor c=3.35173e-17
C30 (\1\:CK VSS) capacitor c=3.94485e-17
C31 (\1\:D VSS) capacitor c=5.95611e-17
C32 (\12\:CKb VSS) capacitor c=3.79479e-17
C33 (\7\:CKbb VSS) capacitor c=4.53421e-17
C34 (\3\:n20 VSS) capacitor c=8.27449e-17
C35 (\7\:SN VSS) capacitor c=5.7165e-17
C36 (\3\:CKb VSS) capacitor c=6.08969e-17
C37 (\4\:CKbb VSS) capacitor c=2.68497e-17
C38 (\7\:qbint VSS) capacitor c=3.07748e-17
C39 (\3\:SN VSS) capacitor c=5.17406e-17
C40 (\3\:n35 VSS) capacitor c=4.76681e-17
C41 (\3\:qbint VSS) capacitor c=2.85593e-17
C42 (\2\:CK VSS) capacitor c=4.83956e-17
C43 (\2\:D VSS) capacitor c=6.47454e-17
C44 (\13\:CKb VSS) capacitor c=4.17566e-17
C45 (\6\:CKbb VSS) capacitor c=8.05793e-17
C46 (\11\:CKb VSS) capacitor c=3.09971e-17
C47 (\2\:mout VSS) capacitor c=5.67819e-17
C48 (\2\:n20 VSS) capacitor c=4.1437e-17
C49 (\6\:SN VSS) capacitor c=6.38229e-17
C50 (\8\:CKb VSS) capacitor c=1.69174e-17
C51 (\6\:CKb VSS) capacitor c=5.25368e-17
C52 (\2\:CKb VSS) capacitor c=4.22022e-17
C53 (\6\:qbint VSS) capacitor c=5.2331e-17
C54 (\2\:SN VSS) capacitor c=6.17624e-17
C55 (\22\:CKb VSS) capacitor c=4.71533e-17
C56 (\11\:VDD VSS) capacitor c=3.70894e-17
C57 (\4\:n20 VSS) capacitor c=6.86998e-17
C58 (\13\:VDD VSS) capacitor c=7.13283e-17
C59 (\6\:mout VSS) capacitor c=1.15971e-16
C60 (\15\:VDD VSS) capacitor c=2.83595e-17
C61 (\13\:CKbb VSS) capacitor c=3.91066e-17
C62 (\8\:mout VSS) capacitor c=1.29822e-16
C63 (\5\:n35 VSS) capacitor c=6.77047e-17
C64 (\17\:VDD VSS) capacitor c=3.10692e-17
C65 (\3\:n41 VSS) capacitor c=6.59811e-17
C66 (\19\:VDD VSS) capacitor c=2.4714e-17
C67 (\12\:qbint VSS) capacitor c=7.68142e-17
C68 (\21\:VDD VSS) capacitor c=8.98668e-17
C69 (\1\:Q VSS) capacitor c=4.66604e-17
C70 (\1\:VDD VSS) capacitor c=6.59796e-17
C71 (\16\:CKb VSS) capacitor c=7.01381e-17
C72 (\8\:n20 VSS) capacitor c=7.44321e-17
C73 (\10\:mout VSS) capacitor c=4.91836e-17
C74 (\11\:CKbb VSS) capacitor c=4.72426e-17
C75 (\12\:mout VSS) capacitor c=1.06026e-16
C76 (\9\:n35 VSS) capacitor c=9.34095e-17
C77 (\14\:qbint VSS) capacitor c=1.99278e-17
C78 (\3\:Q VSS) capacitor c=4.68291e-17
C79 (\2\:qbint VSS) capacitor c=8.98461e-18
C80 (\2\:n35 VSS) capacitor c=2.73657e-17
C81 (\2\:CKbb VSS) capacitor c=5.71017e-17
C82 (\4\:CKb VSS) capacitor c=5.14931e-17
C83 (\8\:qbint VSS) capacitor c=5.98074e-17
C84 (\10\:qbint VSS) capacitor c=6.39089e-17
C85 (\11\:qbint VSS) capacitor c=4.361e-17
C86 (\7\:n35 VSS) capacitor c=1.55462e-16
C87 (\8\:n35 VSS) capacitor c=7.28657e-17
C88 (\14\:CKb VSS) capacitor c=4.82581e-17
C89 (\15\:CKb VSS) capacitor c=5.26565e-17
C90 (\8\:SN VSS) capacitor c=9.04793e-17
C91 (\9\:SN VSS) capacitor c=2.08647e-16
C92 (\4\:mout VSS) capacitor c=5.92192e-17
C93 (\5\:mout VSS) capacitor c=8.292e-17
C94 (\8\:CKbb VSS) capacitor c=2.07757e-16
C95 (\9\:CKbb VSS) capacitor c=1.84586e-16
C96 (\10\:CKbb VSS) capacitor c=4.36579e-17
C97 (\6\:n20 VSS) capacitor c=9.72672e-17
C98 (\7\:n20 VSS) capacitor c=7.75666e-17
C99 (\4\:D VSS) capacitor c=4.953e-17
C100 (\18\:CKb VSS) capacitor c=1.34301e-16
C101 (\19\:CKb VSS) capacitor c=1.25201e-16
C102 (\20\:CKb VSS) capacitor c=1.69476e-16
C103 (\21\:CKb VSS) capacitor c=1.701e-16
C104 (\5\:CK VSS) capacitor c=4.56708e-17
C105 (\3\:VDD VSS) capacitor c=1.76693e-17
C106 (\5\:VDD VSS) capacitor c=1.36497e-17
C107 (\6\:VDD VSS) capacitor c=3.71924e-17
C108 (\8\:VDD VSS) capacitor c=9.08073e-18
C109 (\9\:VDD VSS) capacitor c=1.93293e-17
C110 (\10\:VDD VSS) capacitor c=1.28699e-17
Rk13 (\8\:SN SN) resistor r=0.498 c=0
Rk14 (SN \9\:SN) resistor r=1.2561 c=0
Rk1 (\2\:Q Q) resistor r=0.3426 c=0
Rk2 (Q \4\:Q) resistor r=0.07302 c=0
Rk33 (\4\:CK \5\:CK) resistor r=0.003253 c=0
Rk34 (\6\:CK CK) resistor r=0.003253 c=0
Rk35 (\5\:CK \6\:CK) resistor r=0.03891 c=0
Rk47 (\2\:VDD \3\:VDD) resistor r=0.08013 c=0
Rk48 (\3\:VDD \4\:VDD) resistor r=0.2709 c=0
Rk49 (\4\:VDD \5\:VDD) resistor r=0.08767 c=0
Rk50 (\5\:VDD \6\:VDD) resistor r=0.2472 c=0
Rk51 (\6\:VDD \7\:VDD) resistor r=0.516 c=0
Rk52 (\7\:VDD \8\:VDD) resistor r=0.05252 c=0
Rk53 (\8\:VDD \9\:VDD) resistor r=0.1904 c=0
Rk55 (\10\:VDD VDD) resistor r=0.1025 c=0
Rk54 (\9\:VDD \10\:VDD) resistor r=0.2055 c=0
Rk56 (\3\:VDD \12\:VDD) resistor r=0.1881 c=0
Rk57 (\5\:VDD \14\:VDD) resistor r=0.3238 c=0
Rk58 (\6\:VDD \16\:VDD) resistor r=0.04337 c=0
Rk59 (\8\:VDD \18\:VDD) resistor r=0.1709 c=0
Rk60 (\9\:VDD \20\:VDD) resistor r=0.1802 c=0
Rk61 (\10\:VDD \22\:VDD) resistor r=0.4292 c=0
Rk27 (D \4\:D) resistor r=0.1626 c=0
Rk36 (\2\:VSS \4\:VSS) resistor r=0.5527 c=0
Rk37 (\4\:VSS \5\:VSS) resistor r=0.1379 c=0
Rk38 (\5\:VSS \6\:VSS) resistor r=0.2783 c=0
Rk39 (\6\:VSS \7\:VSS) resistor r=0.537 c=0
Rk40 (\7\:VSS \8\:VSS) resistor r=0.1931 c=0
Rk42 (\9\:VSS VSS) resistor r=0.1025 c=0
Rk41 (\8\:VSS \9\:VSS) resistor r=0.2055 c=0
Rk43 (\5\:VSS \11\:VSS) resistor r=0.2566 c=0
Rk44 (\6\:VSS \13\:VSS) resistor r=0.4058 c=0
Rk45 (\8\:VSS \15\:VSS) resistor r=0.3207 c=0
Rk46 (\9\:VSS \17\:VSS) resistor r=0.2903 c=0
Rk3 (\8\:qbint \9\:qbint) resistor r=0.3023 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.05768 c=0
Rk5 (\10\:qbint \11\:qbint) resistor r=0.1493 c=0
Rk6 (\9\:qbint \13\:qbint) resistor r=0.3856 c=0
Rk7 (\10\:qbint \15\:qbint) resistor r=0.1097 c=0
Rk9 (\6\:n35 \7\:n35) resistor r=0.3755 c=0
Rk10 (\7\:n35 \8\:n35) resistor r=0.4153 c=0
Rk11 (\7\:n35 \10\:n35) resistor r=0.5658 c=0
Rk12 (\14\:CKb \15\:CKb) resistor r=0.1673 c=0
Rk28 (\17\:CKb \18\:CKb) resistor r=0.4323 c=0
Rk29 (\18\:CKb \19\:CKb) resistor r=0.5473 c=0
Rk30 (\19\:CKb \20\:CKb) resistor r=0.2921 c=0
Rk31 (\20\:CKb \21\:CKb) resistor r=1.1824 c=0
Rk32 (\19\:CKb \23\:CKb) resistor r=0.3103 c=0
Rk15 (\4\:mout \5\:mout) resistor r=0.2393 c=0
Rk16 (\5\:mout \7\:mout) resistor r=0.3379 c=0
Rk17 (\7\:mout \9\:mout) resistor r=0.5883 c=0
Rk18 (\5\:mout \11\:mout) resistor r=0.1435 c=0
Rk19 (\9\:mout \13\:mout) resistor r=0.5175 c=0
Rk20 (\8\:CKbb \9\:CKbb) resistor r=1.3804 c=0
Rk21 (\9\:CKbb \10\:CKbb) resistor r=0.2044 c=0
Rk22 (\10\:CKbb \12\:CKbb) resistor r=0.1744 c=0
Rk23 (\9\:CKbb \14\:CKbb) resistor r=0.09496 c=0
Rk24 (\5\:n20 \6\:n20) resistor r=0.2947 c=0
Rk25 (\6\:n20 \7\:n20) resistor r=0.3545 c=0
Rk26 (\6\:n20 \9\:n20) resistor r=0.3638 c=0
Rk8 (\2\:n41 \4\:n41) resistor r=0.334 c=0
Rl7 (\1\:SN \2\:SN) resistor r=72.2519 c=0
Rl8 (\2\:SN \3\:SN) resistor r=95.3288 c=0
Rl21 (\4\:SN \5\:SN) resistor r=114.664 c=0
Rl23 (\5\:SN \7\:SN) resistor r=42.0218 c=0
Rl22 (\5\:SN \6\:SN) resistor r=0.5166 c=0
Rl35 (\2\:CK \3\:CK) resistor r=143.406 c=0
Rl34 (\1\:CK \2\:CK) resistor r=89.5596 c=0
Rl33 (\2\:D \3\:D) resistor r=106.868 c=0
Rl32 (\1\:D \2\:D) resistor r=98.0769 c=0
Rl9 (\5\:qbint \6\:qbint) resistor r=164.05 c=0
Rl10 (\6\:qbint \7\:qbint) resistor r=28.1859 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2334 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=45.0334 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=37.3411 c=0
Rl4 (n35 \2\:n35) resistor r=0.5213 c=0
Rl6 (\2\:n35 \4\:n35) resistor r=34.3295 c=0
Rl5 (\2\:n35 \3\:n35) resistor r=157.406 c=0
Rl31 (\12\:CKb \13\:CKb) resistor r=26.7711 c=0
Rl28 (\10\:CKb \11\:CKb) resistor r=29.5379 c=0
Rl19 (\7\:CKb \8\:CKb) resistor r=52.6149 c=0
Rl11 (CKb \2\:CKb) resistor r=83.3841 c=0
Rl18 (\4\:CKb \7\:CKb) resistor r=47.4088 c=0
Rl15 (\3\:CKb \4\:CKb) resistor r=105.451 c=0
Rl20 (\5\:CKb \9\:CKb) resistor r=34.9258 c=0
Rl17 (\5\:CKb \6\:CKb) resistor r=10.3565 c=0
Rl16 (\4\:CKb \5\:CKb) resistor r=144.422 c=0
Rl26 (mout \2\:mout) resistor r=59.6868 c=0
Rl27 (\2\:mout \3\:mout) resistor r=98.3706 c=0
Rl29 (\5\:CKbb \6\:CKbb) resistor r=227.587 c=0
Rl30 (\6\:CKbb \7\:CKbb) resistor r=26.098 c=0
Rl12 (CKbb \2\:CKbb) resistor r=135.005 c=0
Rl13 (\2\:CKbb \3\:CKbb) resistor r=126.901 c=0
Rl14 (\2\:CKbb \4\:CKbb) resistor r=30.4507 c=0
Rl24 (n20 \2\:n20) resistor r=35.7713 c=0
Rl25 (\2\:n20 \3\:n20) resistor r=153.871 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz14 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz15 (\1\:VDD \4\:VDD) resistor r=15 c=0
Rz16 (\1\:VDD \7\:VDD) resistor r=6.25 c=0
Rz9 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz10 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz11 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz12 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz13 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz2 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz3 (\9\:n35 \10\:n35) resistor r=75 c=0
Rz8 (\16\:CKb \17\:CKb) resistor r=75 c=0
Rz4 (\10\:mout \11\:mout) resistor r=75 c=0
Rz5 (\12\:mout \13\:mout) resistor r=75 c=0
Rz6 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz7 (\8\:n20 \9\:n20) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry13 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry14 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry15 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry16 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry17 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry18 (\21\:VDD \22\:VDD) resistor r=20.6667 c=0
Ry11 (\3\:VSS \4\:VSS) resistor r=7.75 c=0
Ry12 (\3\:VSS \7\:VSS) resistor r=5.6364 c=0
Ry2 (\12\:qbint \13\:qbint) resistor r=31 c=0
Ry5 (\5\:n35 \6\:n35) resistor r=31 c=0
Ry10 (\22\:CKb \23\:CKb) resistor r=62 c=0
Ry6 (\6\:mout \7\:mout) resistor r=31 c=0
Ry7 (\8\:mout \9\:mout) resistor r=31 c=0
Ry8 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry9 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry3 (n41 \2\:n41) resistor r=62 c=0
Ry4 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx6 (\2\:SN \8\:SN) resistor r=45 c=0
Rx7 (\6\:SN \9\:SN) resistor r=45 c=0
Rx16 (\2\:CK \4\:CK) resistor r=45 c=0
Rx12 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\6\:qbint \8\:qbint) resistor r=45 c=0
Rx2 (qbint \11\:qbint) resistor r=45 c=0
Rx3 (n35 \8\:n35) resistor r=45 c=0
Rx4 (\6\:CKb \14\:CKb) resistor r=45 c=0
Rx5 (\2\:CKb \15\:CKb) resistor r=45 c=0
Rx13 (\13\:CKb \18\:CKb) resistor r=45 c=0
Rx14 (\11\:CKb \20\:CKb) resistor r=45 c=0
Rx15 (\8\:CKb \21\:CKb) resistor r=45 c=0
Rx8 (\2\:mout \4\:mout) resistor r=45 c=0
Rx9 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx10 (CKbb \10\:CKbb) resistor r=45 c=0
Rx11 (\2\:n20 \7\:n20) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn45 (\14\:qbint \3\:n35 \14\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.28e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.065e-06 sd=160n sca=18.43 \
        scb=0.0187068 scc=0.00173343 m=(1)
mn50 (n42 \3\:SN \14\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.767e-14 ps=7.3e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.6e-07 sd=160n sca=18.43 scb=0.0187068 \
        scc=0.00173343 m=(1)
mn51 (n40 \7\:qbint n42 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.767e-14 ad=5.432e-14 ps=6.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=6.8e-07 sd=160n sca=18.43 scb=0.0187068 \
        scc=0.00173343 m=(1)
mn52 (\9\:n35 CKb n40 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.432e-14 ad=3.792e-14 ps=9.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=3.7e-07 sd=160n sca=18.43 scb=0.0187068 \
        scc=0.00173343 m=(1)
mn40 (\9\:n35 \4\:CKbb \12\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.87e-14 ad=3.792e-14 ps=6.9e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=1.4e-07 sd=160n sca=18.43 \
        scb=0.0187068 scc=0.00173343 m=(1)
mn21 (\11\:CKbb \3\:CKb \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.92e-14 ad=2.537e-14 ps=7.3e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=4.5e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn30 (n25 \7\:SN \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=1.23e-14 ps=7.3e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.98049e-07 sb=2.45e-07 sd=160n sca=17.1738 \
        scb=0.0176382 scc=0.00148475 m=(1)
mn31 (\10\:mout \3\:n20 n25 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.87e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.03049e-07 sb=1.4e-07 sd=160n sca=17.1738 \
        scb=0.0176382 scc=0.00148475 m=(1)
mn36 (n30 mout \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=1.537e-14 ps=6.9e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.08293e-07 sd=160n sca=11.015 \
        scb=0.0105032 scc=0.000405626 m=(1)
mn35 (\8\:n20 \7\:CKbb n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.537e-14 ad=3.895e-14 ps=5.6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.6e-07 sb=6.88293e-07 sd=160n sca=11.015 \
        scb=0.0105032 scc=0.000405626 m=(1)
mn26 (\8\:n20 \12\:CKb n21 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.767e-14 ad=3.895e-14 ps=6.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=4.53293e-07 sd=160n sca=11.015 \
        scb=0.0105032 scc=0.000405626 m=(1)
mn25 (n21 \1\:D \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.767e-14 ps=7.3e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=2.73293e-07 sd=160n sca=11.015 \
        scb=0.0105032 scc=0.000405626 m=(1)
mn20 (\16\:CKb \1\:CK \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mp45 (\12\:qbint \4\:n35 \19\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.96e-14 ad=4.495e-14 ps=9.4e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=5.5e-07 sd=160n sca=11.8286 \
        scb=0.00894943 scc=0.000118237 m=(1)
mp50 (\3\:n41 \1\:SN \19\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.96e-14 ps=9.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=3.45e-07 sd=160n sca=10.9145 \
        scb=0.00827379 scc=0.000117261 m=(1)
mp51 (\3\:n41 \5\:qbint \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.4e-07 sd=160n sca=10.5719 \
        scb=0.0081746 scc=0.000117241 m=(1)
mp52 (\5\:n35 \3\:CKbb n41 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.6e-07 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp40 (\5\:n35 \9\:CKb \8\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=4.96e-14 ps=9.3e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.55e-07 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp21 (\13\:CKbb \7\:CKb \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.885e-14 ad=3.01e-14 ps=1.65e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.09512e-06 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp30 (\6\:mout \4\:SN \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.885e-14 ad=5.89e-14 ps=1.65e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.32984e-07 sb=9.81935e-07 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp31 (\6\:mout n20 \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.735e-14 ad=5.89e-14 ps=9.9e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.67984e-07 sb=7.46935e-07 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp35 (n31 \3\:mout \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.735e-14 ad=1.86e-14 ps=9.9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.97984e-07 sb=5.16935e-07 sd=160n sca=13.8954 \
        scb=0.0128564 scc=0.000682952 m=(1)
mp36 (\4\:n20 \10\:CKb n31 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=6.83e-14 ps=7.4e-07 pd=1.35e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.02984e-07 sb=4.11935e-07 sd=160n sca=14.1016 \
        scb=0.0129066 scc=0.000682959 m=(1)
mp26 (\4\:n20 \5\:CKbb n22 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=2.48e-14 ad=6.83e-14 ps=7.8e-07 pd=1.35e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.98629e-07 sb=4.19194e-07 sd=160n sca=12.0319 \
        scb=0.00919051 scc=0.000122797 m=(1)
mp25 (n22 \3\:D \11\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.143e-14 ad=2.48e-14 ps=1.01e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.23629e-07 sb=2.94194e-07 sd=160n sca=13.3135 \
        scb=0.0110125 scc=0.000136756 m=(1)
mp20 (\22\:CKb \3\:CK \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.143e-14 ad=3.01e-14 ps=1.01e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.28721e-07 sb=1.4e-07 sd=160n sca=21.8965 \
        scb=0.0242941 scc=0.00109947 m=(1)
ends DFFSHQX1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:10:13 2012 )
// Library name: gsclib045
// Cell name: LSLHX1_TO
// View name: extracted

simulator lang=spectre

subckt LSLHX1_TO A ExtVDD VDD VSS Y
PM2 (\7\:Ab \9\:A \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=21.5924 \
        scb=0.0250741 scc=0.000917806 m=(1)
C1 (VDD VSS) capacitor c=2.75077e-16
C2 (A VSS) capacitor c=2.33738e-17
C3 (ExtVDD VSS) capacitor c=1.3359e-16
C4 (Y VSS) capacitor c=1.73213e-17
C5 (Yint VSS) capacitor c=3.4504e-17
C6 (Ab VSS) capacitor c=1.20532e-16
C7 (Ybint VSS) capacitor c=2.66646e-17
C8 (\6\:Ybint VSS) capacitor c=4.47167e-17
C9 (\4\:Yint VSS) capacitor c=2.69826e-17
C10 (\9\:A VSS) capacitor c=5.76563e-17
C11 (\3\:Ybint VSS) capacitor c=2.72431e-17
C12 (\1\:A VSS) capacitor c=1.75066e-16
C13 (\10\:A VSS) capacitor c=2.5225e-17
C14 (\5\:Ybint VSS) capacitor c=6.04079e-18
C15 (\2\:Ybint VSS) capacitor c=2.84409e-17
C16 (\3\:Yint VSS) capacitor c=2.35231e-17
C17 (\4\:Ab VSS) capacitor c=3.71322e-17
C18 (\6\:A VSS) capacitor c=2.16626e-17
C19 (\2\:Y VSS) capacitor c=5.27718e-17
C20 (\1\:VDD VSS) capacitor c=6.57215e-17
C21 (\7\:VDD VSS) capacitor c=3.45683e-17
C22 (\11\:Yint VSS) capacitor c=6.48165e-17
C23 (\15\:Ybint VSS) capacitor c=8.70394e-17
C24 (\9\:VDD VSS) capacitor c=4.96336e-17
C25 (\7\:Ab VSS) capacitor c=9.92812e-17
C26 (\3\:ExtVDD VSS) capacitor c=3.57642e-17
C27 (\4\:Y VSS) capacitor c=4.34756e-17
C28 (\5\:Yint VSS) capacitor c=1.85011e-16
C29 (\10\:Ab VSS) capacitor c=5.8041e-17
C30 (VDD VSS) capacitor c=1.82136e-17
C31 (\2\:Yint VSS) capacitor c=1.86945e-17
C32 (\4\:A VSS) capacitor c=1.56928e-16
C33 (\5\:A VSS) capacitor c=2.60346e-17
C34 (\4\:Ybint VSS) capacitor c=2.17322e-17
C35 (\11\:A VSS) capacitor c=2.28497e-17
C36 (\9\:Ab VSS) capacitor c=1.18464e-16
C37 (\8\:Yint VSS) capacitor c=4.55377e-17
C38 (\13\:Yint VSS) capacitor c=5.34851e-17
C39 (\7\:Ybint VSS) capacitor c=4.41956e-17
C40 (\8\:Ybint VSS) capacitor c=1.73489e-16
C41 (\10\:Ybint VSS) capacitor c=8.54832e-17
C42 (\1\:Y VSS) capacitor c=4.07916e-17
C43 (\4\:VDD VSS) capacitor c=2.1595e-18
C44 (\5\:VDD VSS) capacitor c=1.41911e-17
C45 (\6\:VDD VSS) capacitor c=2.26207e-17
Rk35 (\2\:VDD \4\:VDD) resistor r=0.4954 c=0
Rk37 (\5\:VDD VDD) resistor r=0.2917 c=0
Rk36 (\4\:VDD \5\:VDD) resistor r=0.124 c=0
Rk39 (\6\:VDD VDD) resistor r=0.3111 c=0
Rk38 (VDD \6\:VDD) resistor r=0.1364 c=0
Rk40 (\5\:VDD \8\:VDD) resistor r=0.2768 c=0
Rk41 (\6\:VDD \10\:VDD) resistor r=0.2768 c=0
Rk28 (VSS VSS) resistor r=0.3623 c=0
Rk20 (\2\:VSS \3\:VSS) resistor r=0.09718 c=0
Rk22 (\4\:VSS VSS) resistor r=0.1459 c=0
Rk21 (\3\:VSS \4\:VSS) resistor r=0.1459 c=0
Rk29 (VSS \10\:VSS) resistor r=0.01728 c=0
Rk30 (\10\:VSS \12\:VSS) resistor r=0.4559 c=0
Rk31 (\3\:VSS \14\:VSS) resistor r=0.2238 c=0
Rk42 (\22\:VSS VSS) resistor r=0.584 c=0
Rk44 (\23\:VSS VSS) resistor r=0.2164 c=0
Rk43 (VSS \23\:VSS) resistor r=0.2437 c=0
Rk1 (A \11\:A) resistor r=0.01817 c=0
Rk3 (\2\:ExtVDD ExtVDD) resistor r=0.02507 c=0
Rk2 (ExtVDD \2\:ExtVDD) resistor r=0.01693 c=0
Rk4 (ExtVDD \4\:ExtVDD) resistor r=0.3343 c=0
Rk17 (Y \1\:Y) resistor r=0.02619 c=0
Rk18 (\1\:Y \3\:Y) resistor r=0.2878 c=0
Rk19 (\1\:Y \5\:Y) resistor r=0.339 c=0
Rk8 (\5\:Yint \8\:Yint) resistor r=0.2601 c=0
Rk10 (\12\:Yint \13\:Yint) resistor r=0.2927 c=0
Rk5 (\8\:Ab \9\:Ab) resistor r=0.8843 c=0
Rk6 (\9\:Ab \11\:Ab) resistor r=0.5142 c=0
Rk11 (\7\:Ybint \8\:Ybint) resistor r=0.2868 c=0
Rk13 (\8\:Ybint \10\:Ybint) resistor r=0.1784 c=0
Rk16 (\10\:Ybint \16\:Ybint) resistor r=0.5894 c=0
Rl17 (\4\:A \9\:A) resistor r=336.831 c=0
Rl12 (\4\:A \1\:A) resistor r=446.755 c=0
Rl18 (\5\:A \10\:A) resistor r=62.4311 c=0
Rl14 (\5\:A \6\:A) resistor r=44.7819 c=0
Rl13 (\5\:A \4\:A) resistor r=240.459 c=0
Rl6 (\2\:Yint Yint) resistor r=105.33 c=0
Rl8 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl7 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl3 (Ab \4\:Ab) resistor r=108.126 c=0
Rl9 (\2\:Ybint Ybint) resistor r=72.3229 c=0
Rl21 (\4\:Ybint \6\:Ybint) resistor r=140.931 c=0
Rl19 (\4\:Ybint \3\:Ybint) resistor r=58.975 c=0
Rl20 (\4\:Ybint \5\:Ybint) resistor r=3.5166 c=0
Rz8 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz9 (\14\:VSS \13\:VSS) resistor r=37.5 c=0
Rz7 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz2 (\11\:Ab \10\:Ab) resistor r=75 c=0
Ry11 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry12 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry13 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry9 (VSS \1\:VSS) resistor r=15.5 c=0
Ry6 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry7 (\4\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry10 (\10\:VSS \1\:VSS) resistor r=7.75 c=0
Ry14 (\22\:VSS \21\:VSS) resistor r=12.4 c=0
Ry15 (\23\:VSS \21\:VSS) resistor r=5.1667 c=0
Ry1 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry5 (\2\:Y \3\:Y) resistor r=20.6667 c=0
Ry3 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry2 (\8\:Ab \7\:Ab) resistor r=62 c=0
Ry4 (\16\:Ybint \15\:Ybint) resistor r=62 c=0
Rx1 (\11\:A \6\:A) resistor r=45 c=0
Rx3 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx4 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\9\:Ab \4\:Ab) resistor r=45 c=0
Rx5 (\7\:Ybint \5\:Ybint) resistor r=45 c=0
Rx6 (\10\:Ybint \2\:Ybint) resistor r=45 c=0
NM2 (\11\:VSS \10\:A \10\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
NM1 (\5\:Yint Ab VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(3)
NM0 (\8\:Ybint \1\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(3)
mn0 (\4\:Y \3\:Ybint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
PM0 (\15\:Ybint \4\:Yint \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.4693 \
        scb=0.0242319 scc=0.00195457 m=(1)
PM1 (\11\:Yint Ybint \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.50531 \
        scb=0.00284023 scc=1.84334e-05 m=(1)
mp0 (\2\:Y \6\:Ybint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.8211 \
        scb=0.0185035 scc=0.000835503 m=(1)
ends LSLHX1_TO
// End of subcircuit definition.

// Generated for: spectre (May  8 15:11:00 2012 )
// Library name: gsclib045
// Cell name: MX2X1
// View name: extracted

simulator lang=spectre

subckt MX2X1 A B S0 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.95e-07 sd=160n sca=23.8245 \
        scb=0.0263954 scc=0.00148173 m=(1)
C1 (S0 VSS) capacitor c=5.03414e-17
C2 (A VSS) capacitor c=4.19903e-17
C3 (Y VSS) capacitor c=5.41874e-17
C4 (VDD VSS) capacitor c=1.27411e-16
C5 (B VSS) capacitor c=4.10649e-17
C6 (S0b VSS) capacitor c=5.91851e-17
C7 (n0 VSS) capacitor c=5.95815e-17
C8 (n5 VSS) capacitor c=1.32841e-18
C9 (n6 VSS) capacitor c=2.03262e-18
C10 (\4\:B VSS) capacitor c=8.26617e-17
C11 (\3\:S0b VSS) capacitor c=5.61232e-17
C12 (\6\:S0 VSS) capacitor c=7.23692e-17
C13 (\1\:A VSS) capacitor c=7.77538e-17
C14 (\1\:S0 VSS) capacitor c=3.35608e-17
C15 (\4\:n0 VSS) capacitor c=3.45138e-17
C16 (\3\:B VSS) capacitor c=7.57168e-17
C17 (\4\:S0 VSS) capacitor c=1.00101e-16
C18 (\3\:A VSS) capacitor c=8.1486e-17
C19 (\3\:S0 VSS) capacitor c=5.84874e-17
C20 (\3\:n0 VSS) capacitor c=2.70933e-17
C21 (\1\:B VSS) capacitor c=3.11238e-17
C22 (\4\:S0b VSS) capacitor c=5.45625e-17
C23 (\2\:S0b VSS) capacitor c=5.97554e-17
C24 (\5\:S0 VSS) capacitor c=1.16203e-16
C25 (\2\:A VSS) capacitor c=9.20297e-17
C26 (\2\:S0 VSS) capacitor c=5.55754e-17
C27 (\1\:Y VSS) capacitor c=7.82357e-17
C28 (\1\:VDD VSS) capacitor c=6.15552e-17
C29 (\9\:n0 VSS) capacitor c=9.6856e-17
C30 (\6\:VDD VSS) capacitor c=4.14264e-17
C31 (\10\:S0b VSS) capacitor c=7.72939e-17
C32 (\3\:Y VSS) capacitor c=3.72244e-17
C33 (\7\:n0 VSS) capacitor c=6.64172e-17
C34 (\8\:S0b VSS) capacitor c=2.0315e-17
C35 (\2\:B VSS) capacitor c=8.07846e-17
C36 (\2\:n0 VSS) capacitor c=2.94215e-17
C37 (\4\:A VSS) capacitor c=3.12278e-17
C38 (\7\:S0 VSS) capacitor c=5.19026e-17
C39 (\8\:S0 VSS) capacitor c=7.1921e-17
C40 (\5\:S0b VSS) capacitor c=8.3814e-17
C41 (\6\:S0b VSS) capacitor c=1.2294e-16
C42 (\7\:S0b VSS) capacitor c=7.82852e-17
C43 (\5\:n0 VSS) capacitor c=3.30365e-17
C44 (\6\:n0 VSS) capacitor c=1.38174e-16
C45 (\5\:B VSS) capacitor c=7.27039e-17
C46 (\4\:VDD VSS) capacitor c=4.04361e-17
C47 (\5\:VDD VSS) capacitor c=9.42726e-18
Rk2 (\7\:S0 S0) resistor r=0.1251 c=0
Rk3 (S0 \8\:S0) resistor r=0.3191 c=0
Rk1 (A \4\:A) resistor r=0.02702 c=0
Rk12 (\2\:Y Y) resistor r=0.6143 c=0
Rk13 (Y \4\:Y) resistor r=0.04477 c=0
Rk14 (\2\:VDD \4\:VDD) resistor r=0.4498 c=0
Rk16 (\5\:VDD VDD) resistor r=0.1029 c=0
Rk15 (\4\:VDD \5\:VDD) resistor r=0.1485 c=0
Rk17 (\5\:VDD \7\:VDD) resistor r=0.2261 c=0
Rk18 (\2\:VSS \4\:VSS) resistor r=0.3444 c=0
Rk20 (\5\:VSS VSS) resistor r=0.1029 c=0
Rk19 (\4\:VSS \5\:VSS) resistor r=0.1485 c=0
Rk21 (\5\:VSS \7\:VSS) resistor r=0.1819 c=0
Rk11 (B \5\:B) resistor r=0.07529 c=0
Rk4 (\5\:S0b \6\:S0b) resistor r=0.4035 c=0
Rk5 (\6\:S0b \7\:S0b) resistor r=0.387 c=0
Rk6 (\7\:S0b \9\:S0b) resistor r=0.1398 c=0
Rk7 (\7\:S0b \11\:S0b) resistor r=0.6367 c=0
Rk8 (\5\:n0 \6\:n0) resistor r=0.1099 c=0
Rk9 (\6\:n0 \8\:n0) resistor r=0.3304 c=0
Rk10 (\6\:n0 \10\:n0) resistor r=0.7659 c=0
Rl8 (\5\:S0 \6\:S0) resistor r=103.079 c=0
Rl7 (\4\:S0 \5\:S0) resistor r=248.616 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=48.7687 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=243 c=0
Rl3 (\1\:A \2\:A) resistor r=121.846 c=0
Rl4 (\2\:A \3\:A) resistor r=169.923 c=0
Rl11 (\2\:B \4\:B) resistor r=157.406 c=0
Rl10 (\2\:B \3\:B) resistor r=151.637 c=0
Rl9 (\1\:B \2\:B) resistor r=6.7128 c=0
Rl6 (\3\:S0b \4\:S0b) resistor r=35.7134 c=0
Rl5 (S0b \2\:S0b) resistor r=89.5596 c=0
Rl12 (n0 \2\:n0) resistor r=163.176 c=0
Rl14 (\2\:n0 \4\:n0) resistor r=34.3295 c=0
Rl13 (\2\:n0 \3\:n0) resistor r=5.9102 c=0
Rz3 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\9\:n0 \10\:n0) resistor r=62 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx7 (\1\:B \5\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx6 (\3\:n0 \5\:n0) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.95e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn1 (n3 \3\:A \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.9e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn2 (\7\:n0 S0b n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.5e-07 sb=6.85e-07 sd=160n sca=6.59604 scb=0.00318587 \
        scc=2.16275e-05 m=(1)
mn4 (\7\:n0 \4\:S0 n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=4.8e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn3 (n5 \3\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=8.7e-15 ps=1.2e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=3.75e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn5 (\3\:Y \4\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=3.64e-14 ps=1.2e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.99135e-07 sb=1.4e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mp1 (n4 \1\:A \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.9e-07 sd=160n sca=13.7907 \
        scb=0.0117228 scc=0.000117112 m=(1)
mp2 (\9\:n0 \6\:S0 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=6.85e-07 sd=160n sca=12.4179 \
        scb=0.00925643 scc=8.16416e-05 m=(1)
mp4 (\9\:n0 \3\:S0b n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=4.8e-07 sd=160n sca=11.7188 \
        scb=0.00807876 scc=7.57808e-05 m=(1)
mp3 (n6 \4\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=1.29e-14 ps=1.59e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=3.75e-07 sd=160n sca=11.9962 \
        scb=0.00852763 scc=7.72908e-05 m=(1)
mp5 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=5.46e-14 ps=1.59e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.93397e-07 sb=1.4e-07 sd=160n sca=18.3406 \
        scb=0.0188689 scc=0.000687762 m=(1)
ends MX2X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:11:47 2012 )
// Library name: gsclib045
// Cell name: MX2XL
// View name: extracted

simulator lang=spectre

subckt MX2XL A B S0 VDD VSS Y
mp0 (\10\:S0b \1\:S0 \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.03e-06 sd=160n sca=24.6667 \
        scb=0.0279468 scc=0.00158007 m=(1)
C1 (Y VSS) capacitor c=5.9833e-17
C2 (S0 VSS) capacitor c=4.22417e-17
C3 (B VSS) capacitor c=4.11387e-17
C4 (VDD VSS) capacitor c=1.37194e-16
C5 (S0b VSS) capacitor c=4.98589e-17
C6 (n0 VSS) capacitor c=2.85034e-17
C7 (n5 VSS) capacitor c=2.31926e-18
C8 (n6 VSS) capacitor c=3.29693e-18
C9 (\4\:B VSS) capacitor c=8.00686e-17
C10 (\3\:S0b VSS) capacitor c=4.32757e-17
C11 (\6\:S0 VSS) capacitor c=5.76235e-17
C12 (\1\:A VSS) capacitor c=7.14246e-17
C13 (\1\:S0 VSS) capacitor c=3.02709e-17
C14 (\4\:n0 VSS) capacitor c=6.16692e-17
C15 (\3\:B VSS) capacitor c=3.56018e-17
C16 (\4\:S0 VSS) capacitor c=6.19987e-17
C17 (\3\:A VSS) capacitor c=5.96314e-17
C18 (\3\:S0 VSS) capacitor c=4.88372e-17
C19 (\3\:n0 VSS) capacitor c=2.6889e-17
C20 (\1\:B VSS) capacitor c=2.7807e-17
C21 (\4\:S0b VSS) capacitor c=4.70346e-17
C22 (\2\:S0b VSS) capacitor c=3.92753e-17
C23 (\5\:S0 VSS) capacitor c=8.72706e-17
C24 (\2\:A VSS) capacitor c=6.89695e-17
C25 (\2\:S0 VSS) capacitor c=4.44761e-17
C26 (\1\:Y VSS) capacitor c=7.24625e-17
C27 (\6\:VDD VSS) capacitor c=3.64852e-17
C28 (\9\:n0 VSS) capacitor c=2.75004e-17
C29 (\8\:VDD VSS) capacitor c=3.8398e-17
C30 (\10\:S0b VSS) capacitor c=7.1918e-17
C31 (\1\:VDD VSS) capacitor c=3.49665e-17
C32 (\3\:Y VSS) capacitor c=1.96508e-17
C33 (\7\:n0 VSS) capacitor c=1.2058e-16
C34 (\8\:S0b VSS) capacitor c=1.93394e-17
C35 (\2\:B VSS) capacitor c=4.36703e-17
C36 (\2\:n0 VSS) capacitor c=2.87131e-17
C37 (\4\:A VSS) capacitor c=4.74817e-17
C38 (\6\:A VSS) capacitor c=4.10748e-17
C39 (\7\:S0 VSS) capacitor c=4.09718e-17
C40 (\8\:S0 VSS) capacitor c=7.11248e-17
C41 (\5\:S0b VSS) capacitor c=9.07773e-17
C42 (\6\:S0b VSS) capacitor c=1.10708e-16
C43 (\7\:S0b VSS) capacitor c=7.54767e-17
C44 (\5\:n0 VSS) capacitor c=4.46278e-17
C45 (\6\:n0 VSS) capacitor c=9.89288e-17
C46 (\5\:B VSS) capacitor c=4.78832e-17
C47 (\3\:VDD VSS) capacitor c=6.79654e-18
C48 (\5\:VDD VSS) capacitor c=3.14805e-18
Rk14 (\2\:Y Y) resistor r=0.5118 c=0
Rk15 (Y \4\:Y) resistor r=0.05349 c=0
Rk4 (\7\:S0 S0) resistor r=0.1314 c=0
Rk5 (S0 \8\:S0) resistor r=0.1615 c=0
Rk1 (\4\:A \5\:A) resistor r=0.01269 c=0
Rk2 (A \6\:A) resistor r=0.01254 c=0
Rk3 (\4\:A \6\:A) resistor r=0.03203 c=0
Rk22 (\2\:VSS \3\:VSS) resistor r=0.1052 c=0
Rk23 (\3\:VSS \4\:VSS) resistor r=0.2458 c=0
Rk25 (\5\:VSS VSS) resistor r=0.1025 c=0
Rk24 (\4\:VSS \5\:VSS) resistor r=0.09771 c=0
Rk26 (\3\:VSS \7\:VSS) resistor r=0.2761 c=0
Rk27 (\5\:VSS \9\:VSS) resistor r=0.278 c=0
Rk13 (B \5\:B) resistor r=0.07283 c=0
Rk16 (\2\:VDD \3\:VDD) resistor r=0.1052 c=0
Rk17 (\3\:VDD \4\:VDD) resistor r=0.2458 c=0
Rk19 (\5\:VDD VDD) resistor r=0.1025 c=0
Rk18 (\4\:VDD \5\:VDD) resistor r=0.09771 c=0
Rk20 (\3\:VDD \7\:VDD) resistor r=0.2679 c=0
Rk21 (\5\:VDD \9\:VDD) resistor r=0.2712 c=0
Rk6 (\5\:S0b \6\:S0b) resistor r=0.3322 c=0
Rk7 (\6\:S0b \7\:S0b) resistor r=0.3175 c=0
Rk8 (\7\:S0b \9\:S0b) resistor r=0.1206 c=0
Rk9 (\7\:S0b \11\:S0b) resistor r=0.5113 c=0
Rk10 (\5\:n0 \6\:n0) resistor r=0.1792 c=0
Rk11 (\6\:n0 \8\:n0) resistor r=0.6176 c=0
Rk12 (\6\:n0 \10\:n0) resistor r=0.2318 c=0
Rl7 (\5\:S0 \6\:S0) resistor r=79.9442 c=0
Rl6 (\4\:S0 \5\:S0) resistor r=169.15 c=0
Rl1 (\1\:S0 \2\:S0) resistor r=26.098 c=0
Rl2 (\2\:S0 \3\:S0) resistor r=176.098 c=0
Rl3 (\1\:A \2\:A) resistor r=129.538 c=0
Rl4 (\2\:A \3\:A) resistor r=79.5379 c=0
Rl11 (\2\:B \4\:B) resistor r=174.714 c=0
Rl10 (\2\:B \3\:B) resistor r=51.6372 c=0
Rl9 (\1\:B \2\:B) resistor r=2.0213 c=0
Rl8 (\3\:S0b \4\:S0b) resistor r=42.9995 c=0
Rl5 (S0b \2\:S0b) resistor r=29.5379 c=0
Rl12 (n0 \2\:n0) resistor r=35.0798 c=0
Rl14 (\2\:n0 \4\:n0) resistor r=190.849 c=0
Rl13 (\2\:n0 \3\:n0) resistor r=0.8823 c=0
Rz3 (\3\:Y \4\:Y) resistor r=75 c=0
Rz6 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz7 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=15 c=0
Rz1 (\8\:S0b \9\:S0b) resistor r=75 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry3 (\1\:Y \2\:Y) resistor r=62 c=0
Ry6 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry7 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry4 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry5 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry1 (\10\:S0b \11\:S0b) resistor r=62 c=0
Ry2 (\9\:n0 \10\:n0) resistor r=62 c=0
Rx2 (\5\:S0 \7\:S0) resistor r=45 c=0
Rx3 (\2\:S0 \8\:S0) resistor r=45 c=0
Rx1 (\2\:A \5\:A) resistor r=45 c=0
Rx7 (\1\:B \5\:B) resistor r=45 c=0
Rx4 (\4\:S0b \5\:S0b) resistor r=45 c=0
Rx5 (\2\:S0b \6\:S0b) resistor r=45 c=0
Rx6 (\3\:n0 \5\:n0) resistor r=45 c=0
mn0 (\8\:S0b \3\:S0 \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.03e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn1 (n3 \3\:A \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=9.42e-15 ps=6.1e-07 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.25e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn2 (\7\:n0 S0b n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=9.42e-15 \
        ad=2.32e-14 ps=4.2e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.55e-07 sb=7.15e-07 sd=160n sca=10.2779 scb=0.00944477 \
        scc=0.000275883 m=(1)
mn4 (\7\:n0 \4\:S0 n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.74e-14 ad=2.32e-14 ps=5.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=5.1e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn3 (n5 \3\:B \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.74e-14 ps=6.1e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.25e-07 sb=3.45e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn5 (\3\:Y \4\:n0 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mp1 (n4 \1\:A \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.613e-14 ps=7.5e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.25e-07 sd=160n sca=14.6329 \
        scb=0.0132741 scc=0.000215448 m=(1)
mp2 (\9\:n0 \6\:S0 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.613e-14 ad=3.548e-14 ps=5.8e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=7.05e-07 sd=160n sca=13.1421 \
        scb=0.0105991 scc=0.000178477 m=(1)
mp4 (\9\:n0 \3\:S0b n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.258e-14 ad=3.548e-14 ps=6.4e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=4.95e-07 sd=160n sca=12.581 \
        scb=0.00966143 scc=0.000174195 m=(1)
mp3 (n6 \4\:B \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.258e-14 ps=7.5e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.25e-07 sb=3.45e-07 sd=160n sca=13.2602 \
        scb=0.0108078 scc=0.000179977 m=(1)
mp5 (\1\:Y n0 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.4e-07 sd=160n sca=17.479 \
        scb=0.0182451 scc=0.000415696 m=(1)
ends MX2XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:12:37 2012 )
// Library name: gsclib045
// Cell name: NAND2BXL
// View name: extracted

simulator lang=spectre

subckt NAND2BXL AN B VDD VSS Y
mp2 (\1\:Y \3\:B \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.125e-14 ad=3.44e-14 ps=1.44e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-07 sb=5.5e-07 sd=160n sca=29.0688 \
        scb=0.0326842 scc=0.00215013 m=(1)
C1 (B VSS) capacitor c=7.51943e-17
C2 (VDD VSS) capacitor c=7.67656e-17
C3 (Y VSS) capacitor c=2.31569e-17
C4 (AN VSS) capacitor c=3.51207e-17
C5 (n1 VSS) capacitor c=3.04313e-18
C6 (n0 VSS) capacitor c=3.8251e-17
C7 (\1\:AN VSS) capacitor c=3.3633e-17
C8 (\3\:B VSS) capacitor c=2.89936e-17
C9 (\3\:AN VSS) capacitor c=3.56982e-17
C10 (\3\:n0 VSS) capacitor c=4.8185e-17
C11 (\1\:B VSS) capacitor c=3.80563e-17
C12 (\2\:AN VSS) capacitor c=3.91351e-17
C13 (\2\:n0 VSS) capacitor c=4.9423e-17
C14 (\2\:B VSS) capacitor c=3.79523e-17
C15 (\7\:n0 VSS) capacitor c=4.41217e-17
C16 (\6\:VDD VSS) capacitor c=1.15015e-17
C17 (\1\:Y VSS) capacitor c=4.18884e-17
C18 (\8\:VDD VSS) capacitor c=2.13738e-17
C19 (\1\:VDD VSS) capacitor c=2.30902e-17
C20 (\4\:n0 VSS) capacitor c=6.50136e-17
C21 (\4\:Y VSS) capacitor c=7.93142e-17
C22 (\3\:Y VSS) capacitor c=3.56559e-17
C23 (\4\:B VSS) capacitor c=6.36551e-17
C24 (\6\:n0 VSS) capacitor c=1.12549e-16
C25 (\4\:AN VSS) capacitor c=6.15437e-17
C26 (\3\:VDD VSS) capacitor c=1.89868e-18
Rk4 (B \4\:B) resistor r=0.2021 c=0
Rk15 (\4\:VSS VSS) resistor r=0.1502 c=0
Rk14 (\2\:VSS \4\:VSS) resistor r=0.4176 c=0
Rk8 (\2\:VDD \3\:VDD) resistor r=0.05247 c=0
Rk10 (\4\:VDD VDD) resistor r=0.1006 c=0
Rk9 (\3\:VDD \4\:VDD) resistor r=0.09761 c=0
Rk12 (\3\:VDD \7\:VDD) resistor r=0.07393 c=0
Rk13 (VDD \9\:VDD) resistor r=0.1021 c=0
Rk3 (\3\:Y Y) resistor r=0.07463 c=0
Rk1 (\2\:Y \3\:Y) resistor r=0.1099 c=0
Rk2 (\3\:Y \5\:Y) resistor r=0.3398 c=0
Rk7 (AN \4\:AN) resistor r=0.04974 c=0
Rk5 (\5\:n0 \6\:n0) resistor r=0.3855 c=0
Rk6 (\6\:n0 \8\:n0) resistor r=0.3127 c=0
Rl2 (\2\:B \3\:B) resistor r=41.4835 c=0
Rl1 (\1\:B \2\:B) resistor r=98.0769 c=0
Rl5 (\1\:AN \2\:AN) resistor r=33.8482 c=0
Rl6 (\2\:AN \3\:AN) resistor r=101.156 c=0
Rl3 (n0 \2\:n0) resistor r=24.2328 c=0
Rl4 (\2\:n0 \3\:n0) resistor r=110.771 c=0
Rz6 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\1\:VDD VDD) resistor r=75 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \4\:VDD) resistor r=75 c=0
Rz1 (\4\:Y \5\:Y) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Ry3 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry4 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry2 (\7\:n0 \8\:n0) resistor r=62 c=0
Rx1 (\2\:B \4\:B) resistor r=45 c=0
Rx3 (\2\:AN \4\:AN) resistor r=45 c=0
Rx2 (\2\:n0 \6\:n0) resistor r=45 c=0
mn2 (\4\:Y \1\:B n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.522e-14 ad=2.175e-14 ps=5e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=4.95e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (n1 \3\:n0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.522e-14 ps=6.1e-07 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=3.45e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn0 (\4\:n0 \3\:AN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp1 (\1\:Y n0 \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=3.44e-14 ps=1.53e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=3.45e-07 sd=160n sca=19.8763 \
        scb=0.0203148 scc=0.000456883 m=(1)
mp0 (\7\:n0 \1\:AN \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=3.01e-14 ps=1.53e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.4e-07 sd=160n sca=27.33 scb=0.0309842 \
        scc=0.00176829 m=(1)
ends NAND2BXL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:13:23 2012 )
// Library name: gsclib045
// Cell name: NAND2XL
// View name: extracted

simulator lang=spectre

subckt NAND2XL A B VDD VSS Y
mp0 (\3\:Y \3\:A \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.618e-14 ad=3.44e-14 ps=1.31e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35e-07 sb=3.4e-07 sd=160n sca=34.4364 \
        scb=0.0404765 scc=0.00269477 m=(1)
C1 (B VSS) capacitor c=2.71641e-17
C2 (VDD VSS) capacitor c=4.30624e-17
C3 (A VSS) capacitor c=2.70756e-17
C4 (\1\:B VSS) capacitor c=2.87969e-17
C5 (\3\:A VSS) capacitor c=3.68575e-17
C6 (\3\:B VSS) capacitor c=4.789e-17
C7 (\1\:A VSS) capacitor c=3.675e-17
C8 (\2\:B VSS) capacitor c=4.4863e-17
C9 (\2\:A VSS) capacitor c=5.14503e-17
C10 (\1\:VDD VSS) capacitor c=2.03659e-17
C11 (\3\:Y VSS) capacitor c=6.08143e-17
C12 (\5\:VDD VSS) capacitor c=3.11241e-18
C13 (\1\:Y VSS) capacitor c=8.9608e-17
C14 (\4\:A VSS) capacitor c=3.47778e-17
C15 (\4\:B VSS) capacitor c=5.2765e-17
C16 (\4\:VDD VSS) capacitor c=1.19557e-17
Rk9 (\3\:VSS VSS) resistor r=0.01706 c=0
Rk10 (\3\:VSS \5\:VSS) resistor r=0.2976 c=0
Rk2 (\4\:B B) resistor r=0.03695 c=0
Rk6 (\4\:VDD VDD) resistor r=0.1001 c=0
Rk5 (\2\:VDD \4\:VDD) resistor r=0.2592 c=0
Rk7 (VDD \6\:VDD) resistor r=0.1677 c=0
Rk1 (\4\:A A) resistor r=0.05013 c=0
Rk3 (Y \2\:Y) resistor r=0.002476 c=0
Rk4 (\2\:Y \4\:Y) resistor r=0.5783 c=0
Rl3 (\1\:B \2\:B) resistor r=65.3846 c=0
Rl4 (\2\:B \3\:B) resistor r=83.7912 c=0
Rl2 (\2\:A \3\:A) resistor r=114.56 c=0
Rl1 (\1\:A \2\:A) resistor r=26.098 c=0
Rz3 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
mn0 (n0 \1\:A \4\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn1 (\1\:Y \3\:B n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 scb=0.0129007 \
        scc=0.000589158 m=(1)
mp1 (\3\:Y \1\:B \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.618e-14 ad=3.44e-14 ps=1.31e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.4e-07 sb=1.35e-07 sd=160n sca=34.4364 \
        scb=0.0404765 scc=0.00269477 m=(1)
ends NAND2XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:14:11 2012 )
// Library name: gsclib045
// Cell name: NAND3BXL
// View name: extracted

simulator lang=spectre

subckt NAND3BXL AN B C VDD VSS Y
mp3 (\3\:Y \3\:C \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.9e-14 ad=2.63e-14 ps=1.53e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=7.17326e-07 sd=160n sca=26.1913 \
        scb=0.0299385 scc=0.0017385 m=(1)
C1 (B VSS) capacitor c=3.84338e-17
C2 (Y VSS) capacitor c=1.46371e-17
C3 (C VSS) capacitor c=2.24714e-17
C4 (VDD VSS) capacitor c=1.00908e-16
C5 (n0 VSS) capacitor c=6.41911e-17
C6 (\1\:AN VSS) capacitor c=3.9175e-17
C7 (\1\:B VSS) capacitor c=5.14392e-17
C8 (\3\:C VSS) capacitor c=5.18334e-17
C9 (\3\:AN VSS) capacitor c=3.69713e-17
C10 (\3\:n0 VSS) capacitor c=2.97621e-17
C11 (\3\:B VSS) capacitor c=4.68893e-17
C12 (\1\:C VSS) capacitor c=2.75064e-17
C13 (\2\:AN VSS) capacitor c=4.63904e-17
C14 (\2\:n0 VSS) capacitor c=5.79854e-17
C15 (\2\:B VSS) capacitor c=5.25334e-17
C16 (\2\:C VSS) capacitor c=4.4065e-17
C17 (\4\:n0 VSS) capacitor c=5.03058e-17
C18 (\1\:VDD VSS) capacitor c=2.13852e-17
C19 (\1\:Y VSS) capacitor c=4.0649e-17
C20 (\6\:VDD VSS) capacitor c=1.24286e-17
C21 (\3\:Y VSS) capacitor c=4.21405e-17
C22 (\8\:n0 VSS) capacitor c=1.87482e-17
C23 (\5\:Y VSS) capacitor c=6.71509e-17
C24 (\4\:C VSS) capacitor c=4.86386e-17
C25 (\4\:B VSS) capacitor c=2.77944e-17
C26 (\4\:AN VSS) capacitor c=6.74569e-17
C27 (\6\:AN VSS) capacitor c=4.63647e-17
C28 (\6\:n0 VSS) capacitor c=4.90514e-17
C29 (\7\:n0 VSS) capacitor c=4.78232e-17
C30 (\4\:VDD VSS) capacitor c=6.08763e-18
C31 (\5\:VDD VSS) capacitor c=1.58864e-18
Rk2 (B \4\:B) resistor r=0.02441 c=0
Rk17 (\4\:VSS VSS) resistor r=0.2003 c=0
Rk16 (\2\:VSS \4\:VSS) resistor r=0.4089 c=0
Rk5 (\4\:Y Y) resistor r=0.05294 c=0
Rk3 (\2\:Y \4\:Y) resistor r=0.2876 c=0
Rk4 (\4\:Y \6\:Y) resistor r=0.4768 c=0
Rk1 (C \4\:C) resistor r=0.02587 c=0
Rk6 (\4\:AN \5\:AN) resistor r=0.006173 c=0
Rk7 (AN \6\:AN) resistor r=0.00607 c=0
Rk8 (\4\:AN \6\:AN) resistor r=0.06409 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.1386 c=0
Rk14 (\5\:VDD VDD) resistor r=0.1176 c=0
Rk13 (\4\:VDD \5\:VDD) resistor r=0.08023 c=0
Rk15 (\5\:VDD \7\:VDD) resistor r=0.05128 c=0
Rk9 (\5\:n0 \6\:n0) resistor r=0.3387 c=0
Rk10 (\6\:n0 \7\:n0) resistor r=0.1884 c=0
Rk11 (\6\:n0 \9\:n0) resistor r=0.1249 c=0
Rl3 (\1\:B \2\:B) resistor r=75.6918 c=0
Rl4 (\2\:B \3\:B) resistor r=94.9225 c=0
Rl2 (\2\:C \3\:C) resistor r=129.319 c=0
Rl1 (\1\:C \2\:C) resistor r=38.3096 c=0
Rl7 (\1\:AN \2\:AN) resistor r=68.4057 c=0
Rl8 (\2\:AN \3\:AN) resistor r=95.3288 c=0
Rl5 (n0 \2\:n0) resistor r=137.637 c=0
Rl6 (\2\:n0 \3\:n0) resistor r=26.098 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz1 (\5\:Y \6\:Y) resistor r=75 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=62 c=0
Ry2 (\3\:Y \4\:Y) resistor r=62 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry3 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx1 (\2\:C \4\:C) resistor r=45 c=0
Rx3 (\2\:AN \5\:AN) resistor r=45 c=0
Rx4 (\2\:n0 \7\:n0) resistor r=45 c=0
mn3 (\5\:Y \1\:C n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=2.03e-14 ps=5.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.15e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn2 (n1 \3\:B n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=1.957e-14 \
        ad=2.102e-14 ps=5.6e-07 pd=5.8e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.2e-07 sb=5.35e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn1 (n1 \3\:n0 \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.102e-14 ps=6.1e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn0 (\8\:n0 \3\:AN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mp2 (\1\:Y \1\:B \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.9e-14 ad=3.44e-14 ps=1.53e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.17326e-07 sb=5.22326e-07 sd=160n sca=17.2808 \
        scb=0.0163439 scc=0.000383193 m=(1)
mp1 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.83e-14 ad=3.44e-14 ps=1.52e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.22326e-07 sb=3.17326e-07 sd=160n sca=17.2808 \
        scb=0.0163439 scc=0.000383193 m=(1)
mp0 (\4\:n0 \1\:AN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.83e-14 ad=2.63e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.17326e-07 sb=1.22326e-07 sd=160n sca=26.1913 \
        scb=0.0299385 scc=0.0017385 m=(1)
ends NAND3BXL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:15:00 2012 )
// Library name: gsclib045
// Cell name: NAND3X1
// View name: extracted

simulator lang=spectre

subckt NAND3X1 A B C VDD VSS Y
mp0 (\4\:Y \1\:A \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=25.4535 \
        scb=0.0286798 scc=0.00163825 m=(1)
C1 (C VSS) capacitor c=2.04013e-17
C2 (VDD VSS) capacitor c=7.74681e-17
C3 (Y VSS) capacitor c=6.14524e-18
C4 (B VSS) capacitor c=1.96774e-17
C5 (n1 VSS) capacitor c=3.35995e-18
C6 (\1\:C VSS) capacitor c=4.92231e-17
C7 (\1\:B VSS) capacitor c=5.76847e-17
C8 (\1\:A VSS) capacitor c=3.61639e-17
C9 (\3\:C VSS) capacitor c=4.61067e-17
C10 (\3\:B VSS) capacitor c=6.41878e-17
C11 (\3\:A VSS) capacitor c=4.30211e-17
C12 (\2\:C VSS) capacitor c=4.08304e-17
C13 (\2\:B VSS) capacitor c=4.8777e-17
C14 (\2\:A VSS) capacitor c=3.84925e-17
C15 (\6\:Y VSS) capacitor c=3.96567e-17
C16 (\1\:VDD VSS) capacitor c=6.80735e-17
C17 (\4\:Y VSS) capacitor c=8.23938e-17
C18 (\5\:VDD VSS) capacitor c=4.6962e-17
C19 (\1\:Y VSS) capacitor c=8.30142e-17
C20 (\5\:A VSS) capacitor c=1.71278e-17
C21 (\6\:A VSS) capacitor c=3.06625e-17
C22 (\4\:B VSS) capacitor c=2.9002e-17
C23 (\4\:C VSS) capacitor c=6.54631e-17
C24 (\3\:Y VSS) capacitor c=5.25966e-17
C25 (\4\:VDD VSS) capacitor c=2.62883e-17
Rk1 (\4\:A \5\:A) resistor r=0.009432 c=0
Rk2 (A \6\:A) resistor r=0.009274 c=0
Rk3 (\4\:A \6\:A) resistor r=0.0314 c=0
Rk14 (VSS \4\:VSS) resistor r=0.3197 c=0
Rk5 (C \4\:C) resistor r=0.02186 c=0
Rk11 (\4\:VDD VDD) resistor r=0.2001 c=0
Rk10 (\2\:VDD \4\:VDD) resistor r=0.2926 c=0
Rk12 (VDD \6\:VDD) resistor r=0.2441 c=0
Rk8 (\3\:Y Y) resistor r=0.05218 c=0
Rk6 (\2\:Y \3\:Y) resistor r=0.4304 c=0
Rk7 (\3\:Y \5\:Y) resistor r=0.386 c=0
Rk9 (Y \7\:Y) resistor r=0.06453 c=0
Rk4 (B \4\:B) resistor r=0.02903 c=0
Rl1 (\1\:A \2\:A) resistor r=26.098 c=0
Rl2 (\2\:A \3\:A) resistor r=114.56 c=0
Rl5 (\1\:C \2\:C) resistor r=127.402 c=0
Rl6 (\2\:C \3\:C) resistor r=26.3736 c=0
Rl3 (\1\:B \2\:B) resistor r=75.6918 c=0
Rl4 (\2\:B \3\:B) resistor r=71.8456 c=0
Rz3 (\3\:VSS \4\:VSS) resistor r=37.5 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry4 (\5\:VDD \6\:VDD) resistor r=31 c=0
Ry1 (\4\:Y \5\:Y) resistor r=31 c=0
Ry2 (\6\:Y \7\:Y) resistor r=31 c=0
Rx1 (\2\:A \5\:A) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
mn0 (n0 \3\:A \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.15e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn1 (n0 \3\:B n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.82e-14 \
        ad=4.16e-14 ps=6.6e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.45e-07 sb=3.1e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mn2 (\1\:Y \3\:C n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.82e-14 \
        ad=5.07e-14 ps=6.6e-07 pd=9.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.6e-07 sb=1.95e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mp1 (\4\:Y \1\:B \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=16.4103 \
        scb=0.0148066 scc=0.000275039 m=(1)
mp2 (\6\:Y \1\:C \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=16.6925 \
        scb=0.0153965 scc=0.00029244 m=(1)
ends NAND3X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:15:47 2012 )
// Library name: gsclib045
// Cell name: NOR2BX1
// View name: extracted

simulator lang=spectre

subckt NOR2BX1 AN B VDD VSS Y
mp2 (\3\:Y \1\:B net59 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.74551e-07 sd=160n sca=22.6423 \
        scb=0.024839 scc=0.000882584 m=(1)
C1 (Y VSS) capacitor c=6.22187e-17
C2 (B VSS) capacitor c=3.7587e-17
C3 (VDD VSS) capacitor c=9.78699e-17
C4 (net76 VSS) capacitor c=5.53967e-17
C5 (\1\:AN VSS) capacitor c=3.73396e-17
C6 (\3\:net76 VSS) capacitor c=7.73674e-17
C7 (\1\:B VSS) capacitor c=7.64588e-17
C8 (\3\:AN VSS) capacitor c=3.95621e-17
C9 (\3\:B VSS) capacitor c=2.86245e-17
C10 (\2\:AN VSS) capacitor c=3.79163e-17
C11 (\2\:net76 VSS) capacitor c=5.0375e-17
C12 (\2\:B VSS) capacitor c=4.59562e-17
C13 (\4\:net76 VSS) capacitor c=4.21052e-17
C14 (\1\:VDD VSS) capacitor c=3.68118e-17
C15 (\3\:Y VSS) capacitor c=5.03603e-17
C16 (\8\:net76 VSS) capacitor c=6.2457e-17
C17 (\1\:Y VSS) capacitor c=9.13509e-17
C18 (\4\:B VSS) capacitor c=8.24576e-17
C19 (\6\:net76 VSS) capacitor c=9.46014e-17
C20 (\7\:net76 VSS) capacitor c=2.0248e-17
C21 (\4\:AN VSS) capacitor c=5.35764e-17
C22 (\6\:AN VSS) capacitor c=4.35814e-17
C23 (\4\:VDD VSS) capacitor c=2.05496e-17
Rk1 (\2\:Y Y) resistor r=0.6199 c=0
Rk2 (Y \4\:Y) resistor r=0.1582 c=0
Rk7 (\4\:AN \5\:AN) resistor r=0.005473 c=0
Rk8 (AN \6\:AN) resistor r=0.005473 c=0
Rk9 (\4\:AN \6\:AN) resistor r=0.02665 c=0
Rk3 (B \4\:B) resistor r=0.07664 c=0
Rk15 (\4\:VDD VDD) resistor r=0.1503 c=0
Rk14 (\2\:VDD \4\:VDD) resistor r=0.2673 c=0
Rk11 (\4\:VSS VSS) resistor r=0.2014 c=0
Rk10 (\2\:VSS \4\:VSS) resistor r=0.399 c=0
Rk13 (VSS \7\:VSS) resistor r=0.1029 c=0
Rk4 (\5\:net76 \6\:net76) resistor r=0.2842 c=0
Rk5 (\6\:net76 \7\:net76) resistor r=0.04832 c=0
Rk6 (\6\:net76 \9\:net76) resistor r=0.4595 c=0
Rl5 (\1\:AN \2\:AN) resistor r=53.0211 c=0
Rl6 (\2\:AN \3\:AN) resistor r=87.6365 c=0
Rl1 (\1\:B \2\:B) resistor r=92.3077 c=0
Rl2 (\2\:B \3\:B) resistor r=56.8681 c=0
Rl3 (net76 \2\:net76) resistor r=115.365 c=0
Rl4 (\2\:net76 \3\:net76) resistor r=29.5379 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (\8\:net76 \9\:net76) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry4 (\3\:VSS VSS) resistor r=62 c=0
Ry3 (\3\:VSS \4\:VSS) resistor r=20.6667 c=0
Ry2 (\4\:net76 \5\:net76) resistor r=62 c=0
Rx3 (\2\:AN \5\:AN) resistor r=45 c=0
Rx1 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:net76 \7\:net76) resistor r=45 c=0
mn2 (\1\:Y \3\:B \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.85e-14 ad=4.16e-14 ps=1.41e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=4.41635e-07 sd=160n sca=13.198 \
        scb=0.0131159 scc=0.000803647 m=(1)
mn1 (\1\:Y net76 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=2.36635e-07 sd=160n sca=13.198 \
        scb=0.0131159 scc=0.000803647 m=(1)
mn0 (\8\:net76 \3\:AN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.4e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mp1 (net59 \3\:net76 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=2.34e-14 ps=1.16e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=2.69551e-07 sd=160n sca=19.5802 \
        scb=0.0197242 scc=0.000428585 m=(1)
mp0 (\4\:net76 \1\:AN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.4e-07 sd=160n sca=28.1856 \
        scb=0.0322489 scc=0.00190885 m=(1)
ends NOR2BX1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:16:34 2012 )
// Library name: gsclib045
// Cell name: NOR2X2
// View name: extracted

simulator lang=spectre

subckt NOR2X2 A B VDD VSS Y
mp0 (3 \1\:A \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.55e-07 sd=160n sca=20.7977 \
        scb=0.0219422 scc=0.000863938 m=(1)
C1 (A VSS) capacitor c=3.63183e-17
C2 (Y VSS) capacitor c=7.90092e-17
C3 (B VSS) capacitor c=6.27214e-17
C4 (VDD VSS) capacitor c=6.72911e-17
C5 (3 VSS) capacitor c=9.37954e-19
C6 (5 VSS) capacitor c=3.74697e-18
C7 (\6\:A VSS) capacitor c=7.24671e-17
C8 (\1\:B VSS) capacitor c=6.16799e-17
C9 (\6\:B VSS) capacitor c=5.66349e-17
C10 (\1\:A VSS) capacitor c=7.41277e-17
C11 (\2\:A VSS) capacitor c=3.26289e-16
C12 (\7\:VDD VSS) capacitor c=5.47717e-17
C13 (\6\:Y VSS) capacitor c=1.39813e-16
C14 (\9\:VDD VSS) capacitor c=4.41863e-17
C15 (\1\:VDD VSS) capacitor c=3.05433e-17
C16 (\1\:Y VSS) capacitor c=1.81065e-16
C17 (\2\:B VSS) capacitor c=1.38037e-16
C18 (\7\:B VSS) capacitor c=3.58604e-17
C19 (\3\:VDD VSS) capacitor c=1.01282e-18
C20 (\5\:VDD VSS) capacitor c=1.01282e-18
Rk3 (\2\:A A) resistor r=0.1014 c=0
Rk6 (\1\:Y Y) resistor r=0.09399 c=0
Rk7 (Y \7\:Y) resistor r=0.7537 c=0
Rk10 (VSS \6\:VSS) resistor r=0.3274 c=0
Rk1 (\7\:B B) resistor r=0.05499 c=0
Rk12 (\2\:VDD \3\:VDD) resistor r=0.03998 c=0
Rk13 (\3\:VDD \4\:VDD) resistor r=0.1605 c=0
Rk15 (\5\:VDD VDD) resistor r=0.04977 c=0
Rk14 (\4\:VDD \5\:VDD) resistor r=0.1504 c=0
Rk17 (\3\:VDD \8\:VDD) resistor r=0.3043 c=0
Rk18 (\5\:VDD \10\:VDD) resistor r=0.3144 c=0
Rl9 (\2\:A \6\:A) resistor r=72.5275 c=0
Rl1 (\2\:A \1\:A) resistor r=75.1972 c=0
Rl3 (\2\:B \1\:B) resistor r=47.3105 c=0
Rl7 (\2\:B \6\:B) resistor r=24.2328 c=0
Rz4 (\6\:VSS \5\:VSS) resistor r=75 c=0
Rz8 (\1\:VDD VDD) resistor r=75 c=0
Rz6 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz7 (\1\:VDD \4\:VDD) resistor r=25 c=0
Ry1 (\7\:Y \6\:Y) resistor r=31 c=0
Ry3 (\7\:VDD \8\:VDD) resistor r=20.6667 c=0
Ry4 (\9\:VDD \10\:VDD) resistor r=20.6667 c=0
Rx1 (\7\:B \2\:B) resistor r=45 c=0
mn0 (\1\:Y \2\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.265e-14 ad=4.16e-14 ps=1.12e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.15e-07 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(2)
mn1 (\1\:Y \2\:B \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.1e-07 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(2)
mp1 (\6\:Y \6\:B 3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=4.5e-07 sd=160n sca=18.3517 scb=0.0171974 \
        scc=0.00064315 m=(1)
mp1_1__rcx (\6\:Y \1\:B 5 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2.45e-07 sd=160n sca=18.6339 \
        scb=0.0177874 scc=0.000660551 m=(1)
mp0_1__rcx (5 \6\:A \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1.4e-07 sd=160n sca=21.6313 \
        scb=0.0233702 scc=0.000971691 m=(1)
ends NOR2X2
// End of subcircuit definition.

// Generated for: spectre (May  8 15:17:23 2012 )
// Library name: gsclib045
// Cell name: NOR4BX1
// View name: extracted

simulator lang=spectre

subckt NOR4BX1 AN B C D VDD VSS Y
mp4 (\6\:Y \1\:D n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.73846e-07 sd=160n sca=17.2376 scb=0.0171686 \
        scc=0.000563105 m=(1)
C1 (B VSS) capacitor c=8.33002e-17
C2 (C VSS) capacitor c=2.00046e-17
C3 (VDD VSS) capacitor c=1.13429e-16
C4 (Y VSS) capacitor c=1.26344e-17
C5 (AN VSS) capacitor c=3.94936e-17
C6 (n0 VSS) capacitor c=4.17522e-17
C7 (n2 VSS) capacitor c=1.99728e-18
C8 (\3\:AN VSS) capacitor c=4.35352e-17
C9 (\3\:n0 VSS) capacitor c=7.64233e-17
C10 (\1\:B VSS) capacitor c=5.46374e-17
C11 (\1\:C VSS) capacitor c=7.59096e-17
C12 (\1\:D VSS) capacitor c=7.32648e-17
C13 (\1\:AN VSS) capacitor c=3.26175e-17
C14 (\3\:B VSS) capacitor c=5.10375e-17
C15 (\3\:C VSS) capacitor c=5.14111e-17
C16 (\3\:D VSS) capacitor c=3.59247e-17
C17 (\2\:AN VSS) capacitor c=4.31481e-17
C18 (\2\:n0 VSS) capacitor c=5.67942e-17
C19 (\2\:B VSS) capacitor c=5.6278e-17
C20 (\2\:C VSS) capacitor c=5.90296e-17
C21 (\2\:D VSS) capacitor c=5.66877e-17
C22 (\7\:n0 VSS) capacitor c=5.60461e-17
C23 (\1\:VDD VSS) capacitor c=4.70269e-17
C24 (\6\:Y VSS) capacitor c=5.10316e-17
C25 (\5\:n0 VSS) capacitor c=7.83744e-17
C26 (\1\:Y VSS) capacitor c=7.41532e-17
C27 (\3\:Y VSS) capacitor c=4.88759e-17
C28 (\4\:D VSS) capacitor c=7.86163e-17
C29 (\4\:C VSS) capacitor c=4.91816e-17
C30 (\5\:Y VSS) capacitor c=8.35106e-17
C31 (\4\:AN VSS) capacitor c=5.68371e-17
C32 (\4\:n0 VSS) capacitor c=7.53315e-17
C33 (\4\:VDD VSS) capacitor c=2.88693e-17
Rk3 (B \4\:B) resistor r=0.00406 c=0
Rk11 (\2\:VSS \3\:VSS) resistor r=0.09973 c=0
Rk12 (\3\:VSS \4\:VSS) resistor r=0.09973 c=0
Rk13 (\4\:VSS \5\:VSS) resistor r=0.1122 c=0
Rk14 (\5\:VSS \6\:VSS) resistor r=0.08724 c=0
Rk16 (\7\:VSS VSS) resistor r=0.03203 c=0
Rk15 (\6\:VSS \7\:VSS) resistor r=0.1172 c=0
Rk18 (\3\:VSS \10\:VSS) resistor r=0.1982 c=0
Rk19 (\5\:VSS \12\:VSS) resistor r=0.1982 c=0
Rk20 (\7\:VSS \14\:VSS) resistor r=0.1982 c=0
Rk2 (C \4\:C) resistor r=0.1134 c=0
Rk22 (\4\:VDD VDD) resistor r=0.2995 c=0
Rk21 (\2\:VDD \4\:VDD) resistor r=0.4258 c=0
Rk1 (\4\:D D) resistor r=0.01679 c=0
Rk4 (\2\:Y \4\:Y) resistor r=0.3382 c=0
Rk6 (\5\:Y Y) resistor r=0.004828 c=0
Rk5 (\4\:Y \5\:Y) resistor r=0.2692 c=0
Rk7 (\5\:Y \7\:Y) resistor r=0.5372 c=0
Rk8 (AN \4\:AN) resistor r=0.09359 c=0
Rk9 (\4\:n0 \6\:n0) resistor r=0.3044 c=0
Rk10 (\6\:n0 \8\:n0) resistor r=0.5005 c=0
Rl5 (\1\:B \2\:B) resistor r=62.2302 c=0
Rl6 (\2\:B \3\:B) resistor r=106.461 c=0
Rl3 (\1\:C \2\:C) resistor r=56.461 c=0
Rl4 (\2\:C \3\:C) resistor r=112.23 c=0
Rl1 (\1\:D \2\:D) resistor r=70.9439 c=0
Rl2 (\2\:D \3\:D) resistor r=101.099 c=0
Rl10 (\2\:AN \3\:AN) resistor r=116.54 c=0
Rl9 (\1\:AN \2\:AN) resistor r=49.2328 c=0
Rl7 (n0 \2\:n0) resistor r=37.6944 c=0
Rl8 (\2\:n0 \3\:n0) resistor r=128.079 c=0
Rz4 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz5 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz6 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Rz2 (\3\:Y \4\:Y) resistor r=75 c=0
Rz3 (\5\:n0 \6\:n0) resistor r=75 c=0
Ry6 (\1\:VSS VSS) resistor r=62 c=0
Ry3 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry4 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry5 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry7 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry1 (\6\:Y \7\:Y) resistor r=31 c=0
Ry2 (\7\:n0 \8\:n0) resistor r=62 c=0
Rx3 (\2\:B \4\:B) resistor r=45 c=0
Rx2 (\2\:C \4\:C) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx4 (\2\:AN \4\:AN) resistor r=45 c=0
Rx5 (\2\:n0 \4\:n0) resistor r=45 c=0
mn4 (\3\:Y \3\:D \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.01058e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn3 (\3\:Y \3\:C \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.96058e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn2 (\1\:Y \3\:B \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.55e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=4.76058e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn1 (\1\:Y n0 \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=2.71058e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(1)
mn0 (\5\:n0 \1\:AN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=1.4e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mp3 (n1 \1\:C n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.825e-14 \
        ad=2.34e-14 ps=1.13e-06 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.68846e-07 sd=160n sca=15.3527 scb=0.0138144 \
        scc=0.000491181 m=(1)
mp2 (n2 \1\:B n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=4.485e-14 \
        ad=6.825e-14 ps=1.01e-06 pd=1.13e-06 nrd=1.16667 nrs=1.16667 \
        sa=4.65e-07 sb=4.48846e-07 sd=160n sca=14.2604 scb=0.0119242 \
        scc=0.000478605 m=(1)
mp1 (n3 \3\:n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=4.485e-14 ps=1.16e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2.88846e-07 sd=160n sca=14.7087 \
        scb=0.0126621 scc=0.000481524 m=(1)
mp0 (\7\:n0 \3\:AN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.762e-14 ps=1.16e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.6e-07 sb=1.75e-07 sd=160n sca=21.1756 \
        scb=0.0235868 scc=0.00103894 m=(1)
ends NOR4BX1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:18:08 2012 )
// Library name: gsclib045
// Cell name: NOR4X1
// View name: extracted

simulator lang=spectre

subckt NOR4X1 A B C D VDD VSS Y
mp0 (n2 \1\:A \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.7e-07 sd=160n sca=39.8224 \
        scb=0.0332643 scc=0.00388272 m=(1)
C1 (Y VSS) capacitor c=2.88223e-17
C2 (B VSS) capacitor c=7.91706e-17
C3 (D VSS) capacitor c=3.02429e-17
C4 (A VSS) capacitor c=2.18591e-17
C5 (C VSS) capacitor c=6.07672e-17
C6 (VDD VSS) capacitor c=4.62353e-17
C7 (n2 VSS) capacitor c=2.62435e-18
C8 (n1 VSS) capacitor c=7.65769e-18
C9 (n0 VSS) capacitor c=2.19493e-18
C10 (\3\:D VSS) capacitor c=4.27532e-17
C11 (\1\:C VSS) capacitor c=5.01282e-17
C12 (\1\:B VSS) capacitor c=6.89565e-17
C13 (\1\:A VSS) capacitor c=6.98697e-17
C14 (\1\:D VSS) capacitor c=2.90982e-17
C15 (\3\:C VSS) capacitor c=4.16088e-17
C16 (\3\:B VSS) capacitor c=4.59021e-17
C17 (\3\:A VSS) capacitor c=2.69411e-17
C18 (\2\:D VSS) capacitor c=2.79616e-17
C19 (\2\:C VSS) capacitor c=3.50394e-17
C20 (\2\:B VSS) capacitor c=4.38959e-17
C21 (\2\:A VSS) capacitor c=4.1968e-17
C22 (\1\:Y VSS) capacitor c=7.28505e-17
C23 (\5\:VDD VSS) capacitor c=6.85701e-17
C24 (\1\:VDD VSS) capacitor c=3.87373e-17
C25 (\3\:Y VSS) capacitor c=8.3859e-17
C26 (\5\:Y VSS) capacitor c=5.48431e-17
C27 (\4\:A VSS) capacitor c=3.24011e-17
C28 (\4\:B VSS) capacitor c=3.96902e-17
C29 (\4\:C VSS) capacitor c=7.58167e-17
C30 (\4\:D VSS) capacitor c=5.9657e-17
Rk5 (Y \2\:Y) resistor r=0.1984 c=0
Rk6 (\2\:Y \4\:Y) resistor r=0.4988 c=0
Rk7 (\4\:Y \6\:Y) resistor r=0.2869 c=0
Rk2 (\4\:B B) resistor r=0.1701 c=0
Rk4 (D \4\:D) resistor r=0.02918 c=0
Rk1 (\4\:A A) resistor r=0.06282 c=0
Rk9 (\4\:VSS VSS) resistor r=0.2017 c=0
Rk8 (\2\:VSS \4\:VSS) resistor r=0.4508 c=0
Rk10 (\4\:VSS \6\:VSS) resistor r=0.3016 c=0
Rk11 (VSS \8\:VSS) resistor r=0.06245 c=0
Rk3 (\4\:C C) resistor r=0.3466 c=0
Rk13 (\3\:VDD VDD) resistor r=0.02966 c=0
Rk12 (\2\:VDD \3\:VDD) resistor r=0.2206 c=0
Rk15 (\3\:VDD \6\:VDD) resistor r=0.3943 c=0
Rl3 (\1\:B \2\:B) resistor r=29.5379 c=0
Rl4 (\2\:B \3\:B) resistor r=56.461 c=0
Rl8 (\2\:D \3\:D) resistor r=29.9451 c=0
Rl7 (\1\:D \2\:D) resistor r=57.6923 c=0
Rl1 (\1\:A \2\:A) resistor r=55.5593 c=0
Rl2 (\2\:A \3\:A) resistor r=33.7912 c=0
Rl5 (\1\:C \2\:C) resistor r=29.5379 c=0
Rl6 (\2\:C \3\:C) resistor r=56.461 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz2 (\5\:Y \6\:Y) resistor r=75 c=0
Rz3 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz4 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz5 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz7 (\1\:VDD VDD) resistor r=75 c=0
Rz6 (\1\:VDD \2\:VDD) resistor r=18.75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=20.6667 c=0
Rx2 (\2\:B \4\:B) resistor r=45 c=0
Rx4 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx3 (\2\:C \4\:C) resistor r=45 c=0
mn0 (\5\:Y \3\:A \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.79e-14 ad=4.16e-14 ps=1.4e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.65e-07 sd=160n sca=12.8392 scb=0.0126987 \
        scc=0.00074151 m=(1)
mn1 (\5\:Y \3\:B \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=5.6e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn2 (\3\:Y \3\:C \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=4.16e-14 ps=8.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=3.45e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn3 (\3\:Y \1\:D \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.4e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mp1 (n1 \1\:B n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=6.63e-14 ps=9e-07 pd=1.12e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=5.65e-07 sd=160n sca=36.1614 scb=0.0267849 \
        scc=0.00344655 m=(1)
mp2 (n0 \1\:C n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.63e-14 \
        ad=4.095e-14 ps=1.12e-06 pd=9.9e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.6e-07 sb=3.5e-07 sd=160n sca=35.408 scb=0.0252222 \
        scc=0.00339762 m=(1)
mp3 (\1\:Y \3\:D n0 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=4.095e-14 \
        ad=7.8e-14 ps=9.9e-07 pd=1.18e-06 nrd=1.16667 nrs=1.16667 \
        sa=6.1e-07 sb=2e-07 sd=160n sca=39.5482 scb=0.03284 scc=0.00384048 \
        m=(1)
ends NOR4X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:18:56 2012 )
// Library name: gsclib045
// Cell name: OA21X1
// View name: extracted

simulator lang=spectre

subckt OA21X1 A0 A1 B0 VDD VSS Y
mp0 (net98 \1\:A0 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.225e-14 ps=7.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.85e-07 sd=160n sca=26.8266 \
        scb=0.0313637 scc=0.00190754 m=(1)
C1 (B0 VSS) capacitor c=4.14605e-17
C2 (A1 VSS) capacitor c=4.75635e-17
C3 (VDD VSS) capacitor c=8.19909e-17
C4 (Y VSS) capacitor c=1.23893e-17
C5 (net107 VSS) capacitor c=6.19835e-17
C6 (net95 VSS) capacitor c=3.86581e-17
C7 (net98 VSS) capacitor c=8.98266e-18
C8 (\4\:net95 VSS) capacitor c=4.77688e-17
C9 (\1\:B0 VSS) capacitor c=6.11187e-17
C10 (\1\:A1 VSS) capacitor c=3.86324e-17
C11 (\1\:A0 VSS) capacitor c=4.75352e-17
C12 (\3\:B0 VSS) capacitor c=2.80236e-17
C13 (\3\:A1 VSS) capacitor c=5.33822e-17
C14 (\4\:A0 VSS) capacitor c=3.12319e-17
C15 (\3\:net95 VSS) capacitor c=2.46289e-17
C16 (\2\:B0 VSS) capacitor c=5.10039e-17
C17 (\2\:A1 VSS) capacitor c=5.59085e-17
C18 (\3\:A0 VSS) capacitor c=1.45659e-17
C19 (\1\:Y VSS) capacitor c=7.17598e-17
C20 (\1\:VDD VSS) capacitor c=6.44634e-17
C21 (\8\:net95 VSS) capacitor c=6.17774e-17
C22 (\5\:VDD VSS) capacitor c=1.83048e-17
C23 (\3\:Y VSS) capacitor c=4.80424e-17
C24 (\5\:net95 VSS) capacitor c=5.64841e-17
C25 (\3\:net107 VSS) capacitor c=4.18056e-17
C26 (\2\:A0 VSS) capacitor c=3.17177e-17
C27 (\2\:net95 VSS) capacitor c=1.92177e-17
C28 (\5\:A0 VSS) capacitor c=3.93457e-17
C29 (\7\:A0 VSS) capacitor c=3.76154e-17
C30 (\4\:A1 VSS) capacitor c=3.2107e-17
C31 (\6\:B0 VSS) capacitor c=4.58927e-17
C32 (\7\:net95 VSS) capacitor c=7.35732e-17
C33 (\4\:VDD VSS) capacitor c=2.81124e-17
Rk6 (\4\:B0 B0) resistor r=0.006735 c=0
Rk8 (\4\:B0 \6\:B0) resistor r=0.02172 c=0
Rk7 (\5\:B0 \6\:B0) resistor r=0.006735 c=0
Rk4 (\4\:A1 A1) resistor r=0.1016 c=0
Rk21 (\4\:VDD VDD) resistor r=0.2507 c=0
Rk20 (\2\:VDD \4\:VDD) resistor r=0.3682 c=0
Rk22 (VDD \6\:VDD) resistor r=0.3148 c=0
Rk1 (\5\:A0 \6\:A0) resistor r=0.002221 c=0
Rk2 (A0 \7\:A0) resistor r=0.002132 c=0
Rk3 (\5\:A0 \7\:A0) resistor r=0.1329 c=0
Rk12 (\4\:Y Y) resistor r=0.03658 c=0
Rk11 (\2\:Y \4\:Y) resistor r=0.5453 c=0
Rk13 (\2\:VSS \3\:VSS) resistor r=0.07749 c=0
Rk14 (\3\:VSS \4\:VSS) resistor r=0.1226 c=0
Rk15 (\4\:VSS \5\:VSS) resistor r=0.1326 c=0
Rk17 (\6\:VSS VSS) resistor r=0.04987 c=0
Rk16 (\5\:VSS \6\:VSS) resistor r=0.06747 c=0
Rk18 (\3\:VSS \8\:VSS) resistor r=0.1333 c=0
Rk19 (\5\:VSS \10\:VSS) resistor r=0.07346 c=0
Rk5 (\2\:net107 \4\:net107) resistor r=0.2251 c=0
Rk9 (\6\:net95 \7\:net95) resistor r=0.2976 c=0
Rk10 (\7\:net95 \9\:net95) resistor r=0.3018 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=153.021 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=26.098 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=62.6365 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=116.483 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=167.022 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=36.2526 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=4.3144 c=0
Rl8 (net95 \2\:net95) resistor r=122.357 c=0
Rl10 (\2\:net95 \4\:net95) resistor r=57.4064 c=0
Rl9 (\2\:net95 \3\:net95) resistor r=4.3144 c=0
Rz4 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz5 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz6 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz1 (net107 \2\:net107) resistor r=75 c=0
Rz2 (\3\:net107 \4\:net107) resistor r=75 c=0
Rz3 (\5\:net95 \6\:net95) resistor r=75 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry7 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry2 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry3 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry4 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry5 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry1 (\8\:net95 \9\:net95) resistor r=62 c=0
Rx3 (\2\:B0 \5\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\3\:A0 \6\:A0) resistor r=45 c=0
Rx4 (\3\:net95 \7\:net95) resistor r=45 c=0
mn0 (\3\:net107 \4\:A0 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.03e-14 ps=1.31e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (net107 \3\:A1 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.465e-14 ps=1.31e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=3.55e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\5\:net95 \3\:B0 net107 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.03e-14 ps=6.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn3 (\3\:Y net95 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.67e-14 ad=3.64e-14 ps=1.5e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mp1 (\8\:net95 \1\:A1 net98 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.225e-14 ad=3.655e-14 ps=7.3e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=5.9e-07 sd=160n sca=17.3843 \
        scb=0.0171664 scc=0.000551089 m=(1)
mp2 (\8\:net95 \1\:B0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.655e-14 ps=1.16e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.75e-07 sd=160n sca=15.8515 \
        scb=0.0140891 scc=0.000503754 m=(1)
mp3 (\1\:Y \4\:net95 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.95577e-07 sb=1.4e-07 sd=160n sca=17.0231 \
        scb=0.0168642 scc=0.000422034 m=(1)
ends OA21X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:19:41 2012 )
// Library name: gsclib045
// Cell name: OA22X1
// View name: extracted

simulator lang=spectre

subckt OA22X1 A0 A1 B0 B1 VDD VSS Y
mp0 (net119 \1\:A0 \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.225e-14 ps=7.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.11e-06 sd=160n sca=25.0208 \
        scb=0.0285597 scc=0.00162702 m=(1)
C1 (Y VSS) capacitor c=6.96707e-17
C2 (A0 VSS) capacitor c=2.51715e-17
C3 (B0 VSS) capacitor c=2.99308e-17
C4 (VDD VSS) capacitor c=9.88477e-17
C5 (net124 VSS) capacitor c=6.30758e-17
C6 (net128 VSS) capacitor c=4.02728e-17
C7 (net115 VSS) capacitor c=5.90412e-18
C8 (\1\:B0 VSS) capacitor c=3.15524e-17
C9 (\1\:B1 VSS) capacitor c=3.84538e-17
C10 (\1\:A1 VSS) capacitor c=3.96309e-17
C11 (\1\:A0 VSS) capacitor c=4.87224e-17
C12 (\4\:net128 VSS) capacitor c=3.05463e-17
C13 (\3\:B0 VSS) capacitor c=5.19971e-17
C14 (\4\:B1 VSS) capacitor c=4.97988e-17
C15 (\3\:A1 VSS) capacitor c=5.44284e-17
C16 (\3\:A0 VSS) capacitor c=3.243e-17
C17 (\3\:net128 VSS) capacitor c=1.98466e-17
C18 (\2\:B0 VSS) capacitor c=4.37009e-17
C19 (\3\:B1 VSS) capacitor c=2.67932e-17
C20 (\2\:A1 VSS) capacitor c=6.52062e-17
C21 (\2\:A0 VSS) capacitor c=4.42142e-17
C22 (\1\:Y VSS) capacitor c=4.53056e-17
C23 (\1\:VDD VSS) capacitor c=3.34793e-17
C24 (\7\:net128 VSS) capacitor c=7.03485e-17
C25 (\5\:VDD VSS) capacitor c=1.79918e-17
C26 (\9\:net128 VSS) capacitor c=3.77039e-17
C27 (\3\:net124 VSS) capacitor c=7.62639e-17
C28 (\5\:net124 VSS) capacitor c=4.01018e-17
C29 (\2\:B1 VSS) capacitor c=3.69476e-17
C30 (\4\:A0 VSS) capacitor c=2.18375e-17
C31 (\4\:A1 VSS) capacitor c=2.96184e-17
C32 (\5\:A1 VSS) capacitor c=3.21622e-17
C33 (\5\:B1 VSS) capacitor c=4.72659e-17
C34 (\7\:B1 VSS) capacitor c=4.46163e-17
C35 (\5\:B0 VSS) capacitor c=4.55269e-17
C36 (\5\:net128 VSS) capacitor c=4.86506e-17
C37 (\6\:net128 VSS) capacitor c=1.01158e-16
C38 (\4\:VDD VSS) capacitor c=3.75691e-17
Rk2 (A1 \4\:A1) resistor r=0.008275 c=0
Rk4 (\4\:A1 \5\:A1) resistor r=0.04592 c=0
Rk3 (\5\:A1 \6\:A1) resistor r=0.008415 c=0
Rk17 (\4\:Y Y) resistor r=0.01657 c=0
Rk16 (\2\:Y \4\:Y) resistor r=0.4069 c=0
Rk1 (A0 \4\:A0) resistor r=0.02361 c=0
Rk10 (\4\:B0 \5\:B0) resistor r=0.01028 c=0
Rk11 (\6\:B0 B0) resistor r=0.01028 c=0
Rk12 (\5\:B0 \6\:B0) resistor r=0.0192 c=0
Rk26 (\4\:VDD VDD) resistor r=0.3003 c=0
Rk25 (\2\:VDD \4\:VDD) resistor r=0.4626 c=0
Rk27 (VDD \6\:VDD) resistor r=0.2804 c=0
Rk5 (\5\:B1 \6\:B1) resistor r=0.005269 c=0
Rk6 (B1 \7\:B1) resistor r=0.005137 c=0
Rk7 (\5\:B1 \7\:B1) resistor r=0.05797 c=0
Rk18 (\2\:VSS \3\:VSS) resistor r=0.0949 c=0
Rk19 (\3\:VSS \4\:VSS) resistor r=0.155 c=0
Rk20 (\4\:VSS \5\:VSS) resistor r=0.2325 c=0
Rk22 (\6\:VSS VSS) resistor r=0.0498 c=0
Rk21 (\5\:VSS \6\:VSS) resistor r=0.06737 c=0
Rk23 (\3\:VSS \8\:VSS) resistor r=0.07311 c=0
Rk24 (\5\:VSS \10\:VSS) resistor r=0.07311 c=0
Rk8 (\2\:net124 \4\:net124) resistor r=0.5039 c=0
Rk9 (\4\:net124 \6\:net124) resistor r=0.2707 c=0
Rk13 (\5\:net128 \6\:net128) resistor r=0.2724 c=0
Rk14 (\6\:net128 \8\:net128) resistor r=0.526 c=0
Rk15 (\6\:net128 \10\:net128) resistor r=0.1688 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=47.2519 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=131.867 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=153.021 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=26.098 c=0
Rl8 (\1\:B0 \2\:B0) resistor r=31.461 c=0
Rl9 (\2\:B0 \3\:B0) resistor r=154.538 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=64.2642 c=0
Rl7 (\2\:B1 \4\:B1) resistor r=137.341 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=1.8551 c=0
Rl10 (net128 \2\:net128) resistor r=72.791 c=0
Rl12 (\2\:net128 \4\:net128) resistor r=38.1757 c=0
Rl11 (\2\:net128 \3\:net128) resistor r=0.5166 c=0
Rz5 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz7 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz1 (net124 \2\:net124) resistor r=75 c=0
Rz2 (\3\:net124 \4\:net124) resistor r=75 c=0
Rz3 (\5\:net124 \6\:net124) resistor r=75 c=0
Rz4 (\9\:net128 \10\:net128) resistor r=75 c=0
Ry2 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry6 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry7 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry3 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry4 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry5 (\1\:VSS \6\:VSS) resistor r=31 c=0
Ry1 (\7\:net128 \8\:net128) resistor r=62 c=0
Rx2 (\2\:A1 \6\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx3 (\3\:B1 \6\:B1) resistor r=45 c=0
Rx5 (\3\:net128 \5\:net128) resistor r=45 c=0
mn0 (\5\:net124 \3\:A0 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.715e-14 ad=2.03e-14 ps=1.41e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn1 (\3\:net124 \3\:A1 \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.715e-14 ad=2.32e-14 ps=1.41e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn3 (\9\:net128 \4\:B1 \3\:net124 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn2 (\9\:net128 \3\:B0 net124 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn4 (\3\:Y \4\:net128 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.89e-14 ad=3.64e-14 ps=1.44e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=14.4034 scb=0.0144248 \
        scc=0.00102063 m=(1)
mp1 (\7\:net128 \1\:A1 net119 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.225e-14 ad=3.44e-14 ps=7.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=9.15e-07 sd=160n sca=15.1901 \
        scb=0.0142438 scc=0.000270537 m=(1)
mp3 (\7\:net128 \1\:B1 net115 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=7.1e-07 sd=160n sca=13.0859 \
        scb=0.0105161 scc=0.000221881 m=(1)
mp2 (net115 \1\:B0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=3.44e-14 ps=1.42e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.45e-07 sb=5.05e-07 sd=160n sca=13.1252 \
        scb=0.0105805 scc=0.000222119 m=(1)
mp4 (\1\:Y net128 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=5.46e-14 ps=1.42e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.56795e-07 sb=1.4e-07 sd=160n sca=31.7169 \
        scb=0.0333373 scc=0.002913 m=(1)
ends OA22X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:20:27 2012 )
// Library name: gsclib045
// Cell name: OAI211X1
// View name: extracted

simulator lang=spectre

subckt OAI211X1 A0 A1 B0 C0 VDD VSS Y
mp0 (n2 \1\:A0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.3e-07 sd=160n sca=26.0122 \
        scb=0.0294337 scc=0.00173965 m=(1)
C1 (Y VSS) capacitor c=3.34454e-17
C2 (VDD VSS) capacitor c=8.74289e-17
C3 (C0 VSS) capacitor c=7.62507e-17
C4 (n1 VSS) capacitor c=5.9525e-17
C5 (n0 VSS) capacitor c=3.39295e-18
C6 (\1\:C0 VSS) capacitor c=4.91214e-17
C7 (\3\:B0 VSS) capacitor c=5.18131e-17
C8 (\3\:A1 VSS) capacitor c=8.6448e-17
C9 (\1\:A0 VSS) capacitor c=6.29686e-17
C10 (\3\:C0 VSS) capacitor c=4.2044e-17
C11 (\1\:B0 VSS) capacitor c=5.4932e-17
C12 (\1\:A1 VSS) capacitor c=4.71955e-17
C13 (\4\:A0 VSS) capacitor c=5.4425e-17
C14 (\2\:C0 VSS) capacitor c=5.0634e-17
C15 (\2\:B0 VSS) capacitor c=5.78918e-17
C16 (\2\:A1 VSS) capacitor c=6.60025e-17
C17 (\3\:A0 VSS) capacitor c=1.44632e-17
C18 (\1\:VDD VSS) capacitor c=6.32746e-17
C19 (\4\:Y VSS) capacitor c=7.30896e-17
C20 (\5\:VDD VSS) capacitor c=3.82612e-17
C21 (\1\:Y VSS) capacitor c=8.48571e-17
C22 (\3\:n1 VSS) capacitor c=3.87351e-17
C23 (\2\:A0 VSS) capacitor c=4.98784e-17
C24 (\5\:A0 VSS) capacitor c=2.84633e-17
C25 (\7\:A0 VSS) capacitor c=2.71305e-17
C26 (\4\:A1 VSS) capacitor c=3.2148e-17
C27 (\6\:A1 VSS) capacitor c=3.58791e-17
C28 (\4\:B0 VSS) capacitor c=5.04094e-17
C29 (\5\:B0 VSS) capacitor c=5.31996e-17
C30 (\4\:C0 VSS) capacitor c=6.67667e-17
C31 (\3\:Y VSS) capacitor c=6.38463e-17
C32 (\4\:VDD VSS) capacitor c=3.08158e-17
Rk14 (\3\:Y Y) resistor r=0.1013 c=0
Rk12 (\2\:Y \3\:Y) resistor r=0.5242 c=0
Rk13 (\3\:Y \5\:Y) resistor r=0.3771 c=0
Rk15 (Y \7\:Y) resistor r=0.01164 c=0
Rk8 (B0 \4\:B0) resistor r=0.0105 c=0
Rk10 (\4\:B0 \5\:B0) resistor r=0.05693 c=0
Rk9 (\5\:B0 \6\:B0) resistor r=0.01062 c=0
Rk4 (\4\:A1 \5\:A1) resistor r=0.004734 c=0
Rk5 (A1 \6\:A1) resistor r=0.004599 c=0
Rk6 (\4\:A1 \6\:A1) resistor r=0.05081 c=0
Rk20 (\3\:VSS VSS) resistor r=0.1024 c=0
Rk21 (\3\:VSS \5\:VSS) resistor r=0.1814 c=0
Rk17 (\4\:VDD VDD) resistor r=0.2007 c=0
Rk16 (\2\:VDD \4\:VDD) resistor r=0.3526 c=0
Rk18 (VDD \6\:VDD) resistor r=0.2435 c=0
Rk11 (\4\:C0 C0) resistor r=0.1732 c=0
Rk1 (\5\:A0 \6\:A0) resistor r=0.002117 c=0
Rk2 (A0 \7\:A0) resistor r=0.001975 c=0
Rk3 (\5\:A0 \7\:A0) resistor r=0.04803 c=0
Rk7 (\2\:n1 \4\:n1) resistor r=0.2718 c=0
Rl7 (\2\:B0 \3\:B0) resistor r=76.903 c=0
Rl6 (\1\:B0 \2\:B0) resistor r=110.307 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=101.718 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=86.5156 c=0
Rl8 (\1\:C0 \2\:C0) resistor r=89.6174 c=0
Rl9 (\2\:C0 \3\:C0) resistor r=97.3098 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=34.3295 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=172.791 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=5.9102 c=0
Rz3 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz5 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz1 (n1 \2\:n1) resistor r=75 c=0
Rz2 (\3\:n1 \4\:n1) resistor r=75 c=0
Ry1 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry2 (\6\:Y \7\:Y) resistor r=20.6667 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry4 (\5\:VDD \6\:VDD) resistor r=31 c=0
Rx3 (\2\:B0 \6\:B0) resistor r=45 c=0
Rx2 (\2\:A1 \5\:A1) resistor r=45 c=0
Rx4 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx1 (\3\:A0 \6\:A0) resistor r=45 c=0
mn0 (\3\:n1 \4\:A0 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.3e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn1 (n1 \1\:A1 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.25e-07 sd=160n sca=8.09546 \
        scb=0.00588493 scc=0.000117119 m=(1)
mn2 (n1 \1\:B0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.51e-14 \
        ad=4.16e-14 ps=7.9e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.5e-07 sb=3.2e-07 sd=160n sca=8.09546 scb=0.00588493 \
        scc=0.000117119 m=(1)
mn3 (\1\:Y \3\:C0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.51e-14 \
        ad=3.64e-14 ps=7.9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 sa=7.3e-07 \
        sb=1.4e-07 sd=160n sca=8.09546 scb=0.00588493 scc=0.000117119 \
        m=(1)
mp1 (\4\:Y \3\:A1 n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=9.165e-14 ps=9e-07 pd=1.25e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=6.25e-07 sd=160n sca=19.2311 scb=0.0199775 \
        scc=0.000575468 m=(1)
mp2 (\4\:Y \3\:B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=9.165e-14 ps=1.1e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=3.45e-07 sd=160n sca=16.9088 \
        scb=0.0154331 scc=0.000373012 m=(1)
mp3 (\6\:Y \1\:C0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.4e-07 sd=160n sca=25.4829 \
        scb=0.0288592 scc=0.00163037 m=(1)
ends OAI211X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:21:12 2012 )
// Library name: gsclib045
// Cell name: OAI221X1
// View name: extracted

simulator lang=spectre

subckt OAI221X1 A0 A1 B0 B1 C0 VDD VSS Y
mp0 (net115 \1\:A0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.2e-07 sd=160n sca=20.0914 \
        scb=0.0223631 scc=0.000753507 m=(1)
C1 (C0 VSS) capacitor c=4.50596e-17
C2 (A1 VSS) capacitor c=1.81179e-17
C3 (A0 VSS) capacitor c=1.78216e-17
C4 (Y VSS) capacitor c=4.53565e-18
C5 (B0 VSS) capacitor c=4.65606e-17
C6 (B1 VSS) capacitor c=6.91485e-17
C7 (VDD VSS) capacitor c=1.22987e-16
C8 (net132 VSS) capacitor c=1.12939e-16
C9 (net128 VSS) capacitor c=4.88827e-17
C10 (net115 VSS) capacitor c=1.40103e-18
C11 (net123 VSS) capacitor c=2.6962e-18
C12 (\3\:C0 VSS) capacitor c=4.66444e-17
C13 (\3\:B0 VSS) capacitor c=9.67493e-17
C14 (\1\:B1 VSS) capacitor c=7.82903e-17
C15 (\1\:A1 VSS) capacitor c=6.27412e-17
C16 (\1\:A0 VSS) capacitor c=7.42135e-17
C17 (\1\:C0 VSS) capacitor c=3.28921e-17
C18 (\1\:B0 VSS) capacitor c=3.85439e-17
C19 (\3\:B1 VSS) capacitor c=5.05151e-17
C20 (\3\:A1 VSS) capacitor c=5.22917e-17
C21 (\3\:A0 VSS) capacitor c=3.39197e-17
C22 (\2\:C0 VSS) capacitor c=3.96263e-17
C23 (\2\:B0 VSS) capacitor c=6.09671e-17
C24 (\2\:B1 VSS) capacitor c=5.01819e-17
C25 (\2\:A1 VSS) capacitor c=4.75032e-17
C26 (\2\:A0 VSS) capacitor c=4.88472e-17
C27 (\4\:Y VSS) capacitor c=5.35894e-17
C28 (\1\:VDD VSS) capacitor c=6.26183e-17
C29 (\6\:Y VSS) capacitor c=7.30941e-17
C30 (\7\:VDD VSS) capacitor c=2.44727e-17
C31 (\3\:VDD VSS) capacitor c=4.38979e-17
C32 (\1\:Y VSS) capacitor c=6.29074e-17
C33 (\3\:net128 VSS) capacitor c=6.27213e-17
C34 (\3\:net132 VSS) capacitor c=3.98705e-17
C35 (\4\:A0 VSS) capacitor c=2.04777e-17
C36 (\4\:A1 VSS) capacitor c=2.73473e-17
C37 (\4\:B0 VSS) capacitor c=4.17075e-17
C38 (\4\:C0 VSS) capacitor c=6.01573e-17
C39 (\3\:Y VSS) capacitor c=8.8101e-17
Rk7 (C0 \4\:C0) resistor r=0.1175 c=0
Rk2 (\4\:A1 A1) resistor r=0.04077 c=0
Rk1 (\4\:A0 A0) resistor r=0.0408 c=0
Rk9 (\3\:Y Y) resistor r=0.03094 c=0
Rk8 (\2\:Y \3\:Y) resistor r=0.3302 c=0
Rk10 (Y \5\:Y) resistor r=0.01294 c=0
Rk11 (\3\:Y \7\:Y) resistor r=0.5051 c=0
Rk17 (\2\:VSS \3\:VSS) resistor r=0.2344 c=0
Rk19 (\4\:VSS VSS) resistor r=0.05048 c=0
Rk18 (\3\:VSS \4\:VSS) resistor r=0.1141 c=0
Rk20 (VSS \6\:VSS) resistor r=0.08738 c=0
Rk21 (\3\:VSS \8\:VSS) resistor r=0.06833 c=0
Rk5 (B0 \4\:B0) resistor r=0.0569 c=0
Rk3 (\4\:B1 B1) resistor r=0.002995 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.3 c=0
Rk14 (\5\:VDD VDD) resistor r=0.02963 c=0
Rk13 (\4\:VDD \5\:VDD) resistor r=0.3206 c=0
Rk16 (\5\:VDD \8\:VDD) resistor r=0.2263 c=0
Rk4 (\2\:net132 \4\:net132) resistor r=0.4182 c=0
Rk6 (\2\:net128 \4\:net128) resistor r=0.3041 c=0
Rl10 (\2\:C0 \3\:C0) resistor r=82.6695 c=0
Rl9 (\1\:C0 \2\:C0) resistor r=55.5643 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=29.5379 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=110.307 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=78.8233 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=59.4104 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=119.964 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=26.9231 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=79.5379 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=60.3072 c=0
Rz5 (\1\:Y \2\:Y) resistor r=75 c=0
Rz8 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz9 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz7 (\3\:VDD VDD) resistor r=75 c=0
Rz6 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz1 (net132 \2\:net132) resistor r=75 c=0
Rz2 (\3\:net132 \4\:net132) resistor r=75 c=0
Rz3 (net128 \2\:net128) resistor r=75 c=0
Rz4 (\3\:net128 \4\:net128) resistor r=75 c=0
Ry1 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry2 (\6\:Y \7\:Y) resistor r=31 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=12.4 c=0
Ry6 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=31 c=0
Rx5 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
mn0 (\3\:net132 \3\:A0 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.39e-14 ad=4.16e-14 ps=1.5e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.05e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn1 (\3\:net132 \3\:A1 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.56e-14 ad=4.16e-14 ps=1.52e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn3 (net132 \3\:B1 \3\:net128 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn2 (net132 \1\:B0 net128 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn4 (\1\:Y \1\:C0 net128 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mp1 (\6\:Y \1\:A1 net115 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=1.248e-13 ps=9e-07 pd=1.42e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=8.15e-07 sd=160n sca=15.9166 \
        scb=0.0154749 scc=0.000316749 m=(1)
mp3 (\6\:Y \1\:B1 net123 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=1.248e-13 ps=9e-07 pd=1.42e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=4.5e-07 sd=160n sca=12.9574 \
        scb=0.0102588 scc=0.000232318 m=(1)
mp2 (net123 \3\:B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=3.45e-07 sd=160n sca=13.2989 \
        scb=0.010817 scc=0.000234376 m=(1)
mp4 (\4\:Y \3\:C0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=1.4e-07 sd=160n sca=16.1834 \
        scb=0.0159482 scc=0.0003331 m=(1)
ends OAI221X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:22:00 2012 )
// Library name: gsclib045
// Cell name: OAI222X1
// View name: extracted

simulator lang=spectre

subckt OAI222X1 A0 A1 B0 B1 C0 C1 VDD VSS Y
mp0 (n2 \1\:A0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.13e-06 sd=160n sca=19.3961 \
        scb=0.0212947 scc=0.000662871 m=(1)
C1 (A0 VSS) capacitor c=2.43623e-17
C2 (B0 VSS) capacitor c=5.22226e-17
C3 (C1 VSS) capacitor c=2.03038e-17
C4 (Y VSS) capacitor c=2.35658e-17
C5 (A1 VSS) capacitor c=4.78962e-17
C6 (VDD VSS) capacitor c=1.23367e-16
C7 (n0 VSS) capacitor c=9.57779e-17
C8 (n1 VSS) capacitor c=6.29072e-17
C9 (n2 VSS) capacitor c=1.65716e-18
C10 (n3 VSS) capacitor c=6.31835e-18
C11 (n4 VSS) capacitor c=2.99166e-18
C12 (\3\:C1 VSS) capacitor c=7.45055e-17
C13 (\1\:C0 VSS) capacitor c=1.04222e-16
C14 (\1\:B0 VSS) capacitor c=5.47956e-17
C15 (\1\:B1 VSS) capacitor c=4.52187e-17
C16 (\1\:A1 VSS) capacitor c=7.39982e-17
C17 (\1\:A0 VSS) capacitor c=6.19371e-17
C18 (\1\:C1 VSS) capacitor c=4.34716e-17
C19 (\3\:C0 VSS) capacitor c=4.15718e-17
C20 (\3\:B0 VSS) capacitor c=5.53159e-17
C21 (\3\:B1 VSS) capacitor c=5.04392e-17
C22 (\3\:A1 VSS) capacitor c=4.378e-17
C23 (\3\:A0 VSS) capacitor c=4.39191e-17
C24 (\2\:C1 VSS) capacitor c=6.12696e-17
C25 (\2\:C0 VSS) capacitor c=5.93779e-17
C26 (\2\:B0 VSS) capacitor c=5.84186e-17
C27 (\2\:B1 VSS) capacitor c=4.87008e-17
C28 (\2\:A1 VSS) capacitor c=4.1755e-17
C29 (\2\:A0 VSS) capacitor c=4.699e-17
C30 (\6\:Y VSS) capacitor c=3.01102e-17
C31 (\1\:VDD VSS) capacitor c=5.27873e-17
C32 (\4\:Y VSS) capacitor c=1.17026e-16
C33 (\7\:VDD VSS) capacitor c=2.92755e-17
C34 (\3\:VDD VSS) capacitor c=6.01362e-17
C35 (\1\:Y VSS) capacitor c=1.04101e-16
C36 (\3\:n1 VSS) capacitor c=7.99084e-17
C37 (\5\:n1 VSS) capacitor c=6.64271e-17
C38 (\3\:n0 VSS) capacitor c=5.2109e-17
C39 (\4\:A0 VSS) capacitor c=5.99845e-17
C40 (\4\:A1 VSS) capacitor c=1.06857e-16
C41 (\4\:B1 VSS) capacitor c=1.1347e-16
C42 (\4\:B0 VSS) capacitor c=3.97717e-17
C43 (\4\:C0 VSS) capacitor c=5.09448e-17
C44 (\5\:C0 VSS) capacitor c=3.90843e-17
C45 (\4\:C1 VSS) capacitor c=3.91621e-17
C46 (\3\:Y VSS) capacitor c=1.11214e-16
C47 (\5\:VDD VSS) capacitor c=1.64665e-17
Rk1 (\4\:A0 A0) resistor r=0.03923 c=0
Rk5 (B0 \4\:B0) resistor r=0.1139 c=0
Rk3 (B1 \4\:B1) resistor r=0.00365 c=0
Rk9 (C1 \4\:C1) resistor r=0.01123 c=0
Rk12 (\2\:Y \3\:Y) resistor r=0.5951 c=0
Rk13 (\3\:Y \5\:Y) resistor r=0.6465 c=0
Rk15 (\7\:Y Y) resistor r=0.06034 c=0
Rk14 (\3\:Y \7\:Y) resistor r=0.06822 c=0
Rk22 (\3\:VSS VSS) resistor r=0.1751 c=0
Rk23 (VSS \5\:VSS) resistor r=0.07638 c=0
Rk24 (\3\:VSS \7\:VSS) resistor r=0.05844 c=0
Rk6 (C0 \4\:C0) resistor r=0.003363 c=0
Rk8 (\4\:C0 \5\:C0) resistor r=0.09016 c=0
Rk7 (\5\:C0 \6\:C0) resistor r=0.003462 c=0
Rk2 (A1 \4\:A1) resistor r=0.1575 c=0
Rk16 (\2\:VDD \4\:VDD) resistor r=0.3047 c=0
Rk18 (\5\:VDD VDD) resistor r=0.03721 c=0
Rk17 (\4\:VDD \5\:VDD) resistor r=0.3639 c=0
Rk20 (\5\:VDD \8\:VDD) resistor r=0.2435 c=0
Rk4 (\2\:n0 \4\:n0) resistor r=0.5007 c=0
Rk10 (\2\:n1 \4\:n1) resistor r=0.3063 c=0
Rk11 (\4\:n1 \6\:n1) resistor r=0.3082 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=30.7692 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=110.372 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=72.2519 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=122.252 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=75.6918 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=125.692 c=0
Rl12 (\2\:C1 \3\:C1) resistor r=78.9444 c=0
Rl11 (\1\:C1 \2\:C1) resistor r=126.923 c=0
Rl9 (\1\:C0 \2\:C0) resistor r=152.615 c=0
Rl10 (\2\:C0 \3\:C0) resistor r=48.7687 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=79.9442 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=49.1749 c=0
Rz6 (\1\:Y \2\:Y) resistor r=75 c=0
Rz9 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz10 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz8 (\3\:VDD VDD) resistor r=75 c=0
Rz7 (\3\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz1 (n0 \2\:n0) resistor r=75 c=0
Rz2 (\3\:n0 \4\:n0) resistor r=75 c=0
Rz3 (n1 \2\:n1) resistor r=75 c=0
Rz4 (\3\:n1 \4\:n1) resistor r=75 c=0
Rz5 (\5\:n1 \6\:n1) resistor r=75 c=0
Ry1 (\4\:Y \5\:Y) resistor r=31 c=0
Ry2 (\6\:Y \7\:Y) resistor r=31 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=31 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=31 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx3 (\2\:B1 \4\:B1) resistor r=45 c=0
Rx6 (\2\:C1 \4\:C1) resistor r=45 c=0
Rx5 (\2\:C0 \6\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (\3\:n0 \3\:A0 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.25e-14 ad=4.16e-14 ps=1.5e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.1e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mn1 (\3\:n0 \3\:A1 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.465e-14 ad=4.16e-14 ps=1.5e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1.05e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3 (n0 \3\:B1 \5\:n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn2 (n0 \3\:B0 \3\:n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.5e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn4 (\1\:Y \3\:C0 \3\:n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.45e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(1)
mn5 (\1\:Y \1\:C1 n1 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.64e-14 \
        ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.55e-07 sb=1.4e-07 sd=160n sca=7.84363 scb=0.00546499 \
        scc=9.84911e-05 m=(1)
mp1 (\4\:Y \1\:A1 n2 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=1.2675e-13 ps=9e-07 pd=1.43e-06 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.025e-06 sd=160n sca=15.6981 scb=0.0150296 \
        scc=0.000323375 m=(1)
mp3 (\4\:Y \1\:B1 n3 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=1.2675e-13 ps=1.1e-06 pd=1.43e-06 nrd=1.16667 nrs=1.16667 \
        sa=6.15e-07 sb=6.55e-07 sd=160n sca=12.3518 scb=0.0100158 \
        scc=0.000258343 m=(1)
mp2 (n3 \1\:B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.2e-07 sb=4.5e-07 sd=160n sca=12.6156 \
        scb=0.0103368 scc=0.000258831 m=(1)
mp4 (n4 \1\:C0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=2.45e-07 sd=160n sca=14.6264 \
        scb=0.0131608 scc=0.000282649 m=(1)
mp5 (\6\:Y \3\:C1 n4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.13e-06 sb=1.4e-07 sd=160n sca=17.0903 scb=0.0174873 \
        scc=0.00041511 m=(1)
ends OAI222X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:22:48 2012 )
// Library name: gsclib045
// Cell name: OAI222XL
// View name: extracted

simulator lang=spectre

subckt OAI222XL A0 A1 B0 B1 C0 C1 VDD VSS Y
mp0 (n2 \1\:A0 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.15e-06 sd=160n sca=18.9152 \
        scb=0.020298 scc=0.000602167 m=(1)
C1 (A0 VSS) capacitor c=1.6562e-17
C2 (B0 VSS) capacitor c=8.60494e-17
C3 (C1 VSS) capacitor c=4.01545e-17
C4 (Y VSS) capacitor c=7.07863e-17
C5 (C0 VSS) capacitor c=5.0151e-17
C6 (VDD VSS) capacitor c=1.7419e-16
C7 (n0 VSS) capacitor c=9.73681e-17
C8 (n1 VSS) capacitor c=9.57211e-17
C9 (n3 VSS) capacitor c=3.04162e-18
C10 (n4 VSS) capacitor c=1.35183e-18
C11 (\3\:C1 VSS) capacitor c=7.01833e-17
C12 (\1\:C0 VSS) capacitor c=7.43524e-17
C13 (\3\:B0 VSS) capacitor c=5.13574e-17
C14 (\1\:B1 VSS) capacitor c=3.77975e-17
C15 (\1\:A1 VSS) capacitor c=6.94768e-17
C16 (\1\:A0 VSS) capacitor c=4.80177e-17
C17 (\1\:C1 VSS) capacitor c=3.0848e-17
C18 (\3\:C0 VSS) capacitor c=3.61428e-17
C19 (\1\:B0 VSS) capacitor c=3.58932e-17
C20 (\3\:B1 VSS) capacitor c=4.45788e-17
C21 (\3\:A1 VSS) capacitor c=3.65323e-17
C22 (\3\:A0 VSS) capacitor c=4.68054e-17
C23 (\2\:C1 VSS) capacitor c=6.62292e-17
C24 (\2\:C0 VSS) capacitor c=7.17833e-17
C25 (\2\:B0 VSS) capacitor c=6.01441e-17
C26 (\2\:B1 VSS) capacitor c=5.13752e-17
C27 (\2\:A1 VSS) capacitor c=4.4655e-17
C28 (\2\:A0 VSS) capacitor c=5.5328e-17
C29 (\3\:Y VSS) capacitor c=7.36874e-17
C30 (\1\:VDD VSS) capacitor c=3.81778e-17
C31 (\5\:Y VSS) capacitor c=1.03638e-16
C32 (\7\:VDD VSS) capacitor c=1.96885e-17
C33 (\3\:VDD VSS) capacitor c=4.02758e-17
C34 (\5\:n1 VSS) capacitor c=7.00787e-17
C35 (\1\:Y VSS) capacitor c=1.0539e-16
C36 (\3\:n1 VSS) capacitor c=1.13791e-16
C37 (\3\:n0 VSS) capacitor c=5.98786e-17
C38 (\4\:A0 VSS) capacitor c=2.21635e-17
C39 (\5\:A1 VSS) capacitor c=1.34572e-17
C40 (\6\:A1 VSS) capacitor c=3.71958e-17
C41 (\4\:B1 VSS) capacitor c=8.25153e-17
C42 (\6\:B1 VSS) capacitor c=4.10578e-17
C43 (\4\:B0 VSS) capacitor c=4.46002e-17
C44 (\4\:C0 VSS) capacitor c=7.07e-17
C45 (\4\:C1 VSS) capacitor c=7.43981e-17
Rk1 (A0 \4\:A0) resistor r=0.03137 c=0
Rk9 (\4\:B0 B0) resistor r=0.01901 c=0
Rk5 (\4\:B1 \5\:B1) resistor r=0.002784 c=0
Rk6 (B1 \6\:B1) resistor r=0.002691 c=0
Rk7 (\4\:B1 \6\:B1) resistor r=0.02706 c=0
Rk11 (C1 \4\:C1) resistor r=0.1316 c=0
Rk12 (\2\:Y Y) resistor r=0.6481 c=0
Rk13 (Y \4\:Y) resistor r=0.04934 c=0
Rk14 (\4\:Y \6\:Y) resistor r=0.5229 c=0
Rk22 (\2\:VSS \3\:VSS) resistor r=0.3012 c=0
Rk24 (\4\:VSS VSS) resistor r=0.1003 c=0
Rk23 (\3\:VSS \4\:VSS) resistor r=0.1006 c=0
Rk26 (\3\:VSS \7\:VSS) resistor r=0.1201 c=0
Rk27 (VSS \9\:VSS) resistor r=0.1008 c=0
Rk10 (C0 \4\:C0) resistor r=0.1479 c=0
Rk2 (\4\:A1 \5\:A1) resistor r=0.004738 c=0
Rk3 (\6\:A1 A1) resistor r=0.004738 c=0
Rk4 (\5\:A1 \6\:A1) resistor r=0.03868 c=0
Rk17 (\2\:VDD \4\:VDD) resistor r=0.2171 c=0
Rk19 (\5\:VDD VDD) resistor r=0.02964 c=0
Rk18 (\4\:VDD \5\:VDD) resistor r=0.3709 c=0
Rk21 (\5\:VDD \8\:VDD) resistor r=0.224 c=0
Rk8 (\2\:n0 \4\:n0) resistor r=0.6051 c=0
Rk15 (\2\:n1 \4\:n1) resistor r=0.4682 c=0
Rk16 (\4\:n1 \6\:n1) resistor r=0.4818 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=42.2849 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=163.257 c=0
Rl8 (\2\:B0 \3\:B0) resistor r=129.538 c=0
Rl7 (\1\:B0 \2\:B0) resistor r=74.9799 c=0
Rl5 (\1\:B1 \2\:B1) resistor r=59.6085 c=0
Rl6 (\2\:B1 \3\:B1) resistor r=142.301 c=0
Rl12 (\2\:C1 \3\:C1) resistor r=136.146 c=0
Rl11 (\1\:C1 \2\:C1) resistor r=78.8462 c=0
Rl9 (\1\:C0 \2\:C0) resistor r=133.79 c=0
Rl10 (\2\:C0 \3\:C0) resistor r=66.4826 c=0
Rl3 (\1\:A1 \2\:A1) resistor r=127.615 c=0
Rl4 (\2\:A1 \3\:A1) resistor r=79.5379 c=0
Rz3 (\1\:Y \2\:Y) resistor r=75 c=0
Rz9 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz10 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz8 (\3\:VDD VDD) resistor r=75 c=0
Rz7 (\3\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz1 (n0 \2\:n0) resistor r=75 c=0
Rz2 (\3\:n0 \4\:n0) resistor r=75 c=0
Rz4 (n1 \2\:n1) resistor r=75 c=0
Rz5 (\3\:n1 \4\:n1) resistor r=75 c=0
Rz6 (\5\:n1 \6\:n1) resistor r=75 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Ry2 (\5\:Y \6\:Y) resistor r=62 c=0
Ry8 (\1\:VSS VSS) resistor r=62 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=12.4 c=0
Ry6 (\1\:VSS \3\:VSS) resistor r=62 c=0
Ry7 (\1\:VSS \4\:VSS) resistor r=62 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=62 c=0
Rx1 (\2\:A0 \4\:A0) resistor r=45 c=0
Rx4 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx3 (\2\:B1 \5\:B1) resistor r=45 c=0
Rx6 (\2\:C1 \4\:C1) resistor r=45 c=0
Rx5 (\2\:C0 \4\:C0) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
mn0 (\3\:n0 \3\:A0 \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.09e-14 ad=2.32e-14 ps=1.35e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.05e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn1 (\3\:n0 \3\:A1 \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.09e-14 ad=2.32e-14 ps=1.35e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn3 (n0 \3\:B1 n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.03e-14 \
        ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.85e-07 sd=160n sca=13.9854 scb=0.014728 \
        scc=0.000819645 m=(1)
mn2 (n0 \1\:B0 \3\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.32e-14 ps=6.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.8e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn4 (\1\:Y \3\:C0 \3\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.392e-14 ps=6.6e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=3.5e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn5 (\1\:Y \1\:C1 \5\:n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.392e-14 ps=5.7e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=1.4e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mp1 (\5\:Y \1\:A1 n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.88e-14 ps=5.5e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.045e-06 sd=160n sca=14.7404 \
        scb=0.0134098 scc=0.000165408 m=(1)
mp3 (\5\:Y \1\:B1 n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=6.88e-14 ps=7e-07 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=6.8e-07 sd=160n sca=11.0531 \
        scb=0.00777426 scc=8.06272e-05 m=(1)
mp2 (n3 \3\:B0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=2.903e-14 ps=8.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=5e-07 sd=160n sca=11.1457 scb=0.00788341 \
        scc=8.07632e-05 m=(1)
mp4 (n4 \1\:C0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=1.29e-14 ps=8.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=2.45e-07 sd=160n sca=13.3848 \
        scb=0.0110305 scc=0.000107196 m=(1)
mp5 (\3\:Y \3\:C1 n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=1.4e-07 sd=160n sca=15.9357 \
        scb=0.0155108 scc=0.000251633 m=(1)
ends OAI222XL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:23:35 2012 )
// Library name: gsclib045
// Cell name: OAI2BB1X1
// View name: extracted

simulator lang=spectre

subckt OAI2BB1X1 A0N A1N B0 VDD VSS Y
mp3 (\1\:Y \3\:n0 \7\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.31026e-07 sd=160n sca=33.0928 \
        scb=0.0355004 scc=0.00312201 m=(1)
C1 (A0N VSS) capacitor c=8.84019e-17
C2 (B0 VSS) capacitor c=5.19126e-17
C3 (VDD VSS) capacitor c=7.47073e-17
C4 (A1N VSS) capacitor c=4.26802e-17
C5 (Y VSS) capacitor c=6.07664e-17
C6 (n0 VSS) capacitor c=5.77466e-17
C7 (\1\:A1N VSS) capacitor c=4.42846e-17
C8 (\3\:A0N VSS) capacitor c=5.06226e-17
C9 (\1\:B0 VSS) capacitor c=6.02141e-17
C10 (\3\:n0 VSS) capacitor c=4.36399e-17
C11 (\3\:A1N VSS) capacitor c=5.25362e-17
C12 (\1\:A0N VSS) capacitor c=6.55052e-17
C13 (\3\:B0 VSS) capacitor c=7.64891e-17
C14 (\4\:A1N VSS) capacitor c=1.27107e-17
C15 (\2\:A0N VSS) capacitor c=6.30152e-17
C16 (\2\:B0 VSS) capacitor c=5.31515e-17
C17 (\2\:n0 VSS) capacitor c=5.19716e-17
C18 (\1\:VDD VSS) capacitor c=3.55973e-18
C19 (\4\:n0 VSS) capacitor c=6.20868e-17
C20 (\9\:VDD VSS) capacitor c=4.54146e-17
C21 (\1\:Y VSS) capacitor c=1.278e-16
C22 (\7\:VDD VSS) capacitor c=5.09303e-17
C23 (\3\:VDD VSS) capacitor c=1.95459e-17
C24 (\8\:n0 VSS) capacitor c=4.31601e-17
C25 (\3\:Y VSS) capacitor c=4.53076e-17
C26 (\2\:A1N VSS) capacitor c=4.47144e-17
C27 (\4\:B0 VSS) capacitor c=5.49366e-17
C28 (\4\:A0N VSS) capacitor c=5.31363e-17
C29 (\6\:n0 VSS) capacitor c=1.26319e-16
C30 (\7\:n0 VSS) capacitor c=8.27662e-17
C31 (\7\:A1N VSS) capacitor c=5.22702e-17
C32 (\5\:VDD VSS) capacitor c=8.35058e-18
Rk4 (\4\:A0N A0N) resistor r=0.1281 c=0
Rk18 (\4\:VSS VSS) resistor r=0.2007 c=0
Rk17 (\2\:VSS \4\:VSS) resistor r=0.3044 c=0
Rk3 (\4\:B0 B0) resistor r=0.1234 c=0
Rk11 (\2\:VDD \4\:VDD) resistor r=0.07834 c=0
Rk12 (\4\:VDD \5\:VDD) resistor r=0.1958 c=0
Rk14 (\6\:VDD VDD) resistor r=0.1508 c=0
Rk13 (\5\:VDD \6\:VDD) resistor r=0.05508 c=0
Rk15 (VDD \8\:VDD) resistor r=0.3287 c=0
Rk16 (\5\:VDD \10\:VDD) resistor r=0.281 c=0
Rk8 (\5\:A1N A1N) resistor r=0.002535 c=0
Rk10 (\5\:A1N \7\:A1N) resistor r=0.03925 c=0
Rk9 (\6\:A1N \7\:A1N) resistor r=0.002438 c=0
Rk1 (\2\:Y Y) resistor r=0.6897 c=0
Rk2 (Y \4\:Y) resistor r=0.04817 c=0
Rk5 (\5\:n0 \6\:n0) resistor r=0.5312 c=0
Rk6 (\6\:n0 \7\:n0) resistor r=0.3644 c=0
Rk7 (\6\:n0 \9\:n0) resistor r=0.1721 c=0
Rl6 (\2\:A0N \3\:A0N) resistor r=92.2876 c=0
Rl5 (\1\:A0N \2\:A0N) resistor r=112.23 c=0
Rl3 (\1\:B0 \2\:B0) resistor r=52.6149 c=0
Rl4 (\2\:B0 \3\:B0) resistor r=87.2302 c=0
Rl7 (\1\:A1N \2\:A1N) resistor r=134.077 c=0
Rl8 (\2\:A1N \3\:A1N) resistor r=86.0481 c=0
Rl9 (\2\:A1N \4\:A1N) resistor r=4.5402 c=0
Rl1 (n0 \2\:n0) resistor r=53.6362 c=0
Rl2 (\2\:n0 \3\:n0) resistor r=89.5604 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz3 (\3\:VDD \4\:VDD) resistor r=75 c=0
Rz4 (\3\:VDD \6\:VDD) resistor r=18.75 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=31 c=0
Ry5 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry2 (\4\:n0 \5\:n0) resistor r=62 c=0
Rx2 (\2\:A0N \4\:A0N) resistor r=45 c=0
Rx1 (\2\:B0 \4\:B0) resistor r=45 c=0
Rx4 (\4\:A1N \6\:A1N) resistor r=45 c=0
Rx3 (\2\:n0 \7\:n0) resistor r=45 c=0
mn3 (\3\:Y n0 n2 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=3.64e-14 ps=6.4e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 sa=1.4e-07 \
        sb=4.45769e-07 sd=160n sca=8.65991 scb=0.00681295 scc=0.000165238 \
        m=(1)
mn2 (n2 \3\:B0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.40769e-07 sd=160n sca=8.65991 \
        scb=0.00681295 scc=0.000165238 m=(1)
mn0 (n1 \1\:A0N \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=8.7e-15 ps=9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=2.65e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn1 (\8\:n0 \3\:A1N n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=1.6e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mp2 (\1\:Y \1\:B0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.26026e-07 sd=160n sca=24.0497 \
        scb=0.0216272 scc=0.0017588 m=(1)
mp0 (\4\:n0 \3\:A0N \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.44e-14 ps=1.1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=3.05e-07 sd=160n sca=16.4198 \
        scb=0.014982 scc=0.000248552 m=(1)
mp1 (\4\:n0 \1\:A1N \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.44e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1e-07 sd=160n sca=27.6521 scb=0.0306729 \
        scc=0.00212413 m=(1)
ends OAI2BB1X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:24:21 2012 )
// Library name: gsclib045
// Cell name: OAI32X1
// View name: extracted

simulator lang=spectre

subckt OAI32X1 A0 A1 A2 B0 B1 VDD VSS Y
mp0 (n2 \1\:A0 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.485e-14 ps=1.06e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.25e-07 sd=160n sca=30.3965 \
        scb=0.0339368 scc=0.00268693 m=(1)
C1 (A2 VSS) capacitor c=5.958e-17
C2 (A1 VSS) capacitor c=5.56388e-17
C3 (Y VSS) capacitor c=2.468e-17
C4 (VDD VSS) capacitor c=8.26706e-17
C5 (A0 VSS) capacitor c=3.54303e-17
C6 (n0 VSS) capacitor c=9.43358e-17
C7 (n2 VSS) capacitor c=7.98026e-18
C8 (n1 VSS) capacitor c=5.42414e-18
C9 (\3\:B0 VSS) capacitor c=7.89868e-17
C10 (\1\:B1 VSS) capacitor c=6.52769e-17
C11 (\4\:A2 VSS) capacitor c=4.20152e-17
C12 (\3\:A1 VSS) capacitor c=4.71145e-17
C13 (\1\:A0 VSS) capacitor c=4.39655e-17
C14 (\1\:B0 VSS) capacitor c=3.05661e-17
C15 (\3\:B1 VSS) capacitor c=5.35683e-17
C16 (\1\:A2 VSS) capacitor c=4.40458e-17
C17 (\1\:A1 VSS) capacitor c=5.03474e-17
C18 (\4\:A0 VSS) capacitor c=4.01942e-17
C19 (\4\:B0 VSS) capacitor c=1.15653e-17
C20 (\2\:B1 VSS) capacitor c=5.22265e-17
C21 (\3\:A2 VSS) capacitor c=4.99611e-17
C22 (\2\:A1 VSS) capacitor c=5.9576e-17
C23 (\3\:A0 VSS) capacitor c=1.34193e-17
C24 (\1\:VDD VSS) capacitor c=5.0103e-17
C25 (\3\:Y VSS) capacitor c=1.38262e-16
C26 (\5\:VDD VSS) capacitor c=5.98643e-17
C27 (\1\:Y VSS) capacitor c=1.1651e-16
C28 (\3\:n0 VSS) capacitor c=1.08506e-16
C29 (\5\:n0 VSS) capacitor c=7.22642e-17
C30 (\2\:A0 VSS) capacitor c=3.21084e-17
C31 (\2\:B0 VSS) capacitor c=2.9228e-17
C32 (\5\:A0 VSS) capacitor c=5.1118e-17
C33 (\4\:A1 VSS) capacitor c=7.35719e-17
C34 (\5\:A2 VSS) capacitor c=7.24368e-17
C35 (\5\:B1 VSS) capacitor c=4.04629e-17
C36 (\6\:B1 VSS) capacitor c=4.42863e-17
C37 (\5\:B0 VSS) capacitor c=1.08873e-16
C38 (\4\:VDD VSS) capacitor c=3.34424e-17
Rk16 (\3\:VSS VSS) resistor r=0.1905 c=0
Rk17 (VSS \5\:VSS) resistor r=0.2789 c=0
Rk18 (\3\:VSS \7\:VSS) resistor r=0.2241 c=0
Rk3 (\5\:A2 A2) resistor r=0.174 c=0
Rk2 (A1 \4\:A1) resistor r=0.2255 c=0
Rk5 (\4\:Y Y) resistor r=0.1562 c=0
Rk4 (\2\:Y \4\:Y) resistor r=0.6299 c=0
Rk11 (B0 \5\:B0) resistor r=0.004147 c=0
Rk13 (\4\:VDD VDD) resistor r=0.301 c=0
Rk12 (\2\:VDD \4\:VDD) resistor r=0.5313 c=0
Rk14 (VDD \6\:VDD) resistor r=0.3525 c=0
Rk6 (\4\:B1 \5\:B1) resistor r=0.0031 c=0
Rk7 (B1 \6\:B1) resistor r=0.0031 c=0
Rk8 (\4\:B1 \6\:B1) resistor r=0.02257 c=0
Rk1 (A0 \5\:A0) resistor r=0.006797 c=0
Rk9 (\2\:n0 \4\:n0) resistor r=0.5778 c=0
Rk10 (\4\:n0 \6\:n0) resistor r=0.4262 c=0
Rl8 (\2\:A2 \4\:A2) resistor r=88.9346 c=0
Rl6 (\1\:A2 \2\:A2) resistor r=71.7177 c=0
Rl7 (\2\:A2 \3\:A2) resistor r=1.2666 c=0
Rl5 (\2\:A1 \3\:A1) resistor r=24.7951 c=0
Rl4 (\1\:A1 \2\:A1) resistor r=105.746 c=0
Rl12 (\2\:B0 \3\:B0) resistor r=117.577 c=0
Rl11 (\1\:B0 \2\:B0) resistor r=26.5731 c=0
Rl13 (\2\:B0 \4\:B0) resistor r=3.8588 c=0
Rl9 (\1\:B1 \2\:B1) resistor r=26.9231 c=0
Rl10 (\2\:B1 \3\:B1) resistor r=106.437 c=0
Rl1 (\1\:A0 \2\:A0) resistor r=41.1873 c=0
Rl3 (\2\:A0 \4\:A0) resistor r=106.572 c=0
Rl2 (\2\:A0 \3\:A0) resistor r=2.4801 c=0
Rz6 (\4\:VSS \5\:VSS) resistor r=37.5 c=0
Rz7 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz2 (n0 \2\:n0) resistor r=37.5 c=0
Rz3 (\3\:n0 \4\:n0) resistor r=37.5 c=0
Rz4 (\5\:n0 \6\:n0) resistor r=37.5 c=0
Ry1 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry3 (\5\:VDD \6\:VDD) resistor r=20.6667 c=0
Rx3 (\3\:A2 \5\:A2) resistor r=45 c=0
Rx2 (\2\:A1 \4\:A1) resistor r=45 c=0
Rx5 (\4\:B0 \5\:B0) resistor r=45 c=0
Rx4 (\2\:B1 \5\:B1) resistor r=45 c=0
Rx1 (\3\:A0 \5\:A0) resistor r=45 c=0
mn0 (\5\:n0 \4\:A0 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.6e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn1 (\5\:n0 \1\:A1 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.55e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn2 (\3\:n0 \1\:A2 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=5.5e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn4 (\1\:Y \3\:B1 \3\:n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=4.16e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=3.45e-07 sd=160n sca=10.104 \
        scb=0.00906063 scc=0.000325539 m=(1)
mn3 (\1\:Y \1\:B0 n0 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.64e-14 \
        ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 sa=9.6e-07 \
        sb=1.4e-07 sd=160n sca=10.104 scb=0.00906063 scc=0.000325539 m=(1)
mp1 (n2 \3\:A1 n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=7.215e-14 \
        ad=4.485e-14 ps=1.15e-06 pd=1.01e-06 nrd=1.16667 nrs=1.16667 \
        sa=3e-07 sb=7.65e-07 sd=160n sca=21.3946 scb=0.02109 \
        scc=0.00137328 m=(1)
mp2 (\3\:Y \4\:A2 n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.215e-14 ad=9.555e-14 ps=1.15e-06 pd=1.27e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=5.35e-07 sd=160n sca=18.501 \
        scb=0.0159575 scc=0.00128203 m=(1)
mp4 (\3\:Y \1\:B1 n4 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=2.34e-14 \
        ad=9.555e-14 ps=9e-07 pd=1.27e-06 nrd=1.16667 nrs=1.16667 \
        sa=8.2e-07 sb=2.45e-07 sd=160n sca=18.9491 scb=0.0167251 \
        scc=0.00128629 m=(1)
mp3 (n4 \3\:B0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.4e-07 sd=160n sca=20.266 \
        scb=0.0190952 scc=0.00131874 m=(1)
ends OAI32X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:25:10 2012 )
// Library name: gsclib045
// Cell name: OR2X1
// View name: extracted

simulator lang=spectre

subckt OR2X1 A B VDD VSS Y
mp1 (\6\:n0 \1\:B n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.8e-07 sd=160n sca=56.6055 \
        scb=0.0430318 scc=0.00645527 m=(1)
C1 (A VSS) capacitor c=7.16644e-17
C2 (B VSS) capacitor c=2.99685e-17
C3 (VDD VSS) capacitor c=4.39096e-17
C4 (Y VSS) capacitor c=4.74405e-17
C5 (n0 VSS) capacitor c=4.43431e-17
C6 (n1 VSS) capacitor c=9.48821e-19
C7 (\3\:A VSS) capacitor c=5.37595e-17
C8 (\1\:B VSS) capacitor c=5.67131e-17
C9 (\3\:n0 VSS) capacitor c=3.93729e-17
C10 (\1\:A VSS) capacitor c=3.74782e-17
C11 (\4\:B VSS) capacitor c=2.76607e-17
C12 (\2\:n0 VSS) capacitor c=3.60314e-17
C13 (\2\:A VSS) capacitor c=4.94166e-17
C14 (\3\:B VSS) capacitor c=1.55855e-17
C15 (\1\:Y VSS) capacitor c=3.4992e-17
C16 (\1\:VDD VSS) capacitor c=8.27373e-17
C17 (\6\:n0 VSS) capacitor c=6.87528e-17
C18 (\3\:Y VSS) capacitor c=4.82441e-17
C19 (\8\:n0 VSS) capacitor c=2.47557e-17
C20 (\2\:B VSS) capacitor c=2.47153e-17
C21 (\5\:B VSS) capacitor c=3.82588e-17
C22 (\4\:A VSS) capacitor c=6.7711e-17
C23 (\4\:n0 VSS) capacitor c=7.64438e-17
C24 (\5\:n0 VSS) capacitor c=6.34048e-17
C25 (\4\:VDD VSS) capacitor c=1.89863e-17
Rk2 (\4\:A A) resistor r=0.1787 c=0
Rk1 (B \5\:B) resistor r=0.04349 c=0
Rk9 (\4\:VDD VDD) resistor r=0.1503 c=0
Rk8 (\2\:VDD \4\:VDD) resistor r=0.4545 c=0
Rk6 (\2\:Y Y) resistor r=0.1673 c=0
Rk7 (Y \4\:Y) resistor r=0.2251 c=0
Rk10 (\2\:VSS VSS) resistor r=0.1107 c=0
Rk11 (VSS \4\:VSS) resistor r=0.1511 c=0
Rk12 (\4\:VSS \6\:VSS) resistor r=0.393 c=0
Rk3 (\4\:n0 \5\:n0) resistor r=0.2897 c=0
Rk4 (\5\:n0 \7\:n0) resistor r=0.3221 c=0
Rk5 (\5\:n0 \9\:n0) resistor r=0.05545 c=0
Rl5 (\2\:A \3\:A) resistor r=26.098 c=0
Rl4 (\1\:A \2\:A) resistor r=43.4057 c=0
Rl1 (\1\:B \2\:B) resistor r=69.5391 c=0
Rl3 (\2\:B \4\:B) resistor r=25.6632 c=0
Rl2 (\2\:B \3\:B) resistor r=9.7447 c=0
Rl6 (n0 \2\:n0) resistor r=41.4826 c=0
Rl7 (\2\:n0 \3\:n0) resistor r=28.0211 c=0
Rz2 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz4 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz5 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz1 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry2 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry1 (\6\:n0 \7\:n0) resistor r=62 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn1 (\8\:n0 \4\:B \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.04e-14 ad=2.32e-14 ps=1.45e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=5.5e-07 sd=160n sca=19.1673 scb=0.0200674 \
        scc=0.00182521 m=(1)
mn0 (\8\:n0 \1\:A \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.32e-14 ps=8.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=3.45e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn2 (\3\:Y \3\:n0 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.28654e-07 sb=1.4e-07 sd=160n sca=14.8545 \
        scb=0.0148797 scc=0.00110433 m=(1)
mp0 (n1 \3\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=1.29e-14 ps=1.16e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.75e-07 sd=160n sca=53.5433 \
        scb=0.0379171 scc=0.00600127 m=(1)
mp2 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.27436e-07 sb=1.4e-07 sd=160n sca=45.5228 \
        scb=0.0401019 scc=0.00476865 m=(1)
ends OR2X1
// End of subcircuit definition.

// Generated for: spectre (May  8 15:25:57 2012 )
// Library name: gsclib045
// Cell name: OR2X2
// View name: extracted

simulator lang=spectre

subckt OR2X2 A B VDD VSS Y
mp1 (\9\:n0 \1\:B n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=2.63e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22326e-07 sb=6.45e-07 sd=160n sca=35.2408 \
        scb=0.036114 scc=0.00353857 m=(1)
C1 (A VSS) capacitor c=6.43959e-17
C2 (B VSS) capacitor c=4.25212e-17
C3 (Y VSS) capacitor c=5.61442e-17
C4 (VDD VSS) capacitor c=5.96457e-17
C5 (n0 VSS) capacitor c=1.56651e-16
C6 (n1 VSS) capacitor c=2.34162e-18
C7 (\1\:A VSS) capacitor c=5.72843e-17
C8 (\1\:B VSS) capacitor c=6.74595e-17
C9 (\3\:A VSS) capacitor c=4.18221e-17
C10 (\4\:B VSS) capacitor c=2.41253e-17
C11 (\2\:A VSS) capacitor c=5.8185e-17
C12 (\3\:B VSS) capacitor c=1.28788e-17
C13 (\1\:VDD VSS) capacitor c=9.50547e-17
C14 (\1\:Y VSS) capacitor c=4.80529e-17
C15 (\9\:n0 VSS) capacitor c=4.44458e-17
C16 (\3\:Y VSS) capacitor c=2.61415e-17
C17 (\11\:n0 VSS) capacitor c=3.54377e-17
C18 (\2\:B VSS) capacitor c=3.55809e-17
C19 (\5\:B VSS) capacitor c=4.8387e-17
C20 (\4\:A VSS) capacitor c=8.63054e-17
C21 (\7\:n0 VSS) capacitor c=7.26079e-17
C22 (\8\:n0 VSS) capacitor c=1.07258e-16
Rk2 (\4\:A A) resistor r=0.1524 c=0
Rk12 (\1\:VSS VSS) resistor r=0.2015 c=0
Rk14 (VSS \8\:VSS) resistor r=0.08493 c=0
Rk1 (B \5\:B) resistor r=0.1051 c=0
Rk6 (\2\:Y Y) resistor r=0.2027 c=0
Rk7 (Y \4\:Y) resistor r=0.2241 c=0
Rk9 (\1\:VDD VDD) resistor r=0.2006 c=0
Rk3 (\7\:n0 \8\:n0) resistor r=0.3016 c=0
Rk4 (\8\:n0 \10\:n0) resistor r=0.3347 c=0
Rk5 (\8\:n0 \12\:n0) resistor r=0.1024 c=0
Rl4 (\1\:A \2\:A) resistor r=48.7687 c=0
Rl5 (\2\:A \3\:A) resistor r=75.6918 c=0
Rl1 (\1\:B \2\:B) resistor r=131.078 c=0
Rl3 (\2\:B \4\:B) resistor r=23.7402 c=0
Rl2 (\2\:B \3\:B) resistor r=5.1011 c=0
Rz6 (\8\:VSS \7\:VSS) resistor r=75 c=0
Rz2 (\4\:Y \3\:Y) resistor r=37.5 c=0
Rz1 (\12\:n0 \11\:n0) resistor r=75 c=0
Ry2 (\2\:Y \1\:Y) resistor r=20.6667 c=0
Ry1 (\10\:n0 \9\:n0) resistor r=62 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
Rx3 (\7\:n0 n0) resistor r=45 c=0
mn1 (\11\:n0 \4\:B \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.28e-14 ad=2.32e-14 ps=1.3e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=7.45e-07 sd=160n sca=12.2839 scb=0.0124725 \
        scc=0.000542081 m=(1)
mn0 (\11\:n0 \3\:A \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=2.32e-14 ps=9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=5.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn2 (\3\:Y n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.521e-14 ad=4.16e-14 ps=1.19e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45385e-07 sb=3.05e-07 sd=160n sca=15.8438 \
        scb=0.0158162 scc=0.00129108 m=(2)
mp0 (n1 \1\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=1.29e-14 ps=1.16e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.27326e-07 sb=5.4e-07 sd=160n sca=31.5798 \
        scb=0.0296345 scc=0.00310241 m=(1)
mp2 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.363e-14 ad=6.24e-14 ps=1.43e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.17692e-07 sb=3.05e-07 sd=160n sca=24.1823 \
        scb=0.0219058 scc=0.0017667 m=(2)
ends OR2X2
// End of subcircuit definition.

// Generated for: spectre (May  8 15:26:51 2012 )
// Library name: gsclib045
// Cell name: OR2X4
// View name: extracted

simulator lang=spectre

subckt OR2X4 A B VDD VSS Y
mp1 (\16\:n0 \1\:B n1 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=5.46e-14 ps=9e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.095e-06 sd=160n sca=18.2281 \
        scb=0.0183524 scc=0.000740229 m=(1)
C1 (A VSS) capacitor c=5.23667e-17
C2 (VDD VSS) capacitor c=1.02521e-16
C3 (Y VSS) capacitor c=3.32752e-17
C4 (B VSS) capacitor c=5.80901e-17
C5 (n0 VSS) capacitor c=3.85994e-16
C6 (n1 VSS) capacitor c=1.04006e-18
C7 (\1\:A VSS) capacitor c=8.1133e-17
C8 (\1\:B VSS) capacitor c=8.7234e-17
C9 (\3\:A VSS) capacitor c=5.09622e-17
C10 (\4\:B VSS) capacitor c=3.4227e-17
C11 (\2\:A VSS) capacitor c=5.72164e-17
C12 (\3\:B VSS) capacitor c=1.36834e-17
C13 (\1\:Y VSS) capacitor c=2.52366e-16
C14 (\16\:n0 VSS) capacitor c=9.9309e-17
C15 (\1\:VDD VSS) capacitor c=3.4562e-17
C16 (\18\:n0 VSS) capacitor c=4.91928e-17
C17 (\2\:B VSS) capacitor c=4.59814e-17
C18 (\5\:B VSS) capacitor c=4.12674e-17
C19 (\4\:A VSS) capacitor c=5.93886e-17
C20 (\15\:n0 VSS) capacitor c=1.05046e-16
C21 (\4\:Y VSS) capacitor c=2.05238e-16
C22 (\3\:VDD VSS) capacitor c=1.96744e-16
Rk2 (\4\:A A) resistor r=0.1336 c=0
Rk13 (\2\:VDD \3\:VDD) resistor r=0.03997 c=0
Rk19 (\8\:VDD VDD) resistor r=0.1002 c=0
Rk18 (\3\:VDD \8\:VDD) resistor r=0.1354 c=0
Rk8 (\1\:Y Y) resistor r=0.1468 c=0
Rk9 (Y \4\:Y) resistor r=0.1025 c=0
Rk1 (\5\:B B) resistor r=0.1316 c=0
Rk23 (\2\:VSS \3\:VSS) resistor r=0.03997 c=0
Rk28 (\3\:VSS \8\:VSS) resistor r=0.08516 c=0
Rk30 (\9\:VSS VSS) resistor r=0.02968 c=0
Rk29 (\8\:VSS \9\:VSS) resistor r=0.1203 c=0
Rk35 (\9\:VSS \18\:VSS) resistor r=0.2327 c=0
Rk4 (n0 \15\:n0) resistor r=0.3857 c=0
Rk5 (\15\:n0 \17\:n0) resistor r=0.405 c=0
Rk6 (\15\:n0 \19\:n0) resistor r=0.1942 c=0
Rl4 (\1\:A \2\:A) resistor r=69.9225 c=0
Rl5 (\2\:A \3\:A) resistor r=106.461 c=0
Rl1 (\1\:B \2\:B) resistor r=156.078 c=0
Rl3 (\2\:B \4\:B) resistor r=50.6632 c=0
Rl2 (\2\:B \3\:B) resistor r=7.3511 c=0
Rz4 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz6 (\3\:VDD \1\:VDD) resistor r=18.75 c=0
Rz7 (\8\:VDD \1\:VDD) resistor r=25 c=0
Rz11 (\18\:VSS \17\:VSS) resistor r=37.5 c=0
Rz1 (\19\:n0 \18\:n0) resistor r=37.5 c=0
Ry11 (VSS \1\:VSS) resistor r=62 c=0
Ry7 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry8 (\3\:VSS \1\:VSS) resistor r=15.5 c=0
Ry10 (\8\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\17\:n0 \16\:n0) resistor r=20.6667 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx1 (\3\:B \5\:B) resistor r=45 c=0
mn1 (\18\:n0 \4\:B \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
