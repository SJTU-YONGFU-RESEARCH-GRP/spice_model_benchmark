        scb=0.0189183 scc=0.00156031 m=(1)
mn52 (\10\:n35 \10\:CKb \3\:n40 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.4e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn31 (\4\:mout \2\:n20 n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.668e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.1e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn30 (n25 \6\:SN \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=1.668e-14 ps=1.05e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=6.5e-07 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn50 (n42 \4\:SN \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=2.9e-14 ps=1.05e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=3.85e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn51 (n40 \3\:qbint n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.03e-14 ps=6.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.4e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn45 (\23\:qbint \5\:n35 \3\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=9.285e-14 ad=2.87e-14 ps=1.6e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.38512e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn55 (\1\:Q \5\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.0593e-13 ad=5.46e-14 ps=1.69e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55288e-07 sb=1.07673e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn57 (\1\:QN net331 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.231e-14 ad=4.16e-14 ps=1.745e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65288e-07 sb=4.66731e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn56 (\12\:net331 \13\:qbint \3\:VSS VSS) g45n1svt w=(1.45e-07) \
        l=4.5e-08 nf=1 as=6.562e-14 ad=2.03e-14 ps=1.71e-06 pd=5.7e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.47e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp25 (n22 \1\:D \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.128e-14 ps=7.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.165e-06 sd=160n sca=13.1595 \
        scb=0.0109711 scc=0.000224272 m=(1)
mp26 (\5\:n20 \3\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.128e-14 ad=3.44e-14 ps=1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=8.35e-07 sd=160n sca=11.5515 \
        scb=0.00958998 scc=0.000220658 m=(1)
mp36 (\5\:n20 \3\:CKb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=6.3e-07 sd=160n sca=11.3578 \
        scb=0.0095436 scc=0.000220652 m=(1)
mp35 (n31 \3\:mout \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.517e-13 ad=1.29e-14 ps=2.02e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=5.25e-07 sd=160n sca=11.3578 \
        scb=0.0095436 scc=0.000220652 m=(1)
mp21 (\8\:CKbb \5\:CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.517e-13 ad=3.01e-14 ps=2.02e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=1.4e-07 sd=160n sca=11.3578 \
        scb=0.0095436 scc=0.000220652 m=(1)
mp40 (\8\:n35 \8\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.2e-07 sd=160n sca=16.037 scb=0.0158964 \
        scc=0.00103899 m=(1)
mp52 (\8\:n35 \4\:CKbb \3\:n41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=3.44e-14 ps=1.06e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.15e-07 sd=160n sca=16.037 \
        scb=0.0158964 scc=0.00103899 m=(1)
mp31 (\10\:mout n20 \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.415e-14 ad=3.978e-14 ps=1.73e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=7.7e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp30 (\10\:mout \5\:SN \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.465e-14 ad=3.977e-14 ps=1.83e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=5.4e-07 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp50 (n41 \1\:SN \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.465e-14 ad=4.3e-14 ps=1.83e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=3.45e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp51 (n41 \4\:qbint \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.39e-14 ad=4.3e-14 ps=1.73e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1e-07 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp45 (\19\:qbint \3\:n35 \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.76e-14 ad=4.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.24129e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp55_1__rcx (\3\:Q \5\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=8.925e-14 ad=7.995e-14 ps=1.25e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.94744e-07 sb=1.06987e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp57 (\3\:QN net331 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.124e-14 ad=6.24e-14 ps=1.295e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.99744e-07 sb=4.64872e-07 sd=160n sca=30.8584 \
        scb=0.020306 scc=0.00336099 m=(2)
mp56 (\8\:net331 \12\:qbint \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.158e-14 ad=3.01e-14 ps=1.19e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31384e-06 sb=1.4e-07 sd=160n sca=50.5874 \
        scb=0.0347407 scc=0.00598541 m=(1)
ends DFFSX2
// End of subcircuit definition.

// Generated for: spectre (May  9 14:32:41 2012 )
// Library name: gsclib045
// Cell name: DFFSX4
// View name: extracted

simulator lang=spectre

subckt DFFSX4 CK D Q QN SN VDD VSS
mp20 (\15\:CKb \3\:CK \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.45e-14 ad=4.837e-14 ps=1.03e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=1.84733e-06 sd=160n sca=25.0615 \
        scb=0.0281532 scc=0.00173703 m=(1)
C1 (SN VSS) capacitor c=1.62757e-16
C2 (Q VSS) capacitor c=2.54838e-17
C3 (D VSS) capacitor c=6.21098e-17
C4 (QN VSS) capacitor c=1.28752e-17
C5 (VDD VSS) capacitor c=3.6372e-16
C6 (CKb VSS) capacitor c=4.77935e-17
C7 (n20 VSS) capacitor c=4.23947e-17
C8 (n30 VSS) capacitor c=2.8021e-18
C9 (CKbb VSS) capacitor c=2.77486e-17
C10 (mout VSS) capacitor c=4.76049e-17
C11 (n25 VSS) capacitor c=3.61404e-18
C12 (n35 VSS) capacitor c=1.73897e-16
C13 (n40 VSS) capacitor c=1.87763e-18
C14 (qbint VSS) capacitor c=5.4116e-17
C15 (net331 VSS) capacitor c=2.66612e-16
C16 (n22 VSS) capacitor c=3.00795e-18
C17 (n41 VSS) capacitor c=9.57997e-17
C18 (\20\:qbint VSS) capacitor c=4.47132e-17
C19 (\4\:qbint VSS) capacitor c=2.4894e-16
C20 (\4\:SN VSS) capacitor c=4.2245e-17
C21 (\7\:CKbb VSS) capacitor c=4.7059e-17
C22 (\9\:CKb VSS) capacitor c=3.80328e-17
C23 (\8\:CKb VSS) capacitor c=4.18179e-17
C24 (\1\:SN VSS) capacitor c=6.4583e-17
C25 (\3\:n20 VSS) capacitor c=3.92424e-17
C26 (\3\:mout VSS) capacitor c=5.70055e-17
C27 (\3\:CKb VSS) capacitor c=4.89919e-17
C28 (\3\:CKbb VSS) capacitor c=7.49476e-17
C29 (\1\:D VSS) capacitor c=2.8556e-17
C30 (\3\:CK VSS) capacitor c=2.0565e-17
C31 (\18\:qbint VSS) capacitor c=2.5991e-17
C32 (\6\:SN VSS) capacitor c=6.64064e-17
C33 (\3\:qbint VSS) capacitor c=3.82703e-17
C34 (\5\:CKb VSS) capacitor c=7.78857e-17
C35 (\4\:CKbb VSS) capacitor c=4.126e-17
C36 (\6\:CKb VSS) capacitor c=6.54211e-17
C37 (\2\:SN VSS) capacitor c=3.52083e-17
C38 (\3\:D VSS) capacitor c=6.64709e-17
C39 (\1\:CK VSS) capacitor c=4.48617e-17
C40 (\19\:qbint VSS) capacitor c=4.11365e-17
C41 (\6\:n35 VSS) capacitor c=1.05376e-17
C42 (\5\:SN VSS) capacitor c=6.27315e-17
C43 (\2\:qbint VSS) capacitor c=4.84773e-17
C44 (\6\:CKbb VSS) capacitor c=2.67802e-17
C45 (\10\:CKb VSS) capacitor c=1.61872e-17
C46 (\3\:SN VSS) capacitor c=1.90597e-17
C47 (\2\:n20 VSS) capacitor c=4.60015e-17
C48 (\2\:mout VSS) capacitor c=5.76019e-17
C49 (\2\:CKbb VSS) capacitor c=6.97359e-17
C50 (\4\:CKb VSS) capacitor c=2.33677e-17
C51 (\2\:CKb VSS) capacitor c=5.04224e-17
C52 (\2\:D VSS) capacitor c=5.03424e-17
C53 (\2\:CK VSS) capacitor c=3.99527e-17
C54 (\20\:net331 VSS) capacitor c=3.07095e-17
C55 (\1\:Q VSS) capacitor c=1.59996e-16
C56 (\27\:qbint VSS) capacitor c=6.96826e-17
C57 (\28\:VDD VSS) capacitor c=1.93209e-17
C58 (\3\:n41 VSS) capacitor c=8.01934e-17
C59 (\10\:n35 VSS) capacitor c=4.75785e-17
C60 (\6\:mout VSS) capacitor c=1.37471e-16
C61 (\14\:CKbb VSS) capacitor c=4.203e-17
C62 (\30\:VDD VSS) capacitor c=2.4254e-17
C63 (\8\:mout VSS) capacitor c=9.90205e-17
C64 (\32\:VDD VSS) capacitor c=2.05538e-17
C65 (\8\:n20 VSS) capacitor c=2.89727e-17
C66 (\34\:VDD VSS) capacitor c=5.41553e-17
C67 (\15\:CKb VSS) capacitor c=5.67153e-17
C68 (\1\:VDD VSS) capacitor c=8.07447e-17
C69 (\16\:net331 VSS) capacitor c=3.35627e-17
C70 (\1\:QN VSS) capacitor c=8.67927e-17
C71 (\29\:qbint VSS) capacitor c=2.07499e-17
C72 (\12\:n35 VSS) capacitor c=8.80479e-17
C73 (\4\:mout VSS) capacitor c=1.27717e-16
C74 (\12\:CKbb VSS) capacitor c=2.22642e-17
C75 (\11\:mout VSS) capacitor c=3.06559e-17
C76 (\6\:n20 VSS) capacitor c=7.29203e-17
C77 (\17\:CKb VSS) capacitor c=1.93538e-17
C78 (\5\:CKbb VSS) capacitor c=3.06505e-17
C79 (\7\:CKb VSS) capacitor c=4.99769e-17
C80 (\4\:CK VSS) capacitor c=6.4492e-17
C81 (\5\:CK VSS) capacitor c=5.16778e-17
C82 (\4\:D VSS) capacitor c=6.35922e-17
C83 (\4\:n20 VSS) capacitor c=5.72469e-17
C84 (\5\:n20 VSS) capacitor c=7.72393e-17
C85 (\11\:CKb VSS) capacitor c=1.0417e-16
C86 (\12\:CKb VSS) capacitor c=1.43043e-16
C87 (\13\:CKb VSS) capacitor c=1.55483e-16
C88 (\14\:CKb VSS) capacitor c=9.82676e-17
C89 (\8\:CKbb VSS) capacitor c=4.1673e-17
C90 (\9\:CKbb VSS) capacitor c=2.81161e-17
C91 (\10\:CKbb VSS) capacitor c=1.10695e-16
C92 (\11\:CKbb VSS) capacitor c=1.28156e-16
C93 (\10\:mout VSS) capacitor c=5.70314e-17
C94 (\13\:mout VSS) capacitor c=3.64867e-17
C95 (\7\:SN VSS) capacitor c=6.98109e-17
C96 (\8\:SN VSS) capacitor c=1.47049e-16
C97 (\8\:n35 VSS) capacitor c=1.29435e-16
C98 (\9\:n35 VSS) capacitor c=1.586e-16
C99 (\4\:Q VSS) capacitor c=1.08456e-16
C100 (\5\:QN VSS) capacitor c=1.71921e-16
C101 (\21\:qbint VSS) capacitor c=2.28101e-16
C102 (\22\:qbint VSS) capacitor c=1.84798e-16
C103 (\23\:qbint VSS) capacitor c=3.14635e-17
C104 (\24\:qbint VSS) capacitor c=4.31477e-17
C105 (\25\:qbint VSS) capacitor c=5.78797e-17
C106 (\26\:qbint VSS) capacitor c=3.35944e-17
C107 (\18\:net331 VSS) capacitor c=4.04695e-17
C108 (\19\:net331 VSS) capacitor c=5.06759e-17
C109 (\3\:VDD VSS) capacitor c=4.66798e-16
C110 (\10\:VDD VSS) capacitor c=2.02913e-17
C111 (\12\:VDD VSS) capacitor c=2.37968e-17
C112 (\13\:VDD VSS) capacitor c=2.8309e-17
C113 (\15\:VDD VSS) capacitor c=8.95311e-18
Rk23 (\7\:SN SN) resistor r=0.3441 c=0
Rk24 (SN \8\:SN) resistor r=1.2331 c=0
Rk30 (\1\:Q Q) resistor r=0.07275 c=0
Rk31 (Q \4\:Q) resistor r=0.1621 c=0
Rk4 (\4\:D D) resistor r=0.04146 c=0
Rk36 (\1\:QN QN) resistor r=0.04298 c=0
Rk37 (QN \5\:QN) resistor r=0.1878 c=0
Rk57 (\1\:VSS \11\:VSS) resistor r=0.5614 c=0
Rk58 (\11\:VSS \12\:VSS) resistor r=0.1853 c=0
Rk59 (\12\:VSS \13\:VSS) resistor r=0.3647 c=0
Rk60 (\13\:VSS \14\:VSS) resistor r=0.3498 c=0
Rk62 (\15\:VSS VSS) resistor r=0.1851 c=0
Rk61 (\14\:VSS \15\:VSS) resistor r=0.1151 c=0
Rk68 (\12\:VSS \27\:VSS) resistor r=0.127 c=0
Rk69 (\13\:VSS \29\:VSS) resistor r=0.04329 c=0
Rk70 (\15\:VSS \31\:VSS) resistor r=0.1762 c=0
Rk71 (\2\:VDD \3\:VDD) resistor r=0.09758 c=0
Rk78 (\3\:VDD \10\:VDD) resistor r=0.2277 c=0
Rk79 (\10\:VDD \11\:VDD) resistor r=0.426 c=0
Rk80 (\11\:VDD \12\:VDD) resistor r=0.2571 c=0
Rk81 (\12\:VDD \13\:VDD) resistor r=0.2594 c=0
Rk82 (\13\:VDD \14\:VDD) resistor r=0.3332 c=0
Rk84 (\15\:VDD VDD) resistor r=0.2177 c=0
Rk83 (\14\:VDD \15\:VDD) resistor r=0.08253 c=0
Rk91 (\10\:VDD \29\:VDD) resistor r=0.1024 c=0
Rk92 (\12\:VDD \31\:VDD) resistor r=0.04329 c=0
Rk93 (\13\:VDD \33\:VDD) resistor r=0.07369 c=0
Rk94 (\15\:VDD \35\:VDD) resistor r=0.3502 c=0
Rk1 (CK \4\:CK) resistor r=0.001952 c=0
Rk3 (\4\:CK \5\:CK) resistor r=0.02435 c=0
Rk2 (\5\:CK \6\:CK) resistor r=0.002019 c=0
Rk8 (\11\:CKb \12\:CKb) resistor r=0.7005 c=0
Rk9 (\12\:CKb \13\:CKb) resistor r=0.6671 c=0
Rk10 (\13\:CKb \14\:CKb) resistor r=0.499 c=0
Rk11 (\14\:CKb \16\:CKb) resistor r=0.6031 c=0
Rk12 (\14\:CKb \18\:CKb) resistor r=0.097 c=0
Rk5 (\4\:n20 \5\:n20) resistor r=0.3443 c=0
Rk6 (\5\:n20 \7\:n20) resistor r=0.4427 c=0
Rk7 (\5\:n20 \9\:n20) resistor r=0.1307 c=0
Rk13 (\8\:CKbb \9\:CKbb) resistor r=0.1202 c=0
Rk14 (\9\:CKbb \10\:CKbb) resistor r=0.2222 c=0
Rk15 (\10\:CKbb \11\:CKbb) resistor r=1.0275 c=0
Rk16 (\9\:CKbb \13\:CKbb) resistor r=0.1155 c=0
Rk17 (\10\:CKbb \15\:CKbb) resistor r=0.1664 c=0
Rk18 (\5\:mout \7\:mout) resistor r=0.7392 c=0
Rk19 (\7\:mout \9\:mout) resistor r=0.6137 c=0
Rk20 (\9\:mout \10\:mout) resistor r=0.3339 c=0
Rk21 (\10\:mout \12\:mout) resistor r=0.07479 c=0
Rk22 (\10\:mout \13\:mout) resistor r=0.1825 c=0
Rk26 (\8\:n35 \9\:n35) resistor r=0.8385 c=0
Rk27 (\9\:n35 \11\:n35) resistor r=0.2583 c=0
Rk28 (\9\:n35 \13\:n35) resistor r=0.4121 c=0
Rk40 (\21\:qbint \22\:qbint) resistor r=1.8272 c=0
Rk41 (\22\:qbint \23\:qbint) resistor r=0.09741 c=0
Rk42 (\23\:qbint \24\:qbint) resistor r=0.1601 c=0
Rk43 (\24\:qbint \25\:qbint) resistor r=0.3388 c=0
Rk44 (\22\:qbint \26\:qbint) resistor r=0.1025 c=0
Rk45 (\23\:qbint \28\:qbint) resistor r=0.28 c=0
Rk46 (\24\:qbint \30\:qbint) resistor r=0.06442 c=0
Rk47 (\17\:net331 \18\:net331) resistor r=0.3792 c=0
Rk48 (\18\:net331 \19\:net331) resistor r=0.271 c=0
Rk49 (\18\:net331 \21\:net331) resistor r=0.097 c=0
Rk25 (\2\:n41 \4\:n41) resistor r=0.3958 c=0
Rl13 (\1\:SN \2\:SN) resistor r=151.489 c=0
Rl25 (\4\:SN \5\:SN) resistor r=69.208 c=0
Rl26 (\5\:SN \6\:SN) resistor r=95.9489 c=0
Rl14 (\2\:SN \3\:SN) resistor r=24.2328 c=0
Rl3 (\1\:D \2\:D) resistor r=50.6918 c=0
Rl4 (\2\:D \3\:D) resistor r=164.153 c=0
Rl2 (\2\:CK \3\:CK) resistor r=26.3736 c=0
Rl1 (\1\:CK \2\:CK) resistor r=190.385 c=0
Rl18 (\5\:CKb \6\:CKb) resistor r=414.95 c=0
Rl22 (\8\:CKb \10\:CKb) resistor r=50.6918 c=0
Rl6 (\3\:CKb \4\:CKb) resistor r=71.8456 c=0
Rl5 (CKb \2\:CKb) resistor r=91.4826 c=0
Rl21 (\7\:CKb \9\:CKb) resistor r=142.286 c=0
Rl20 (\7\:CKb \8\:CKb) resistor r=153.824 c=0
Rl19 (\6\:CKb \7\:CKb) resistor r=90.0661 c=0
Rl11 (n20 \2\:n20) resistor r=114.183 c=0
Rl12 (\2\:n20 \3\:n20) resistor r=26.1559 c=0
Rl7 (CKbb \2\:CKbb) resistor r=29.5379 c=0
Rl8 (\2\:CKbb \3\:CKbb) resistor r=257.95 c=0
Rl17 (\5\:CKbb \7\:CKbb) resistor r=118.912 c=0
Rl15 (\4\:CKbb \5\:CKbb) resistor r=80.7471 c=0
Rl16 (\5\:CKbb \6\:CKbb) resistor r=40.3099 c=0
Rl9 (mout \2\:mout) resistor r=117.103 c=0
Rl10 (\2\:mout \3\:mout) resistor r=97.6132 c=0
Rl31 (n35 \6\:n35) resistor r=1.2301 c=0
Rl61 (\19\:qbint \20\:qbint) resistor r=47.3097 c=0
Rl60 (\19\:qbint \18\:qbint) resistor r=59.5201 c=0
Rl23 (\2\:qbint qbint) resistor r=137.694 c=0
Rl24 (\2\:qbint \3\:qbint) resistor r=26.1559 c=0
Rz19 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz20 (\29\:VSS \28\:VSS) resistor r=75 c=0
Rz21 (\31\:VSS \30\:VSS) resistor r=75 c=0
Rz22 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz23 (\3\:VDD \1\:VDD) resistor r=6.25 c=0
Rz24 (\11\:VDD \1\:VDD) resistor r=7.5 c=0
Rz25 (\14\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz2 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz1 (\6\:n20 \7\:n20) resistor r=75 c=0
Rz3 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz4 (\4\:mout \5\:mout) resistor r=75 c=0
Rz5 (\11\:mout \12\:mout) resistor r=75 c=0
Rz6 (\13\:n35 \12\:n35) resistor r=75 c=0
Rz11 (\30\:qbint \29\:qbint) resistor r=75 c=0
Rz12 (\17\:net331 \16\:net331) resistor r=75 c=0
Ry16 (\1\:VSS \4\:VSS) resistor r=4.4286 c=0
Ry17 (\11\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry18 (\14\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry25 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry26 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry27 (\33\:VDD \32\:VDD) resistor r=62 c=0
Ry28 (\35\:VDD \34\:VDD) resistor r=62 c=0
Ry2 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry1 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry3 (\14\:CKbb \15\:CKbb) resistor r=62 c=0
Ry4 (\6\:mout \7\:mout) resistor r=62 c=0
Ry5 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\11\:n35 \10\:n35) resistor r=62 c=0
Ry13 (\28\:qbint \27\:qbint) resistor r=31 c=0
Ry14 (\21\:net331 \20\:net331) resistor r=20.6667 c=0
Ry6 (n41 \2\:n41) resistor r=62 c=0
Ry7 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx10 (\5\:SN \7\:SN) resistor r=45 c=0
Rx11 (\3\:SN \8\:SN) resistor r=45 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \6\:CK) resistor r=45 c=0
Rx4 (\10\:CKb \11\:CKb) resistor r=45 c=0
Rx5 (\4\:CKb \12\:CKb) resistor r=45 c=0
Rx6 (\2\:CKb \13\:CKb) resistor r=45 c=0
Rx3 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx7 (\6\:CKbb \8\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \11\:CKbb) resistor r=45 c=0
Rx9 (\2\:mout \13\:mout) resistor r=45 c=0
Rx12 (\8\:n35 \6\:n35) resistor r=45 c=0
Rx13 (\21\:qbint \19\:qbint) resistor r=45 c=0
Rx14 (\25\:qbint \2\:qbint) resistor r=45 c=0
Rx15 (\26\:qbint \4\:qbint) resistor r=45 c=0
Rx16 (\19\:net331 net331) resistor r=45 c=0
mn20 (\17\:CKb \1\:CK \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.263e-14 ad=2.03e-14 ps=7.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-06 sd=160n sca=6.59604 scb=0.00318587 \
        scc=2.16275e-05 m=(1)
mn25 (n21 \3\:D \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.263e-14 ad=1.088e-14 ps=7.4e-07 pd=4.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=7.3e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn26 (\6\:n20 CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.088e-14 ad=3.988e-14 ps=4.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=6.1e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn35 (\6\:n20 CKbb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.103e-14 ad=3.988e-14 ps=5.8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=2.9e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn36 (n30 mout \28\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.04e-14 ad=2.103e-14 ps=9.3e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=1e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
mn31 (\11\:mout n20 n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.393e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.55e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn30 (n25 \2\:SN \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.081e-13 ad=2.393e-14 ps=1.9e-06 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=6.45e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn21 (\12\:CKbb \6\:CKb \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=1.081e-13 ad=2.03e-14 ps=1.9e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=1.4e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn40 (\12\:n35 \4\:CKbb \4\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.7245 scb=0.0178071 \
        scc=0.00133148 m=(1)
mn52 (\12\:n35 \5\:CKb n40 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=2.32e-14 ps=9.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=16.7245 scb=0.0178071 \
        scc=0.00133148 m=(1)
mn51 (n40 \3\:qbint n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.858e-14 ps=4.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2e-06 sd=160n sca=16.7245 scb=0.0178071 \
        scc=0.00133148 m=(1)
mn50 (n42 \6\:SN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=8.7e-15 ps=7.3e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=2e-06 sd=160n sca=16.7245 scb=0.0178071 \
        scc=0.00133148 m=(1)
mn45_1__rcx (\29\:qbint n35 \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.554e-14 ad=3.28e-14 ps=9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.61341e-07 sb=2e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(2)
mn55_1__rcx (\4\:Q \4\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.717e-14 ad=4.16e-14 ps=1.4675e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03538e-06 sb=2e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn57_1__rcx (\1\:QN net331 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.73e-14 ad=4.615e-14 ps=1.45e-06 pd=8.75e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.69654e-06 sb=1.135e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn56 (\16\:net331 \18\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=3.64e-14 ps=1e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mp25 (n22 \1\:D \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.45e-14 ad=3.44e-14 ps=1.03e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.50233e-06 sd=160n sca=19.0383 \
        scb=0.0183896 scc=0.00142445 m=(1)
mp26 (\8\:n20 \3\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=1.29733e-06 sd=160n sca=18.2092 \
        scb=0.0178429 scc=0.00142384 m=(1)
mp36 (\8\:n20 \3\:CKb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=1.09233e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp35 (n31 \3\:mout \32\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=3.01e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=9.07326e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp31 (\8\:mout \3\:n20 \32\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.71e-14 ad=4.515e-14 ps=1.7e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=6.42326e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp30 (\8\:mout \1\:SN \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=4.515e-14 ps=1.7e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.685e-06 sb=3.87326e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp21 (\14\:CKbb \8\:CKb \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.71e-14 ad=2.63e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95e-06 sb=1.22326e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp40 (\10\:n35 \9\:CKb \6\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.67e-14 ad=3.548e-14 ps=7.1e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24186e-07 sb=3.5e-07 sd=160n sca=11.6359 \
        scb=0.0100097 scc=0.00025962 m=(1)
mp52 (\10\:n35 \7\:CKbb \3\:n41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.548e-14 ps=7.1e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.34186e-07 sb=1.4e-07 sd=160n sca=11.6359 \
        scb=0.0100097 scc=0.00025962 m=(1)
mp51 (n41 qbint \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.255e-14 ad=3.44e-14 ps=1.37e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=11.3578 scb=0.0095436 \
        scc=0.000220652 m=(1)
mp50 (n41 \4\:SN \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.647e-14 ad=3.44e-14 ps=1.15e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2e-06 sd=160n sca=11.3578 scb=0.0095436 \
        scc=0.000220652 m=(1)
mp45_1__rcx (\27\:qbint n35 \3\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=6.829e-14 ad=4.96e-14 ps=1.155e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05726e-07 sb=2e-06 sd=160n sca=14.1869 \
        scb=0.0131869 scc=0.000739194 m=(2)
mp55_1__rcx (\1\:Q \4\:qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.432e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.80449e-07 sb=1.78e-06 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(4)
mp57_1__rcx (\5\:QN net331 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.60045e-06 sb=9.6e-07 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(4)
mp56 (\20\:net331 \20\:qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.95487e-06 sb=1.4e-07 sd=160n sca=24.44 \
        scb=0.022002 scc=0.00203224 m=(1)
ends DFFSX4
// End of subcircuit definition.

// Generated for: spectre (May  9 14:33:19 2012 )
// Library name: gsclib045
// Cell name: DFFSXL
// View name: extracted

simulator lang=spectre

subckt DFFSXL CK D Q QN SN VDD VSS
mp57 (\1\:QN \4\:net331 \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.515e-14 ad=3.762e-14 ps=1.45e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.35e-07 sd=160n sca=49.323 \
        scb=0.0325052 scc=0.00592234 m=(1)
C1 (SN VSS) capacitor c=4.905e-17
C2 (CK VSS) capacitor c=4.32382e-17
C3 (Q VSS) capacitor c=3.67077e-17
C4 (D VSS) capacitor c=1.32848e-16
C5 (QN VSS) capacitor c=2.20784e-17
C6 (VDD VSS) capacitor c=2.58053e-16
C7 (net331 VSS) capacitor c=1.99323e-17
C8 (qbint VSS) capacitor c=3.3854e-17
C9 (n35 VSS) capacitor c=4.17028e-17
C10 (n42 VSS) capacitor c=1.75543e-18
C11 (n40 VSS) capacitor c=3.68286e-17
C12 (n25 VSS) capacitor c=7.38748e-18
C13 (mout VSS) capacitor c=4.4399e-17
C14 (n20 VSS) capacitor c=2.31794e-17
C15 (CKb VSS) capacitor c=3.24126e-17
C16 (CKbb VSS) capacitor c=3.96682e-17
C17 (n30 VSS) capacitor c=1.80955e-18
C18 (n21 VSS) capacitor c=2.10073e-19
C19 (n41 VSS) capacitor c=1.32916e-16
C20 (n31 VSS) capacitor c=4.38396e-18
C21 (\3\:CK VSS) capacitor c=3.84574e-17
C22 (\3\:D VSS) capacitor c=4.40156e-17
C23 (\5\:CKbb VSS) capacitor c=6.21895e-17
C24 (\8\:CKb VSS) capacitor c=4.11163e-17
C25 (\4\:mout VSS) capacitor c=3.88565e-17
C26 (\5\:CKb VSS) capacitor c=6.33908e-17
C27 (\3\:CKb VSS) capacitor c=3.53659e-17
C28 (\3\:CKbb VSS) capacitor c=6.53061e-17
C29 (\2\:n20 VSS) capacitor c=4.0166e-17
C30 (\1\:SN VSS) capacitor c=4.44349e-17
C31 (\5\:SN VSS) capacitor c=2.10595e-17
C32 (\8\:qbint VSS) capacitor c=2.57733e-17
C33 (\7\:qbint VSS) capacitor c=3.67489e-17
C34 (\4\:net331 VSS) capacitor c=3.69168e-17
C35 (\1\:CK VSS) capacitor c=2.80338e-17
C36 (\1\:D VSS) capacitor c=6.66497e-17
C37 (\10\:CKb VSS) capacitor c=6.50285e-17
C38 (\8\:CKbb VSS) capacitor c=2.86727e-17
C39 (\6\:CKb VSS) capacitor c=4.94761e-17
C40 (\2\:CKb VSS) capacitor c=3.53453e-17
C41 (\3\:n20 VSS) capacitor c=4.92851e-17
C42 (\4\:SN VSS) capacitor c=1.78178e-17
C43 (\3\:SN VSS) capacitor c=5.12136e-17
C44 (\11\:qbint VSS) capacitor c=5.5805e-17
C45 (\3\:n35 VSS) capacitor c=3.45607e-17
C46 (\5\:qbint VSS) capacitor c=2.60081e-17
C47 (\4\:qbint VSS) capacitor c=2.69442e-17
C48 (\3\:net331 VSS) capacitor c=3.01404e-17
C49 (\2\:CK VSS) capacitor c=3.46022e-17
C50 (\2\:D VSS) capacitor c=4.29465e-17
C51 (\11\:CKb VSS) capacitor c=2.46544e-17
C52 (\9\:CKb VSS) capacitor c=5.26701e-17
C53 (\7\:CKbb VSS) capacitor c=5.65647e-17
C54 (\3\:mout VSS) capacitor c=2.50422e-17
C55 (\7\:CKb VSS) capacitor c=2.0512e-17
C56 (\4\:CKbb VSS) capacitor c=4.10802e-17
C57 (\4\:CKb VSS) capacitor c=4.166e-17
C58 (\2\:n40 VSS) capacitor c=3.99966e-17
C59 (\2\:SN VSS) capacitor c=5.04683e-17
C60 (\10\:qbint VSS) capacitor c=1.73779e-17
C61 (\2\:n35 VSS) capacitor c=4.04428e-17
C62 (\6\:qbint VSS) capacitor c=4.24342e-17
C63 (\20\:CKb VSS) capacitor c=6.09359e-17
C64 (\13\:VDD VSS) capacitor c=3.75776e-17
C65 (\6\:n20 VSS) capacitor c=2.19995e-16
C66 (\15\:VDD VSS) capacitor c=8.38176e-18
C67 (\13\:CKbb VSS) capacitor c=5.79658e-17
C68 (\7\:mout VSS) capacitor c=6.25297e-17
C69 (\8\:n35 VSS) capacitor c=5.49244e-17
C70 (\17\:VDD VSS) capacitor c=2.00024e-17
C71 (\14\:mout VSS) capacitor c=4.18655e-17
C72 (\19\:VDD VSS) capacitor c=2.69195e-17
C73 (\3\:n41 VSS) capacitor c=8.19562e-17
C74 (\21\:VDD VSS) capacitor c=3.00943e-17
C75 (\13\:qbint VSS) capacitor c=4.86989e-17
C76 (\23\:VDD VSS) capacitor c=7.94187e-18
C77 (\3\:Q VSS) capacitor c=4.36502e-17
C78 (\5\:net331 VSS) capacitor c=2.45361e-17
C79 (\25\:VDD VSS) capacitor c=4.51323e-18
C80 (\1\:QN VSS) capacitor c=1.55603e-17
C81 (\1\:VDD VSS) capacitor c=8.87036e-17
C82 (\18\:CKb VSS) capacitor c=8.19557e-17
C83 (\4\:n20 VSS) capacitor c=8.59558e-17
C84 (\11\:CKbb VSS) capacitor c=3.35204e-17
C85 (\5\:mout VSS) capacitor c=8.23939e-17
C86 (\4\:n35 VSS) capacitor c=4.4057e-17
C87 (\6\:n40 VSS) capacitor c=5.3135e-17
C88 (\11\:mout VSS) capacitor c=6.12671e-17
C89 (\3\:n40 VSS) capacitor c=7.50481e-17
C90 (\16\:qbint VSS) capacitor c=3.91791e-17
C91 (\1\:Q VSS) capacitor c=3.11975e-17
C92 (\9\:net331 VSS) capacitor c=2.77195e-17
C93 (\3\:QN VSS) capacitor c=3.4042e-17
C94 (\2\:net331 VSS) capacitor c=1.25893e-17
C95 (\3\:qbint VSS) capacitor c=3.72985e-17
C96 (\9\:qbint VSS) capacitor c=2.89009e-17
C97 (\2\:CKbb VSS) capacitor c=4.90626e-17
C98 (\2\:mout VSS) capacitor c=3.74288e-17
C99 (\6\:CKbb VSS) capacitor c=5.725e-17
C100 (\7\:net331 VSS) capacitor c=2.941e-17
C101 (\8\:net331 VSS) capacitor c=2.90999e-17
C102 (\12\:qbint VSS) capacitor c=3.97526e-17
C103 (\15\:qbint VSS) capacitor c=7.28829e-17
C104 (\5\:n40 VSS) capacitor c=8.65267e-17
C105 (\6\:SN VSS) capacitor c=6.6103e-17
C106 (\8\:n40 VSS) capacitor c=5.59439e-17
C107 (\6\:n35 VSS) capacitor c=2.53767e-16
C108 (\7\:n35 VSS) capacitor c=2.68547e-16
C109 (\9\:mout VSS) capacitor c=1.7122e-16
C110 (\10\:mout VSS) capacitor c=1.26056e-16
C111 (\13\:mout VSS) capacitor c=1.02207e-16
C112 (\9\:CKbb VSS) capacitor c=7.54035e-17
C113 (\10\:CKbb VSS) capacitor c=6.29028e-17
C114 (\8\:n20 VSS) capacitor c=1.835e-16
C115 (\4\:CK VSS) capacitor c=8.68939e-17
C116 (\12\:CKb VSS) capacitor c=2.70931e-17
C117 (\13\:CKb VSS) capacitor c=6.40691e-17
C118 (\14\:CKb VSS) capacitor c=6.529e-17
C119 (\15\:CKb VSS) capacitor c=6.4457e-17
C120 (\16\:CKb VSS) capacitor c=6.50415e-17
C121 (\17\:CKb VSS) capacitor c=1.98531e-17
C122 (\22\:CKb VSS) capacitor c=7.56168e-17
C123 (\23\:CKb VSS) capacitor c=8.14584e-17
C124 (\3\:VDD VSS) capacitor c=7.15514e-19
C125 (\5\:VDD VSS) capacitor c=2.1375e-17
C126 (\7\:VDD VSS) capacitor c=2.16758e-17
C127 (\8\:VDD VSS) capacitor c=1.19236e-17
C128 (\10\:VDD VSS) capacitor c=3.37921e-18
C129 (\11\:VDD VSS) capacitor c=9.84023e-18
Rk12 (\6\:SN SN) resistor r=0.09718 c=0
Rk30 (CK \4\:CK) resistor r=0.07791 c=0
Rk6 (Q \2\:Q) resistor r=0.06892 c=0
Rk7 (Q \4\:Q) resistor r=0.1768 c=0
Rk40 (\2\:VSS \3\:VSS) resistor r=0.06498 c=0
Rk41 (\3\:VSS \4\:VSS) resistor r=0.08503 c=0
Rk42 (\4\:VSS \5\:VSS) resistor r=0.3397 c=0
Rk43 (\5\:VSS \6\:VSS) resistor r=0.3097 c=0
Rk44 (\6\:VSS \7\:VSS) resistor r=0.644 c=0
Rk45 (\7\:VSS \8\:VSS) resistor r=0.1577 c=0
Rk46 (\8\:VSS \9\:VSS) resistor r=0.2104 c=0
Rk47 (\9\:VSS \10\:VSS) resistor r=0.1402 c=0
Rk48 (\10\:VSS \11\:VSS) resistor r=0.1778 c=0
Rk50 (\12\:VSS VSS) resistor r=0.1 c=0
Rk49 (\11\:VSS \12\:VSS) resistor r=0.1226 c=0
Rk51 (\3\:VSS \14\:VSS) resistor r=0.07358 c=0
Rk52 (\5\:VSS \16\:VSS) resistor r=0.04328 c=0
Rk53 (\7\:VSS \18\:VSS) resistor r=0.07358 c=0
Rk54 (\9\:VSS \20\:VSS) resistor r=0.07358 c=0
Rk55 (\11\:VSS \22\:VSS) resistor r=0.07358 c=0
Rk2 (\4\:QN QN) resistor r=0.08316 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2244 c=0
Rk56 (\2\:VDD \3\:VDD) resistor r=0.1101 c=0
Rk57 (\3\:VDD \4\:VDD) resistor r=0.09004 c=0
Rk58 (\4\:VDD \5\:VDD) resistor r=0.1577 c=0
Rk59 (\5\:VDD \6\:VDD) resistor r=0.4435 c=0
Rk60 (\6\:VDD \7\:VDD) resistor r=0.3097 c=0
Rk61 (\7\:VDD \8\:VDD) resistor r=0.2343 c=0
Rk62 (\8\:VDD \9\:VDD) resistor r=0.2053 c=0
Rk63 (\9\:VDD \10\:VDD) resistor r=0.07751 c=0
Rk64 (\10\:VDD \11\:VDD) resistor r=0.1826 c=0
Rk73 (\12\:VDD VDD) resistor r=0.251 c=0
Rk65 (\11\:VDD \12\:VDD) resistor r=0.2906 c=0
Rk66 (\3\:VDD \14\:VDD) resistor r=0.3774 c=0
Rk67 (\5\:VDD \16\:VDD) resistor r=0.07358 c=0
Rk68 (\7\:VDD \18\:VDD) resistor r=0.04328 c=0
Rk69 (\8\:VDD \20\:VDD) resistor r=0.2166 c=0
Rk70 (\10\:VDD \22\:VDD) resistor r=0.373 c=0
Rk71 (\11\:VDD \24\:VDD) resistor r=0.2233 c=0
Rk72 (\12\:VDD \26\:VDD) resistor r=0.2695 c=0
Rk3 (\6\:net331 \7\:net331) resistor r=0.1176 c=0
Rk4 (\7\:net331 \8\:net331) resistor r=0.1192 c=0
Rk5 (\7\:net331 \10\:net331) resistor r=0.1056 c=0
Rk8 (\12\:qbint \14\:qbint) resistor r=0.1911 c=0
Rk9 (\14\:qbint \15\:qbint) resistor r=0.2773 c=0
Rk10 (\15\:qbint \17\:qbint) resistor r=0.2776 c=0
Rk15 (\5\:n35 \6\:n35) resistor r=0.1616 c=0
Rk16 (\6\:n35 \7\:n35) resistor r=1.8334 c=0
Rk17 (\6\:n35 \9\:n35) resistor r=0.201 c=0
Rk11 (\4\:n40 \5\:n40) resistor r=0.5256 c=0
Rk14 (\7\:n40 \8\:n40) resistor r=0.1367 c=0
Rk18 (\6\:mout \8\:mout) resistor r=0.4467 c=0
Rk19 (\8\:mout \9\:mout) resistor r=0.07096 c=0
Rk20 (\9\:mout \10\:mout) resistor r=0.8266 c=0
Rk21 (\10\:mout \12\:mout) resistor r=0.2619 c=0
Rk22 (\9\:mout \13\:mout) resistor r=0.5864 c=0
Rk23 (\10\:mout \15\:mout) resistor r=0.1203 c=0
Rk27 (\5\:n20 \7\:n20) resistor r=0.4473 c=0
Rk28 (\7\:n20 \8\:n20) resistor r=1.4774 c=0
Rk31 (\12\:CKb \13\:CKb) resistor r=0.05541 c=0
Rk32 (\13\:CKb \14\:CKb) resistor r=0.1884 c=0
Rk33 (\14\:CKb \15\:CKb) resistor r=0.3843 c=0
Rk34 (\15\:CKb \16\:CKb) resistor r=0.3044 c=0
Rk35 (\16\:CKb \17\:CKb) resistor r=0.06828 c=0
Rk36 (\13\:CKb \19\:CKb) resistor r=0.49 c=0
Rk37 (\19\:CKb \21\:CKb) resistor r=0.4556 c=0
Rk38 (\14\:CKb \22\:CKb) resistor r=0.3774 c=0
Rk39 (\16\:CKb \23\:CKb) resistor r=0.3613 c=0
Rk24 (\9\:CKbb \10\:CKbb) resistor r=0.4535 c=0
Rk25 (\10\:CKbb \12\:CKbb) resistor r=0.142 c=0
Rk26 (\10\:CKbb \14\:CKbb) resistor r=0.2187 c=0
Rk13 (\2\:n41 \4\:n41) resistor r=0.6891 c=0
Rl15 (\1\:SN \2\:SN) resistor r=139.939 c=0
Rl18 (\2\:SN \5\:SN) resistor r=24.2328 c=0
Rl17 (\2\:SN \4\:SN) resistor r=76.1559 c=0
Rl16 (\2\:SN \3\:SN) resistor r=114.001 c=0
Rl40 (\2\:CK \3\:CK) resistor r=79.9451 c=0
Rl39 (\1\:CK \2\:CK) resistor r=30.7692 c=0
Rl38 (\2\:D \3\:D) resistor r=29.0109 c=0
Rl37 (\1\:D \2\:D) resistor r=75.6797 c=0
Rl1 (net331 \2\:net331) resistor r=0.5213 c=0
Rl3 (\2\:net331 \4\:net331) resistor r=49.7141 c=0
Rl2 (\2\:net331 \3\:net331) resistor r=34.3295 c=0
Rl4 (qbint \2\:qbint) resistor r=68.0527 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=33.4373 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=4.1351 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=162.491 c=0
Rl12 (\8\:qbint \9\:qbint) resistor r=34.3295 c=0
Rl14 (\9\:qbint \11\:qbint) resistor r=86.2526 c=0
Rl13 (\9\:qbint \10\:qbint) resistor r=9.1017 c=0
Rl10 (n35 \2\:n35) resistor r=56.9251 c=0
Rl11 (\2\:n35 \3\:n35) resistor r=26.1559 c=0
Rl21 (n40 \2\:n40) resistor r=232.153 c=0
Rl29 (mout \2\:mout) resistor r=90.4693 c=0
Rl31 (\2\:mout \4\:mout) resistor r=34.3295 c=0
Rl30 (\2\:mout \3\:mout) resistor r=1.2666 c=0
Rl19 (n20 \2\:n20) resistor r=58.3841 c=0
Rl20 (\2\:n20 \3\:n20) resistor r=141.873 c=0
Rl27 (\5\:CKb \6\:CKb) resistor r=132.718 c=0
Rl22 (CKb \2\:CKb) resistor r=64.0094 c=0
Rl36 (\10\:CKb \11\:CKb) resistor r=93.4636 c=0
Rl32 (\8\:CKb \9\:CKb) resistor r=29.5379 c=0
Rl28 (\6\:CKb \7\:CKb) resistor r=30.0021 c=0
Rl23 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl24 (CKbb \2\:CKbb) resistor r=30.4507 c=0
Rl25 (\2\:CKbb \3\:CKbb) resistor r=168.774 c=0
Rl26 (\2\:CKbb \4\:CKbb) resistor r=88.851 c=0
Rl33 (\5\:CKbb \6\:CKbb) resistor r=114.928 c=0
Rl35 (\6\:CKbb \8\:CKbb) resistor r=30.4507 c=0
Rl34 (\6\:CKbb \7\:CKbb) resistor r=104.516 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz13 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz14 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz15 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz16 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz17 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz18 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz19 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Rz20 (\1\:VDD \6\:VDD) resistor r=7.5 c=0
Rz21 (\1\:VDD \9\:VDD) resistor r=15 c=0
Rz22 (\1\:VDD \12\:VDD) resistor r=12.5 c=0
Rz2 (\9\:net331 \10\:net331) resistor r=75 c=0
Rz4 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz7 (\4\:n35 \5\:n35) resistor r=75 c=0
Rz5 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz6 (\6\:n40 \7\:n40) resistor r=75 c=0
Rz8 (\5\:mout \6\:mout) resistor r=75 c=0
Rz9 (\11\:mout \12\:mout) resistor r=75 c=0
Rz11 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz12 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz10 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Ry3 (\3\:Q \4\:Q) resistor r=62 c=0
Ry13 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry14 (\1\:VSS \4\:VSS) resistor r=62 c=0
Ry15 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry16 (\1\:VSS \8\:VSS) resistor r=15.5 c=0
Ry17 (\1\:VSS \10\:VSS) resistor r=20.6667 c=0
Ry18 (\1\:VSS \12\:VSS) resistor r=20.6667 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry19 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry20 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry21 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry22 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry23 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry24 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry25 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry2 (\5\:net331 \6\:net331) resistor r=62 c=0
Ry4 (\13\:qbint \14\:qbint) resistor r=62 c=0
Ry7 (\8\:n35 \9\:n35) resistor r=62 c=0
Ry8 (\7\:mout \8\:mout) resistor r=62 c=0
Ry9 (\14\:mout \15\:mout) resistor r=62 c=0
Ry11 (\6\:n20 \7\:n20) resistor r=62 c=0
Ry12 (\20\:CKb \21\:CKb) resistor r=62 c=0
Ry10 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry5 (n41 \2\:n41) resistor r=62 c=0
Ry6 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx5 (\2\:SN \6\:SN) resistor r=45 c=0
Rx13 (\2\:CK \4\:CK) resistor r=45 c=0
Rx12 (\2\:D D) resistor r=45 c=0
Rx1 (net331 \8\:net331) resistor r=45 c=0
Rx2 (\10\:qbint \12\:qbint) resistor r=45 c=0
Rx3 (\6\:qbint \15\:qbint) resistor r=45 c=0
Rx7 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx4 (\2\:n40 \5\:n40) resistor r=45 c=0
Rx6 (n40 \8\:n40) resistor r=45 c=0
Rx8 (\3\:mout \13\:mout) resistor r=45 c=0
Rx11 (n20 \8\:n20) resistor r=45 c=0
Rx14 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx15 (\7\:CKb \15\:CKb) resistor r=45 c=0
Rx16 (CKb \17\:CKb) resistor r=45 c=0
Rx17 (\9\:CKb \22\:CKb) resistor r=45 c=0
Rx18 (\4\:CKb \23\:CKb) resistor r=45 c=0
Rx9 (\7\:CKbb \9\:CKbb) resistor r=45 c=0
Rx10 (\4\:CKbb \10\:CKbb) resistor r=45 c=0
mn57 (\3\:QN \3\:net331 \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.537e-14 ps=1.6e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:net331 \4\:qbint \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\1\:Q \5\:qbint \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=2.537e-14 ps=1.5e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.35e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn45 (\16\:qbint \3\:n35 \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.94e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn51 (\3\:n40 \11\:qbint n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn50 (n42 \3\:SN \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=8.7e-15 ps=1.5e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn30 (n25 \4\:SN \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=5.002e-14 ps=1.5e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.4e-07 sb=5.3e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn31 (\11\:mout \3\:n20 n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.002e-14 ad=2.03e-14 ps=9.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn52 (\4\:n35 \2\:CKb \6\:n40 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=4.277e-14 ps=5.7e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.9e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn40 (\4\:n35 CKbb \5\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=4.277e-14 ps=5.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=1.5e-07 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn21 (\11\:CKbb \6\:CKb \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.965e-14 ad=2.03e-14 ps=1.51e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.22e-06 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn36 (n30 mout \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.965e-14 ad=4.35e-14 ps=1.51e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.025e-06 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn35 (\4\:n20 \8\:CKbb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.35e-14 ad=2.32e-14 ps=8.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=6.8e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn26 (\4\:n20 \10\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=4.75e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn25 (n21 \1\:D \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.037e-14 ad=8.7e-15 ps=1.52e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=3.7e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn20 (\18\:CKb \1\:CK \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.037e-14 ad=2.465e-14 ps=1.52e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19e-06 sb=1.7e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mp56 (\5\:net331 \7\:qbint \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.515e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=47.0806 \
        scb=0.0291408 scc=0.00588526 m=(1)
mp55 (\3\:Q qbint \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.762e-14 ps=1.45e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.17326e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp45 (\13\:qbint n35 \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=2.63e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.22326e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp51 (\3\:n41 \8\:qbint \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.09e-14 ad=5.482e-14 ps=8.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32558e-07 sb=8.7e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp50 (\3\:n41 \5\:SN \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.79e-14 ad=5.482e-14 ps=1.38e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.32558e-07 sb=5.7e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp30 (\14\:mout \1\:SN \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.79e-14 ad=3.44e-14 ps=1.38e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.97558e-07 sb=3.05e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp31 (\14\:mout \2\:n20 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.34e-14 ad=3.44e-14 ps=1.71e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.02558e-07 sb=1e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp52 (\8\:n35 \3\:CKbb n41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=3.44e-14 ps=1.06e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=3.45e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp40 (\8\:n35 \3\:CKb \7\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.4e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp21 (\13\:CKbb \5\:CKb \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.662e-14 ad=3.01e-14 ps=2.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.145e-06 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp35 (n31 \4\:mout \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.662e-14 ad=4.73e-14 ps=2.32e-06 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.4e-07 sb=9.45e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp36 (\6\:n20 \8\:CKb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.44e-14 ps=8.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=6.8e-07 sd=160n sca=23.0812 \
        scb=0.0214629 scc=0.00242443 m=(1)
mp26 (\6\:n20 \5\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.827e-14 ad=3.44e-14 ps=6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=4.75e-07 sd=160n sca=23.8644 \
        scb=0.0219441 scc=0.00242489 m=(1)
mp25 (n22 \3\:D \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.827e-14 ps=7.5e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.4e-07 sb=3.45e-07 sd=160n sca=24.8442 \
        scb=0.0230968 scc=0.00242964 m=(1)
mp20 (\20\:CKb \3\:CK \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=1.4e-07 sd=160n sca=28.9348 \
        scb=0.0300604 scc=0.00262798 m=(1)
ends DFFSXL
// End of subcircuit definition.

// Generated for: spectre (May  9 14:33:56 2012 )
// Library name: gsclib045
// Cell name: DFFTRX1
// View name: extracted

simulator lang=spectre

subckt DFFTRX1 CK D Q QN RN VDD VSS
mp57 (\1\:QN \4\:qint \21\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.728e-14 ad=5.46e-14 ps=1.15e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.48846e-07 sd=160n sca=34.3332 \
        scb=0.0249008 scc=0.00341086 m=(1)
C1 (D VSS) capacitor c=4.7717e-17
C2 (QN VSS) capacitor c=2.29258e-17
C3 (RN VSS) capacitor c=4.41261e-17
C4 (VDD VSS) capacitor c=2.84078e-16
C5 (CK VSS) capacitor c=5.55531e-17
C6 (Q VSS) capacitor c=9.1061e-17
C7 (qint VSS) capacitor c=2.20669e-17
C8 (qbint VSS) capacitor c=2.90219e-17
C9 (CKb VSS) capacitor c=2.4331e-17
C10 (n30 VSS) capacitor c=3.18015e-17
C11 (mout VSS) capacitor c=7.46386e-17
C12 (CKbb VSS) capacitor c=5.49826e-17
C13 (n20 VSS) capacitor c=2.57024e-17
C14 (Db VSS) capacitor c=6.18757e-17
C15 (n36 VSS) capacitor c=2.57935e-18
C16 (\1\:D VSS) capacitor c=3.05245e-17
C17 (\1\:RN VSS) capacitor c=4.29207e-17
C18 (\8\:CKb VSS) capacitor c=4.25184e-17
C19 (\7\:CKbb VSS) capacitor c=4.42637e-17
C20 (\7\:CKb VSS) capacitor c=6.78879e-17
C21 (\4\:n20 VSS) capacitor c=3.80813e-17
C22 (\2\:CKb VSS) capacitor c=6.23804e-17
C23 (\8\:qbint VSS) capacitor c=5.54417e-17
C24 (\1\:CK VSS) capacitor c=2.88704e-17
C25 (\5\:qbint VSS) capacitor c=4.30655e-17
C26 (\7\:qbint VSS) capacitor c=3.17205e-17
C27 (\4\:qint VSS) capacitor c=4.27139e-17
C28 (\3\:D VSS) capacitor c=2.5836e-17
C29 (\3\:RN VSS) capacitor c=2.86702e-17
C30 (\4\:CKb VSS) capacitor c=2.00611e-17
C31 (\9\:CKb VSS) capacitor c=2.64312e-17
C32 (\5\:CKbb VSS) capacitor c=8.66904e-17
C33 (\3\:mout VSS) capacitor c=5.15967e-17
C34 (\3\:n20 VSS) capacitor c=4.53147e-17
C35 (\3\:CKbb VSS) capacitor c=3.68785e-17
C36 (\3\:CKb VSS) capacitor c=7.4832e-17
C37 (\11\:qbint VSS) capacitor c=2.81259e-17
C38 (\3\:n30 VSS) capacitor c=3.48205e-17
C39 (\3\:CK VSS) capacitor c=4.00967e-17
C40 (\4\:qbint VSS) capacitor c=2.77695e-17
C41 (\3\:qint VSS) capacitor c=3.79207e-17
C42 (\2\:D VSS) capacitor c=3.10741e-17
C43 (\2\:RN VSS) capacitor c=3.2811e-17
C44 (\8\:CKbb VSS) capacitor c=4.97097e-17
C45 (\10\:CKb VSS) capacitor c=3.0952e-17
C46 (\6\:CKbb VSS) capacitor c=2.7869e-17
C47 (\2\:mout VSS) capacitor c=5.58227e-17
C48 (\4\:CKbb VSS) capacitor c=3.79026e-17
C49 (\2\:CKbb VSS) capacitor c=4.64e-17
C50 (\10\:qbint VSS) capacitor c=2.68754e-17
C51 (\2\:n30 VSS) capacitor c=3.06948e-17
C52 (\2\:CK VSS) capacitor c=2.67937e-17
C53 (\1\:VDD VSS) capacitor c=4.01596e-17
C54 (\3\:Db VSS) capacitor c=1.47304e-16
C55 (\13\:VDD VSS) capacitor c=1.33655e-17
C56 (\9\:CKbb VSS) capacitor c=7.09428e-17
C57 (\5\:Db VSS) capacitor c=1.51343e-16
C58 (\9\:n20 VSS) capacitor c=3.48348e-17
C59 (\15\:VDD VSS) capacitor c=2.28961e-17
C60 (\8\:mout VSS) capacitor c=3.65234e-17
C61 (\4\:n30 VSS) capacitor c=4.32379e-17
C62 (\17\:VDD VSS) capacitor c=2.3598e-17
C63 (\16\:qbint VSS) capacitor c=5.79354e-17
C64 (\13\:CKb VSS) capacitor c=1.31256e-16
C65 (\19\:VDD VSS) capacitor c=4.90209e-17
C66 (\1\:Q VSS) capacitor c=9.25889e-17
C67 (\5\:qint VSS) capacitor c=3.0486e-17
C68 (\21\:VDD VSS) capacitor c=6.17888e-17
C69 (\1\:QN VSS) capacitor c=4.74185e-17
C70 (\3\:VDD VSS) capacitor c=9.32818e-17
C71 (\11\:CKbb VSS) capacitor c=1.22674e-16
C72 (\7\:Db VSS) capacitor c=9.29247e-17
C73 (\7\:n20 VSS) capacitor c=4.92773e-17
C74 (\6\:mout VSS) capacitor c=3.35587e-17
C75 (\8\:n30 VSS) capacitor c=6.14471e-17
C76 (\14\:qbint VSS) capacitor c=7.45926e-17
C77 (\15\:CKb VSS) capacitor c=6.08521e-17
C78 (\9\:qint VSS) capacitor c=2.81219e-17
C79 (\3\:QN VSS) capacitor c=2.75168e-17
C80 (\2\:qint VSS) capacitor c=7.24445e-18
C81 (\2\:qbint VSS) capacitor c=3.37081e-17
C82 (\3\:qbint VSS) capacitor c=3.00023e-17
C83 (\9\:qbint VSS) capacitor c=2.55239e-17
C84 (\2\:n20 VSS) capacitor c=2.30758e-17
C85 (\5\:CKb VSS) capacitor c=4.55519e-17
C86 (\6\:CKb VSS) capacitor c=6.52215e-17
C87 (\7\:qint VSS) capacitor c=2.92874e-17
C88 (\8\:qint VSS) capacitor c=2.31117e-17
C89 (\4\:CK VSS) capacitor c=6.308e-17
C90 (\12\:qbint VSS) capacitor c=5.70121e-17
C91 (\13\:qbint VSS) capacitor c=4.28791e-17
C92 (\18\:qbint VSS) capacitor c=1.42323e-16
C93 (\6\:n30 VSS) capacitor c=7.79308e-17
C94 (\7\:n30 VSS) capacitor c=5.51053e-17
C95 (\4\:mout VSS) capacitor c=4.41044e-17
C96 (\5\:mout VSS) capacitor c=5.29933e-17
C97 (\11\:CKb VSS) capacitor c=7.70174e-17
C98 (\12\:CKb VSS) capacitor c=1.52536e-16
C99 (\5\:n20 VSS) capacitor c=4.74984e-17
C100 (\6\:n20 VSS) capacitor c=4.77143e-17
C101 (\13\:CKbb VSS) capacitor c=6.58651e-17
C102 (\14\:CKbb VSS) capacitor c=8.70635e-17
C103 (\15\:CKbb VSS) capacitor c=1.17426e-16
C104 (\16\:CKbb VSS) capacitor c=4.55189e-17
C105 (\17\:CKbb VSS) capacitor c=7.28455e-17
C106 (\18\:CKbb VSS) capacitor c=1.69647e-17
C107 (\4\:RN VSS) capacitor c=5.57611e-17
C108 (\4\:D VSS) capacitor c=5.95772e-17
C109 (\5\:VDD VSS) capacitor c=1.51657e-17
C110 (\7\:VDD VSS) capacitor c=1.70204e-17
C111 (\9\:VDD VSS) capacitor c=3.47012e-17
C112 (\11\:VDD VSS) capacitor c=1.17718e-17
C113 (\12\:VDD VSS) capacitor c=1.66543e-17
Rk34 (D \4\:D) resistor r=0.1975 c=0
Rk2 (\4\:QN QN) resistor r=0.0928 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3049 c=0
Rk33 (\4\:RN RN) resistor r=0.09118 c=0
Rk38 (\2\:VDD \4\:VDD) resistor r=0.4213 c=0
Rk39 (\4\:VDD \5\:VDD) resistor r=0.1827 c=0
Rk40 (\5\:VDD \6\:VDD) resistor r=0.2178 c=0
Rk41 (\6\:VDD \7\:VDD) resistor r=0.3256 c=0
Rk42 (\7\:VDD \8\:VDD) resistor r=0.1251 c=0
Rk43 (\8\:VDD \9\:VDD) resistor r=0.3707 c=0
Rk44 (\9\:VDD \10\:VDD) resistor r=0.4308 c=0
Rk45 (\10\:VDD \11\:VDD) resistor r=0.03238 c=0
Rk47 (\12\:VDD VDD) resistor r=0.2 c=0
Rk46 (\11\:VDD \12\:VDD) resistor r=0.3178 c=0
Rk48 (\5\:VDD \14\:VDD) resistor r=0.07334 c=0
Rk49 (\7\:VDD \16\:VDD) resistor r=0.102 c=0
Rk50 (\9\:VDD \18\:VDD) resistor r=0.102 c=0
Rk51 (\11\:VDD \20\:VDD) resistor r=0.2702 c=0
Rk52 (\12\:VDD \22\:VDD) resistor r=0.4324 c=0
Rk8 (\4\:CK CK) resistor r=0.2087 c=0
Rk6 (\2\:Q Q) resistor r=0.5016 c=0
Rk7 (Q \4\:Q) resistor r=0.002638 c=0
Rk53 (\2\:VSS \3\:VSS) resistor r=0.1627 c=0
Rk54 (\3\:VSS \4\:VSS) resistor r=0.288 c=0
Rk55 (\4\:VSS \5\:VSS) resistor r=0.2595 c=0
Rk56 (\5\:VSS \6\:VSS) resistor r=0.5098 c=0
Rk57 (\6\:VSS \7\:VSS) resistor r=0.1301 c=0
Rk58 (\7\:VSS \8\:VSS) resistor r=0.3256 c=0
Rk59 (\8\:VSS \9\:VSS) resistor r=0.3103 c=0
Rk61 (\10\:VSS VSS) resistor r=0.09998 c=0
Rk60 (\9\:VSS \10\:VSS) resistor r=0.1151 c=0
Rk62 (\3\:VSS \12\:VSS) resistor r=0.3709 c=0
Rk63 (\5\:VSS \14\:VSS) resistor r=0.04326 c=0
Rk64 (\6\:VSS \16\:VSS) resistor r=0.3572 c=0
Rk65 (\8\:VSS \18\:VSS) resistor r=0.2962 c=0
Rk66 (\9\:VSS \20\:VSS) resistor r=0.07334 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.09348 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.119 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.1294 c=0
Rk9 (\12\:qbint \13\:qbint) resistor r=0.23 c=0
Rk10 (\13\:qbint \15\:qbint) resistor r=0.1863 c=0
Rk11 (\13\:qbint \17\:qbint) resistor r=0.3293 c=0
Rk12 (\15\:qbint \18\:qbint) resistor r=0.8158 c=0
Rk19 (\11\:CKb \12\:CKb) resistor r=0.5297 c=0
Rk20 (\12\:CKb \14\:CKb) resistor r=0.9863 c=0
Rk21 (\14\:CKb \16\:CKb) resistor r=0.272 c=0
Rk13 (\5\:n30 \6\:n30) resistor r=0.3034 c=0
Rk14 (\6\:n30 \7\:n30) resistor r=0.2335 c=0
Rk15 (\6\:n30 \9\:n30) resistor r=0.3782 c=0
Rk16 (\4\:mout \5\:mout) resistor r=0.196 c=0
Rk17 (\5\:mout \7\:mout) resistor r=0.1123 c=0
Rk18 (\5\:mout \9\:mout) resistor r=0.2572 c=0
Rk25 (\10\:CKbb \12\:CKbb) resistor r=0.4919 c=0
Rk26 (\12\:CKbb \13\:CKbb) resistor r=0.3643 c=0
Rk27 (\13\:CKbb \14\:CKbb) resistor r=0.2125 c=0
Rk28 (\14\:CKbb \15\:CKbb) resistor r=0.7312 c=0
Rk29 (\15\:CKbb \16\:CKbb) resistor r=0.1581 c=0
Rk30 (\13\:CKbb \17\:CKbb) resistor r=0.3487 c=0
Rk31 (\14\:CKbb \18\:CKbb) resistor r=0.02532 c=0
Rk32 (\15\:CKbb \19\:CKbb) resistor r=0.03037 c=0
Rk22 (\5\:n20 \6\:n20) resistor r=0.2126 c=0
Rk23 (\6\:n20 \8\:n20) resistor r=0.2377 c=0
Rk24 (\6\:n20 \10\:n20) resistor r=0.1554 c=0
Rk35 (\2\:Db \4\:Db) resistor r=0.4946 c=0
Rk36 (\4\:Db \6\:Db) resistor r=0.8953 c=0
Rk37 (\6\:Db \8\:Db) resistor r=0.4925 c=0
Rl36 (\1\:D \2\:D) resistor r=72.4273 c=0
Rl37 (\2\:D \3\:D) resistor r=38.2566 c=0
Rl34 (\1\:RN \2\:RN) resistor r=77.6148 c=0
Rl35 (\2\:RN \3\:RN) resistor r=39.1533 c=0
Rl10 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl11 (\2\:CK \3\:CK) resistor r=56.461 c=0
Rl1 (qint \2\:qint) resistor r=5.915 c=0
Rl3 (\2\:qint \4\:qint) resistor r=34.3295 c=0
Rl2 (\2\:qint \3\:qint) resistor r=49.7141 c=0
Rl4 (qbint \2\:qbint) resistor r=37.477 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=72.0924 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=5.1042 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=53.0797 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=35.772 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=147.248 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=111.253 c=0
Rl16 (\9\:qbint \11\:qbint) resistor r=36.2526 c=0
Rl15 (\9\:qbint \10\:qbint) resistor r=11.4953 c=0
Rl18 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl19 (\2\:CKb \3\:CKb) resistor r=210.67 c=0
Rl33 (\7\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl31 (\5\:CKb \8\:CKb) resistor r=99.3167 c=0
Rl28 (\4\:CKb \5\:CKb) resistor r=38.9332 c=0
Rl30 (\6\:CKb \7\:CKb) resistor r=161.082 c=0
Rl32 (\6\:CKb \9\:CKb) resistor r=30.4507 c=0
Rl29 (\5\:CKb \6\:CKb) resistor r=181.633 c=0
Rl12 (n30 \2\:n30) resistor r=29.5379 c=0
Rl13 (\2\:n30 \3\:n30) resistor r=100.692 c=0
Rl24 (mout \2\:mout) resistor r=103.079 c=0
Rl25 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl27 (\7\:CKbb \8\:CKbb) resistor r=53.079 c=0
Rl26 (\5\:CKbb \6\:CKbb) resistor r=58.3841 c=0
Rl20 (\3\:CKbb \4\:CKbb) resistor r=37.2302 c=0
Rl17 (CKbb \2\:CKbb) resistor r=50.6918 c=0
Rl21 (n20 \2\:n20) resistor r=10.7022 c=0
Rl23 (\2\:n20 \4\:n20) resistor r=51.6372 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=95.868 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz12 (\3\:VDD \4\:VDD) resistor r=25 c=0
Rz13 (\3\:VDD \6\:VDD) resistor r=15 c=0
Rz14 (\3\:VDD \8\:VDD) resistor r=18.75 c=0
Rz15 (\3\:VDD \10\:VDD) resistor r=6.25 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz16 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz17 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz18 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz19 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz20 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz4 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz7 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz5 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz6 (\6\:mout \7\:mout) resistor r=75 c=0
Rz9 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz8 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\7\:Db \8\:Db) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry12 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry13 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry14 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry15 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry16 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry17 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry3 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry18 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry19 (\1\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry20 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry21 (\1\:VSS \10\:VSS) resistor r=20.6667 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry4 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry7 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry5 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry6 (\8\:mout \9\:mout) resistor r=62 c=0
Ry9 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry8 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry10 (\3\:Db \4\:Db) resistor r=62 c=0
Ry11 (\5\:Db \6\:Db) resistor r=62 c=0
Rx15 (\2\:D \4\:D) resistor r=45 c=0
Rx14 (\2\:RN \4\:RN) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx3 (\10\:qbint \12\:qbint) resistor r=45 c=0
Rx4 (\6\:qbint \18\:qbint) resistor r=45 c=0
Rx7 (\10\:CKb \11\:CKb) resistor r=45 c=0
Rx8 (CKb \12\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx10 (\2\:CKbb \16\:CKbb) resistor r=45 c=0
Rx11 (\8\:CKbb \17\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \18\:CKbb) resistor r=45 c=0
Rx13 (\4\:CKbb \19\:CKbb) resistor r=45 c=0
Rx9 (n20 \5\:n20) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \19\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.273e-14 ad=3.64e-14 ps=1.67e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\9\:qint \4\:qbint \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\3\:Q qbint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=3.64e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.18462e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (\15\:CKb \3\:CK \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=2.755e-14 ps=9.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn45 (\14\:qbint \3\:n30 \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.19e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.85e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn50 (n35 \11\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=1.812e-14 ps=7.3e-07 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.585e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn51 (\8\:n30 \3\:CKb n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.812e-14 ad=3.625e-14 ps=5.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=1.415e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn40 (\8\:n30 \3\:CKbb \6\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=3.625e-14 ps=7.2e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.12e-06 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn30 (\6\:mout \3\:n20 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.11e-14 ad=3.118e-14 ps=1.55e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13e-06 sb=8.6e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn35 (n25 \3\:mout \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.11e-14 ad=8.7e-15 ps=1.55e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.395e-06 sb=5.95e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn36 (\7\:n20 \5\:CKbb n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-06 sb=4.9e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn25 (\7\:n20 \9\:CKb \7\:Db VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.133e-14 ad=2.32e-14 ps=8.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.705e-06 sb=2.85e-07 sd=160n sca=19.1673 \
        scb=0.0200674 scc=0.00182521 m=(1)
mn21 (\11\:CKbb \4\:CKb \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.61e-14 ad=2.03e-14 ps=6.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn0 (n0 \3\:RN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=2.03e-14 ps=6.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=4.1e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (Db \3\:D n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=2.03e-14 \
        ad=3.263e-14 ps=5.7e-07 pd=7.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.5e-07 sb=2.25e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mp56 (\5\:qint \7\:qbint \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.728e-14 ad=3.01e-14 ps=1.15e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=46.9517 scb=0.029008 \
        scc=0.00588492 m=(1)
mp55 (\1\:Q \5\:qbint \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.61e-14 ad=5.46e-14 ps=1.26e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.24679e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp20 (\13\:CKb \1\:CK \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.61e-14 ad=4.085e-14 ps=1.26e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.9e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp45 (\16\:qbint n30 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.725e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp50 (n36 \8\:qbint \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.332e-14 ps=1.62e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.46e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp51 (\4\:n30 CKbb n36 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.332e-14 ad=3.44e-14 ps=7.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=1.26e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp40 (\4\:n30 \2\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.912e-14 ad=3.44e-14 ps=9.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.1e-07 sb=1.055e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp30 (\8\:mout \4\:n20 \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.23e-14 ad=5.912e-14 ps=1.62e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13e-06 sb=7.35e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp35 (n26 mout \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=1.72e-14 ps=1.62e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.395e-06 sb=4.7e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp36 (\9\:n20 \7\:CKb n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=3.44e-14 ps=5.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52e-06 sb=3.45e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp25 (\9\:n20 \7\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.725e-06 sb=1.4e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp21 (\9\:CKbb \8\:CKb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.995e-14 ad=3.01e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.9e-07 sd=160n sca=15.6591 \
        scb=0.0151507 scc=0.000885469 m=(1)
mp0 (\3\:Db \1\:RN \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.995e-14 ad=4.515e-14 ps=1.7e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=3.95e-07 sd=160n sca=17.4637 \
        scb=0.0170276 scc=0.000892958 m=(1)
mp1 (\3\:Db \1\:D \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=1.4e-07 sd=160n sca=24.9308 \
        scb=0.0292329 scc=0.0015565 m=(1)
ends DFFTRX1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:34:34 2012 )
// Library name: gsclib045
// Cell name: DFFTRX2
// View name: extracted

simulator lang=spectre

subckt DFFTRX2 CK D Q QN RN VDD VSS
mp1 (\4\:Db \4\:D \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.548e-14 ps=7.1e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.45e-07 sd=160n sca=27.2529 \
        scb=0.0321202 scc=0.00197428 m=(1)
C1 (CK VSS) capacitor c=5.08992e-17
C2 (Q VSS) capacitor c=3.4984e-17
C3 (QN VSS) capacitor c=4.23702e-17
C4 (RN VSS) capacitor c=3.45334e-17
C5 (VDD VSS) capacitor c=2.73893e-16
C6 (D VSS) capacitor c=1.67759e-17
C7 (n0 VSS) capacitor c=1.48018e-18
C8 (Db VSS) capacitor c=9.1574e-17
C9 (CKbb VSS) capacitor c=3.82528e-17
C10 (CKb VSS) capacitor c=3.02882e-17
C11 (n20 VSS) capacitor c=4.61225e-17
C12 (mout VSS) capacitor c=5.68065e-17
C13 (n30 VSS) capacitor c=6.23014e-17
C14 (qbint VSS) capacitor c=3.45326e-17
C15 (qint VSS) capacitor c=1.68827e-16
C16 (n36 VSS) capacitor c=2.01545e-18
C17 (\15\:qbint VSS) capacitor c=4.08038e-17
C18 (\5\:qbint VSS) capacitor c=4.38925e-16
C19 (\1\:CK VSS) capacitor c=2.58941e-17
C20 (\4\:qbint VSS) capacitor c=4.68159e-17
C21 (\7\:CKbb VSS) capacitor c=5.26868e-17
C22 (\9\:CKb VSS) capacitor c=6.49824e-17
C23 (\2\:CKb VSS) capacitor c=8.67872e-17
C24 (\7\:CKb VSS) capacitor c=5.4114e-17
C25 (\4\:RN VSS) capacitor c=4.00798e-17
C26 (\4\:D VSS) capacitor c=4.08334e-17
C27 (\14\:qbint VSS) capacitor c=2.71586e-17
C28 (\3\:CK VSS) capacitor c=3.22246e-17
C29 (\4\:n30 VSS) capacitor c=3.23833e-17
C30 (\3\:qbint VSS) capacitor c=7.96728e-17
C31 (\8\:CKb VSS) capacitor c=8.83403e-17
C32 (\5\:CKbb VSS) capacitor c=3.21655e-17
C33 (\4\:n20 VSS) capacitor c=3.15445e-17
C34 (\3\:mout VSS) capacitor c=7.04526e-17
C35 (\3\:CKbb VSS) capacitor c=8.05643e-17
C36 (\6\:CKb VSS) capacitor c=2.10071e-17
C37 (\5\:CKb VSS) capacitor c=3.49788e-17
C38 (\3\:RN VSS) capacitor c=7.57045e-17
C39 (\1\:D VSS) capacitor c=4.54873e-17
C40 (\13\:qbint VSS) capacitor c=2.08236e-17
C41 (\2\:CK VSS) capacitor c=3.03682e-17
C42 (\3\:n30 VSS) capacitor c=5.11472e-17
C43 (\8\:CKbb VSS) capacitor c=5.37787e-17
C44 (\10\:CKb VSS) capacitor c=2.16512e-17
C45 (\6\:CKbb VSS) capacitor c=3.84398e-17
C46 (\3\:n20 VSS) capacitor c=1.77634e-17
C47 (\2\:mout VSS) capacitor c=5.14698e-17
C48 (\4\:CKbb VSS) capacitor c=2.53823e-17
C49 (\2\:CKbb VSS) capacitor c=4.53319e-17
C50 (\1\:RN VSS) capacitor c=2.42197e-17
C51 (\3\:D VSS) capacitor c=1.04274e-17
C52 (\11\:qint VSS) capacitor c=1.75409e-17
C53 (\3\:QN VSS) capacitor c=9.16781e-17
C54 (\1\:Q VSS) capacitor c=9.69673e-17
C55 (\12\:CKb VSS) capacitor c=1.48669e-16
C56 (\25\:qbint VSS) capacitor c=3.64546e-17
C57 (\21\:VDD VSS) capacitor c=2.4644e-17
C58 (\7\:n30 VSS) capacitor c=6.27995e-17
C59 (\8\:mout VSS) capacitor c=2.19409e-17
C60 (\23\:VDD VSS) capacitor c=1.86962e-17
C61 (\9\:n20 VSS) capacitor c=3.86695e-17
C62 (\8\:Db VSS) capacitor c=3.01569e-17
C63 (\18\:CKbb VSS) capacitor c=8.34043e-17
C64 (\25\:VDD VSS) capacitor c=1.83788e-17
C65 (\4\:Db VSS) capacitor c=1.43705e-16
C66 (\12\:VDD VSS) capacitor c=3.64308e-17
C67 (\1\:VDD VSS) capacitor c=6.28213e-17
C68 (\7\:qint VSS) capacitor c=2.47552e-17
C69 (\1\:QN VSS) capacitor c=3.90811e-17
C70 (\3\:Q VSS) capacitor c=3.61603e-17
C71 (\15\:CKb VSS) capacitor c=9.53745e-17
C72 (\19\:qbint VSS) capacitor c=1.02896e-16
C73 (\9\:n30 VSS) capacitor c=6.09114e-17
C74 (\4\:mout VSS) capacitor c=7.18919e-17
C75 (\7\:n20 VSS) capacitor c=3.96035e-17
C76 (\13\:CKbb VSS) capacitor c=8.26882e-17
C77 (\6\:Db VSS) capacitor c=8.7453e-17
C78 (\2\:D VSS) capacitor c=3.2531e-17
C79 (\2\:RN VSS) capacitor c=3.2732e-17
C80 (\3\:CKb VSS) capacitor c=5.66086e-17
C81 (\4\:CKb VSS) capacitor c=4.58641e-17
C82 (\2\:n20 VSS) capacitor c=2.43962e-17
C83 (\2\:qbint VSS) capacitor c=2.7744e-17
C84 (\5\:D VSS) capacitor c=8.61271e-17
C85 (\5\:RN VSS) capacitor c=9.03087e-17
C86 (\3\:Db VSS) capacitor c=9.39787e-17
C87 (\5\:n20 VSS) capacitor c=4.98616e-17
C88 (\6\:n20 VSS) capacitor c=5.27153e-17
C89 (\6\:mout VSS) capacitor c=5.20122e-17
C90 (\7\:mout VSS) capacitor c=3.93014e-17
C91 (\9\:CKbb VSS) capacitor c=4.56266e-17
C92 (\10\:CKbb VSS) capacitor c=1.23213e-16
C93 (\11\:CKbb VSS) capacitor c=9.34619e-17
C94 (\12\:CKbb VSS) capacitor c=6.43623e-17
C95 (\15\:CKbb VSS) capacitor c=2.39465e-17
C96 (\16\:CKbb VSS) capacitor c=1.3226e-17
C97 (\17\:CKbb VSS) capacitor c=6.96461e-17
C98 (\5\:n30 VSS) capacitor c=3.32009e-17
C99 (\6\:n30 VSS) capacitor c=5.02951e-17
C100 (\11\:CKb VSS) capacitor c=1.4872e-16
C101 (\14\:CKb VSS) capacitor c=6.84503e-17
C102 (\4\:CK VSS) capacitor c=7.06405e-17
C103 (\16\:qbint VSS) capacitor c=6.1087e-17
C104 (\21\:qbint VSS) capacitor c=4.82449e-17
C105 (\22\:qbint VSS) capacitor c=3.42877e-17
C106 (\9\:qint VSS) capacitor c=2.52949e-17
C107 (\10\:qint VSS) capacitor c=3.50572e-17
C108 (\3\:VDD VSS) capacitor c=2.58662e-16
C109 (\7\:VDD VSS) capacitor c=4.15081e-17
C110 (\9\:VDD VSS) capacitor c=2.79789e-17
C111 (\10\:VDD VSS) capacitor c=2.28819e-17
Rk27 (CK \4\:CK) resistor r=0.07932 c=0
Rk28 (\2\:Q Q) resistor r=0.3362 c=0
Rk29 (Q \4\:Q) resistor r=0.03326 c=0
Rk30 (\2\:QN QN) resistor r=0.02733 c=0
Rk31 (QN \4\:QN) resistor r=0.256 c=0
Rk2 (RN \5\:RN) resistor r=0.07501 c=0
Rk59 (\2\:VDD \3\:VDD) resistor r=0.1177 c=0
Rk63 (\3\:VDD \7\:VDD) resistor r=0.4434 c=0
Rk64 (\7\:VDD \8\:VDD) resistor r=0.4311 c=0
Rk65 (\8\:VDD \9\:VDD) resistor r=0.07909 c=0
Rk66 (\9\:VDD \10\:VDD) resistor r=0.5352 c=0
Rk68 (\11\:VDD VDD) resistor r=0.1006 c=0
Rk67 (\10\:VDD \11\:VDD) resistor r=0.1352 c=0
Rk69 (VDD \13\:VDD) resistor r=0.3494 c=0
Rk74 (\7\:VDD \22\:VDD) resistor r=0.1025 c=0
Rk75 (\9\:VDD \24\:VDD) resistor r=0.0433 c=0
Rk76 (\10\:VDD \26\:VDD) resistor r=0.1439 c=0
Rk1 (D \5\:D) resistor r=0.01969 c=0
Rk43 (\2\:VSS \3\:VSS) resistor r=0.08756 c=0
Rk47 (\3\:VSS \7\:VSS) resistor r=0.3424 c=0
Rk48 (\7\:VSS \8\:VSS) resistor r=0.07503 c=0
Rk49 (\8\:VSS \9\:VSS) resistor r=0.5212 c=0
Rk50 (\9\:VSS \10\:VSS) resistor r=0.406 c=0
Rk52 (\11\:VSS VSS) resistor r=0.2027 c=0
Rk51 (\10\:VSS \11\:VSS) resistor r=0.1477 c=0
Rk56 (\8\:VSS \19\:VSS) resistor r=0.3459 c=0
Rk57 (\9\:VSS \21\:VSS) resistor r=0.1025 c=0
Rk58 (\11\:VSS \23\:VSS) resistor r=0.2599 c=0
Rk3 (\2\:Db \3\:Db) resistor r=0.4146 c=0
Rk4 (\3\:Db \5\:Db) resistor r=0.5495 c=0
Rk5 (\5\:Db \7\:Db) resistor r=0.5506 c=0
Rk6 (\3\:Db \9\:Db) resistor r=0.07429 c=0
Rk13 (\9\:CKbb \10\:CKbb) resistor r=0.2231 c=0
Rk14 (\10\:CKbb \11\:CKbb) resistor r=0.8883 c=0
Rk15 (\11\:CKbb \12\:CKbb) resistor r=0.2322 c=0
Rk16 (\12\:CKbb \14\:CKbb) resistor r=0.2623 c=0
Rk17 (\10\:CKbb \15\:CKbb) resistor r=0.02784 c=0
Rk18 (\11\:CKbb \16\:CKbb) resistor r=0.02283 c=0
Rk19 (\12\:CKbb \17\:CKbb) resistor r=0.359 c=0
Rk20 (\14\:CKbb \19\:CKbb) resistor r=0.5014 c=0
Rk24 (\11\:CKb \13\:CKb) resistor r=0.9665 c=0
Rk25 (\11\:CKb \14\:CKb) resistor r=0.5498 c=0
Rk26 (\13\:CKb \16\:CKb) resistor r=0.4824 c=0
Rk7 (\5\:n20 \6\:n20) resistor r=0.2851 c=0
Rk8 (\6\:n20 \8\:n20) resistor r=0.1277 c=0
Rk9 (\6\:n20 \10\:n20) resistor r=0.2533 c=0
Rk10 (\5\:mout \6\:mout) resistor r=0.2946 c=0
Rk11 (\6\:mout \7\:mout) resistor r=0.2417 c=0
Rk12 (\6\:mout \9\:mout) resistor r=0.1176 c=0
Rk21 (\5\:n30 \6\:n30) resistor r=0.132 c=0
Rk22 (\6\:n30 \8\:n30) resistor r=0.3714 c=0
Rk23 (\6\:n30 \10\:n30) resistor r=0.2777 c=0
Rk32 (\16\:qbint \5\:qbint) resistor r=0.4971 c=0
Rk34 (\5\:qbint \20\:qbint) resistor r=0.5528 c=0
Rk35 (\20\:qbint \21\:qbint) resistor r=0.4085 c=0
Rk36 (\21\:qbint \22\:qbint) resistor r=0.1162 c=0
Rk39 (\21\:qbint \26\:qbint) resistor r=0.1458 c=0
Rk40 (\8\:qint \9\:qint) resistor r=0.1713 c=0
Rk41 (\9\:qint \10\:qint) resistor r=0.1954 c=0
Rk42 (\9\:qint \12\:qint) resistor r=0.1063 c=0
Rl30 (\1\:CK \2\:CK) resistor r=26.9231 c=0
Rl31 (\2\:CK \3\:CK) resistor r=41.7582 c=0
Rl6 (\2\:RN \4\:RN) resistor r=34.3295 c=0
Rl5 (\2\:RN \3\:RN) resistor r=157.99 c=0
Rl4 (\1\:RN \2\:RN) resistor r=0.5213 c=0
Rl3 (\2\:D \4\:D) resistor r=130.231 c=0
Rl1 (\1\:D \2\:D) resistor r=57.2019 c=0
Rl2 (\2\:D \3\:D) resistor r=4.5402 c=0
Rl21 (\7\:CKbb \8\:CKbb) resistor r=46.3695 c=0
Rl20 (\5\:CKbb \6\:CKbb) resistor r=48.7687 c=0
Rl14 (\3\:CKbb \4\:CKbb) resistor r=55.0021 c=0
Rl7 (CKbb \2\:CKbb) resistor r=62.9746 c=0
Rl8 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl22 (\8\:CKb \9\:CKb) resistor r=218.796 c=0
Rl23 (\9\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl9 (\2\:CKb \3\:CKb) resistor r=234.159 c=0
Rl12 (\3\:CKb \6\:CKb) resistor r=30.4507 c=0
Rl13 (\4\:CKb \7\:CKb) resistor r=99.3618 c=0
Rl11 (\4\:CKb \5\:CKb) resistor r=102.754 c=0
Rl10 (\3\:CKb \4\:CKb) resistor r=139.705 c=0
Rl17 (n20 \2\:n20) resistor r=106.572 c=0
Rl19 (\2\:n20 \4\:n20) resistor r=37.3411 c=0
Rl18 (\2\:n20 \3\:n20) resistor r=1.2301 c=0
Rl15 (mout \2\:mout) resistor r=24.2328 c=0
Rl16 (\2\:mout \3\:mout) resistor r=101.156 c=0
Rl27 (n30 \2\:n30) resistor r=123.385 c=0
Rl29 (\2\:n30 \4\:n30) resistor r=23.7402 c=0
Rl28 (\2\:n30 \3\:n30) resistor r=4.3511 c=0
Rl44 (\14\:qbint \15\:qbint) resistor r=97.6426 c=0
Rl43 (\13\:qbint \14\:qbint) resistor r=31.9846 c=0
Rl24 (\2\:qbint qbint) resistor r=10.9374 c=0
Rl26 (\2\:qbint \4\:qbint) resistor r=37.3411 c=0
Rl25 (\2\:qbint \3\:qbint) resistor r=106.581 c=0
Rz8 (\4\:Q \3\:Q) resistor r=75 c=0
Rz9 (\2\:QN \1\:QN) resistor r=75 c=0
Rz18 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz19 (\3\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz20 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz21 (\11\:VDD \1\:VDD) resistor r=25 c=0
Rz15 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz16 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz17 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz1 (Db \2\:Db) resistor r=75 c=0
Rz2 (\6\:Db \7\:Db) resistor r=75 c=0
Rz5 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz7 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz3 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz4 (\4\:mout \5\:mout) resistor r=75 c=0
Rz6 (\9\:n30 \10\:n30) resistor r=75 c=0
Rz10 (\20\:qbint \19\:qbint) resistor r=75 c=0
Rz11 (\8\:qint \7\:qint) resistor r=75 c=0
Ry8 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry9 (\4\:QN \3\:QN) resistor r=20.6667 c=0
Ry16 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry21 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry22 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry23 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry13 (\3\:VSS \1\:VSS) resistor r=31 c=0
Ry14 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\10\:VSS \1\:VSS) resistor r=7.75 c=0
Ry1 (\4\:Db \5\:Db) resistor r=62 c=0
Ry2 (\8\:Db \9\:Db) resistor r=62 c=0
Ry5 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry7 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry3 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry6 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry10 (\26\:qbint \25\:qbint) resistor r=62 c=0
Ry11 (\12\:qint \11\:qint) resistor r=62 c=0
Rx12 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\1\:RN \5\:RN) resistor r=45 c=0
Rx1 (\3\:D \5\:D) resistor r=45 c=0
Rx5 (\8\:CKbb \9\:CKbb) resistor r=45 c=0
Rx6 (\6\:CKbb \15\:CKbb) resistor r=45 c=0
Rx7 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \17\:CKbb) resistor r=45 c=0
Rx10 (\10\:CKb \11\:CKb) resistor r=45 c=0
Rx11 (CKb \14\:CKb) resistor r=45 c=0
Rx3 (\3\:n20 \5\:n20) resistor r=45 c=0
Rx4 (\2\:mout \7\:mout) resistor r=45 c=0
Rx9 (\3\:n30 \5\:n30) resistor r=45 c=0
Rx13 (\16\:qbint \13\:qbint) resistor r=45 c=0
Rx14 (\22\:qbint qbint) resistor r=45 c=0
Rx17 (\10\:qint qint) resistor r=45 c=0
mn1 (\6\:Db \1\:D n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=4.5e-07 sd=160n sca=9.50767 scb=0.00818119 \
        scc=0.00019576 m=(1)
mn0 (n0 \3\:RN \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn21 (\13\:CKbb \5\:CKb \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn25 (\7\:n20 \6\:CKb Db VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=4.93e-14 ps=5.7e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.88e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\7\:n20 \3\:CKbb n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.43e-15 ad=4.93e-14 ps=4.2e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=1.495e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\4\:mout \4\:n20 \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.41e-14 ad=3.988e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=1.12e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn35 (n25 \3\:mout \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=9.43e-15 ps=1.6e-06 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=1.385e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\9\:n30 \5\:CKbb \4\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=3.988e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=8e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn51 (\9\:n30 \8\:CKb n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.988e-14 ps=4.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=4.8e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (n35 \3\:qbint \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=8.7e-15 ps=7.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.645e-06 sb=3.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\19\:qbint \4\:n30 \18\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.595e-14 ad=2.87e-14 ps=7.9e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.37073e-06 sb=1.4e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn20 (\15\:CKb \3\:CK \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=3.48e-14 ps=1.7e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.4e-07 sb=1.395e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn55_1__rcx (\3\:Q \5\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=9.635e-14 ad=4.16e-14 ps=1.65e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.84712e-07 sb=9.76058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn57 (\1\:QN qint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.273e-14 ad=4.16e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.54712e-07 sb=5.06058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn56 (\7\:qint \14\:qbint \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.985e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.495e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp0 (\4\:Db \4\:RN \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.548e-14 ps=1.45e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=3.35e-07 sd=160n sca=19.1286 \
        scb=0.0193134 scc=0.00106338 m=(1)
mp21 (\18\:CKbb \7\:CKb \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.515e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=1.4e-07 sd=160n sca=17.1675 \
        scb=0.0165438 scc=0.00103968 m=(1)
mp25 (\9\:n20 CKbb \8\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.775e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp36 (\9\:n20 \2\:CKb n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=3.44e-14 ps=5.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.57e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp35 (n26 mout \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.99e-14 ad=1.505e-14 ps=1.58e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.455e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp30 (\8\:mout n20 \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.99e-14 ad=8.17e-14 ps=1.58e-06 pd=1.19e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.19e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp40 (\7\:n30 \9\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.17e-14 ad=3.44e-14 ps=1.19e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=7.65e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp51 (\7\:n30 \7\:CKbb n36 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.365e-14 ad=3.44e-14 ps=6.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.355e-06 sb=5.6e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp50 (n36 \4\:qbint \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.465e-14 ad=2.365e-14 ps=1.58e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.51e-06 sb=4.05e-07 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp45 (\25\:qbint n30 \21\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.465e-14 ad=4.34e-14 ps=1.58e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28315e-06 sb=1.4e-07 sd=160n sca=12.3129 \
        scb=0.0108562 scc=0.00039161 m=(1)
mp20 (\12\:CKb \1\:CK \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.288e-14 ad=3.01e-14 ps=1.23e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.26e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp55_1__rcx (\1\:Q \5\:qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.764e-14 ad=6.24e-14 ps=1.165e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.88846e-07 sb=8.84551e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp57 (\3\:QN qint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.388e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.98846e-07 sb=4.74551e-07 sd=160n sca=31.0979 \
        scb=0.0204275 scc=0.00336106 m=(2)
mp56 (\11\:qint \15\:qbint \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26e-06 sb=1.4e-07 sd=160n sca=52.4731 \
        scb=0.0379902 scc=0.00614793 m=(1)
ends DFFTRX2
// End of subcircuit definition.

// Generated for: spectre (May  9 14:35:18 2012 )
// Library name: gsclib045
// Cell name: DFFTRX4
// View name: extracted

simulator lang=spectre

subckt DFFTRX4 CK D Q QN RN VDD VSS
mp0 (\4\:Db \3\:RN \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.915e-14 ad=3.44e-14 ps=1.54e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.05e-07 sd=160n sca=26.9085 scb=0.0317837 \
        scc=0.0019009 m=(1)
C1 (CK VSS) capacitor c=6.76066e-17
C2 (Q VSS) capacitor c=2.3653e-17
C3 (D VSS) capacitor c=4.89379e-17
C4 (QN VSS) capacitor c=1.66545e-17
C5 (VDD VSS) capacitor c=2.8312e-16
C6 (RN VSS) capacitor c=3.71072e-17
C7 (Db VSS) capacitor c=7.09853e-17
C8 (CKb VSS) capacitor c=7.68948e-17
C9 (CKbb VSS) capacitor c=3.29492e-17
C10 (n20 VSS) capacitor c=5.01875e-17
C11 (mout VSS) capacitor c=6.20494e-17
C12 (n30 VSS) capacitor c=2.17128e-16
C13 (qbint VSS) capacitor c=2.98922e-17
C14 (qint VSS) capacitor c=2.75843e-16
C15 (n36 VSS) capacitor c=5.26647e-18
C16 (\22\:qbint VSS) capacitor c=4.66957e-17
C17 (\5\:qbint VSS) capacitor c=2.67587e-16
C18 (\4\:qbint VSS) capacitor c=3.83567e-17
C19 (\7\:CKbb VSS) capacitor c=5.03559e-17
C20 (\2\:CKb VSS) capacitor c=1.03619e-16
C21 (\3\:CKb VSS) capacitor c=1.18891e-16
C22 (\8\:CKb VSS) capacitor c=4.57857e-17
C23 (\1\:CK VSS) capacitor c=4.09199e-17
C24 (\1\:D VSS) capacitor c=3.32671e-17
C25 (\3\:RN VSS) capacitor c=3.44715e-17
C26 (\20\:qbint VSS) capacitor c=3.37834e-17
C27 (\3\:qbint VSS) capacitor c=6.22418e-17
C28 (\5\:CKbb VSS) capacitor c=3.551e-17
C29 (\3\:n20 VSS) capacitor c=3.23212e-17
C30 (\3\:mout VSS) capacitor c=6.97711e-17
C31 (\3\:CKbb VSS) capacitor c=8.32264e-17
C32 (\7\:CKb VSS) capacitor c=2.79172e-17
C33 (\9\:CKb VSS) capacitor c=2.71903e-17
C34 (\3\:CK VSS) capacitor c=3.24376e-17
C35 (\3\:D VSS) capacitor c=4.70675e-17
C36 (\1\:RN VSS) capacitor c=4.39296e-17
C37 (\21\:qbint VSS) capacitor c=3.99268e-17
C38 (\8\:CKbb VSS) capacitor c=4.02261e-17
C39 (\6\:CKbb VSS) capacitor c=3.47636e-17
C40 (\2\:n20 VSS) capacitor c=3.58999e-17
C41 (\2\:mout VSS) capacitor c=5.698e-17
C42 (\4\:CKbb VSS) capacitor c=2.85952e-17
C43 (\2\:CKbb VSS) capacitor c=4.76756e-17
C44 (\6\:CKb VSS) capacitor c=5.1126e-17
C45 (\2\:CK VSS) capacitor c=4.56789e-17
C46 (\2\:D VSS) capacitor c=4.23087e-17
C47 (\2\:RN VSS) capacitor c=4.29349e-17
C48 (\19\:qint VSS) capacitor c=3.50198e-17
C49 (\1\:VDD VSS) capacitor c=4.65321e-16
C50 (\1\:Q VSS) capacitor c=1.52391e-16
C51 (\30\:qbint VSS) capacitor c=5.97645e-17
C52 (\10\:n30 VSS) capacitor c=5.84428e-17
C53 (\4\:mout VSS) capacitor c=2.34038e-17
C54 (\22\:VDD VSS) capacitor c=3.63519e-17
C55 (\8\:n20 VSS) capacitor c=3.02801e-17
C56 (\9\:Db VSS) capacitor c=2.53351e-17
C57 (\16\:CKbb VSS) capacitor c=7.73829e-17
C58 (\26\:VDD VSS) capacitor c=1.93914e-17
C59 (\14\:CKb VSS) capacitor c=1.19596e-16
C60 (\30\:VDD VSS) capacitor c=2.07787e-17
C61 (\4\:Db VSS) capacitor c=3.74353e-17
C62 (\34\:VDD VSS) capacitor c=6.8113e-18
C63 (\3\:VDD VSS) capacitor c=1.03975e-16
C64 (\15\:qint VSS) capacitor c=4.40671e-17
C65 (\1\:QN VSS) capacitor c=1.19302e-16
C66 (\24\:qbint VSS) capacitor c=2.20408e-16
C67 (\8\:n30 VSS) capacitor c=6.51029e-17
C68 (\8\:mout VSS) capacitor c=5.06322e-17
C69 (\6\:n20 VSS) capacitor c=3.8344e-17
C70 (\7\:Db VSS) capacitor c=9.90245e-17
C71 (\11\:CKbb VSS) capacitor c=8.87237e-17
C72 (\12\:CKb VSS) capacitor c=1.9152e-17
C73 (\4\:CKb VSS) capacitor c=7.94873e-17
C74 (\2\:qbint VSS) capacitor c=3.38822e-17
C75 (\4\:RN VSS) capacitor c=5.57677e-17
C76 (\4\:D VSS) capacitor c=8.62431e-17
C77 (\4\:CK VSS) capacitor c=6.91674e-17
C78 (\10\:CKb VSS) capacitor c=8.30486e-17
C79 (\11\:CKb VSS) capacitor c=1.01551e-16
C80 (\3\:Db VSS) capacitor c=1.56858e-16
C81 (\6\:Db VSS) capacitor c=1.25744e-16
C82 (\4\:n20 VSS) capacitor c=5.79374e-17
C83 (\5\:n20 VSS) capacitor c=5.54232e-17
C84 (\6\:mout VSS) capacitor c=5.4268e-17
C85 (\7\:mout VSS) capacitor c=4.55691e-17
C86 (\9\:CKbb VSS) capacitor c=1.10704e-16
C87 (\10\:CKbb VSS) capacitor c=6.19546e-17
C88 (\13\:CKbb VSS) capacitor c=1.26533e-16
C89 (\14\:CKbb VSS) capacitor c=6.38716e-17
C90 (\15\:CKbb VSS) capacitor c=7.25195e-17
C91 (\6\:n30 VSS) capacitor c=5.19798e-17
C92 (\7\:n30 VSS) capacitor c=8.58165e-17
C93 (\4\:Q VSS) capacitor c=1.22166e-16
C94 (\5\:QN VSS) capacitor c=1.65408e-16
C95 (\23\:qbint VSS) capacitor c=2.44078e-16
C96 (\26\:qbint VSS) capacitor c=2.8382e-17
C97 (\27\:qbint VSS) capacitor c=2.28651e-17
C98 (\28\:qbint VSS) capacitor c=4.73133e-17
C99 (\29\:qbint VSS) capacitor c=2.8182e-17
C100 (\17\:qint VSS) capacitor c=3.52176e-17
C101 (\18\:qint VSS) capacitor c=3.79702e-17
C102 (\21\:VDD VSS) capacitor c=1.91405e-17
Rk3 (\4\:CK CK) resistor r=0.03634 c=0
Rk28 (\1\:Q Q) resistor r=0.04985 c=0
Rk29 (Q \4\:Q) resistor r=0.2115 c=0
Rk54 (\1\:VSS \11\:VSS) resistor r=0.4548 c=0
Rk55 (\11\:VSS \12\:VSS) resistor r=0.05148 c=0
Rk56 (\12\:VSS \13\:VSS) resistor r=0.5236 c=0
Rk57 (\13\:VSS \14\:VSS) resistor r=0.1276 c=0
Rk59 (\15\:VSS VSS) resistor r=0.02211 c=0
Rk58 (\14\:VSS \15\:VSS) resistor r=0.5286 c=0
Rk65 (\11\:VSS \27\:VSS) resistor r=0.04327 c=0
Rk66 (\13\:VSS \29\:VSS) resistor r=0.1835 c=0
Rk67 (\15\:VSS \31\:VSS) resistor r=0.3326 c=0
Rk2 (D \4\:D) resistor r=0.02649 c=0
Rk34 (\1\:QN QN) resistor r=0.2166 c=0
Rk35 (QN \5\:QN) resistor r=0.04792 c=0
Rk80 (\1\:VDD \21\:VDD) resistor r=0.5359 c=0
Rk81 (\21\:VDD \23\:VDD) resistor r=0.3625 c=0
Rk82 (\21\:VDD \24\:VDD) resistor r=0.2379 c=0
Rk83 (\24\:VDD \25\:VDD) resistor r=0.2705 c=0
Rk84 (\25\:VDD \27\:VDD) resistor r=0.203 c=0
Rk85 (\25\:VDD \28\:VDD) resistor r=0.2304 c=0
Rk86 (\28\:VDD \29\:VDD) resistor r=0.2705 c=0
Rk87 (\29\:VDD \31\:VDD) resistor r=0.203 c=0
Rk88 (\29\:VDD \32\:VDD) resistor r=0.08 c=0
Rk91 (\33\:VDD VDD) resistor r=0.02963 c=0
Rk89 (\32\:VDD \33\:VDD) resistor r=0.1201 c=0
Rk90 (\33\:VDD \35\:VDD) resistor r=0.07346 c=0
Rk1 (\4\:RN RN) resistor r=0.01719 c=0
Rk7 (\2\:Db \3\:Db) resistor r=0.5579 c=0
Rk8 (\3\:Db \5\:Db) resistor r=0.2605 c=0
Rk9 (\3\:Db \6\:Db) resistor r=0.8671 c=0
Rk10 (\6\:Db \8\:Db) resistor r=0.4629 c=0
Rk11 (\6\:Db \10\:Db) resistor r=0.0619 c=0
Rk4 (\10\:CKb \11\:CKb) resistor r=0.4907 c=0
Rk5 (\11\:CKb \13\:CKb) resistor r=0.1204 c=0
Rk6 (\11\:CKb \15\:CKb) resistor r=0.642 c=0
Rk18 (\9\:CKbb \10\:CKbb) resistor r=0.1842 c=0
Rk19 (\10\:CKbb \12\:CKbb) resistor r=0.2568 c=0
Rk20 (\9\:CKbb \13\:CKbb) resistor r=0.7568 c=0
Rk21 (\13\:CKbb \14\:CKbb) resistor r=0.3027 c=0
Rk22 (\10\:CKbb \15\:CKbb) resistor r=0.3655 c=0
Rk23 (\12\:CKbb \17\:CKbb) resistor r=0.4721 c=0
Rk12 (\4\:n20 \5\:n20) resistor r=0.2794 c=0
Rk13 (\5\:n20 \7\:n20) resistor r=0.1269 c=0
Rk14 (\5\:n20 \9\:n20) resistor r=0.2555 c=0
Rk15 (\5\:mout \6\:mout) resistor r=0.1403 c=0
Rk16 (\6\:mout \7\:mout) resistor r=0.2406 c=0
Rk17 (\6\:mout \9\:mout) resistor r=0.2577 c=0
Rk24 (\6\:n30 \7\:n30) resistor r=0.258 c=0
Rk25 (\7\:n30 \9\:n30) resistor r=0.3134 c=0
Rk26 (\7\:n30 \11\:n30) resistor r=0.419 c=0
Rk38 (\23\:qbint \25\:qbint) resistor r=1.8737 c=0
Rk39 (\25\:qbint \26\:qbint) resistor r=0.433 c=0
Rk40 (\26\:qbint \27\:qbint) resistor r=0.1039 c=0
Rk41 (\27\:qbint \28\:qbint) resistor r=0.178 c=0
Rk42 (\26\:qbint \29\:qbint) resistor r=0.06882 c=0
Rk43 (\27\:qbint \31\:qbint) resistor r=0.197 c=0
Rk44 (\16\:qint \17\:qint) resistor r=0.3535 c=0
Rk45 (\17\:qint \18\:qint) resistor r=0.2067 c=0
Rk46 (\17\:qint \20\:qint) resistor r=0.1262 c=0
Rl5 (\1\:CK \2\:CK) resistor r=71.1538 c=0
Rl6 (\2\:CK \3\:CK) resistor r=101.374 c=0
Rl3 (\1\:D \2\:D) resistor r=57.6923 c=0
Rl4 (\2\:D \3\:D) resistor r=78.2967 c=0
Rl2 (\2\:RN \3\:RN) resistor r=88.2566 c=0
Rl1 (\1\:RN \2\:RN) resistor r=48.161 c=0
Rl14 (CKb \2\:CKb) resistor r=187.593 c=0
Rl15 (\2\:CKb \3\:CKb) resistor r=408.747 c=0
Rl21 (\6\:CKb \9\:CKb) resistor r=80.2255 c=0
Rl16 (\3\:CKb \4\:CKb) resistor r=168.774 c=0
Rl19 (\4\:CKb \7\:CKb) resistor r=30.4507 c=0
Rl20 (\5\:CKb \8\:CKb) resistor r=83.7744 c=0
Rl18 (\5\:CKb \6\:CKb) resistor r=14.7598 c=0
Rl17 (\4\:CKb \5\:CKb) resistor r=201.998 c=0
Rl22 (\7\:CKbb \8\:CKbb) resistor r=29.5379 c=0
Rl13 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl8 (\3\:CKbb \4\:CKbb) resistor r=58.3841 c=0
Rl7 (CKbb \2\:CKbb) resistor r=53.079 c=0
Rl11 (n20 \2\:n20) resistor r=100.692 c=0
Rl12 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl9 (mout \2\:mout) resistor r=37.6944 c=0
Rl10 (\2\:mout \3\:mout) resistor r=89.6174 c=0
Rl58 (\21\:qbint \22\:qbint) resistor r=62.6944 c=0
Rl57 (\21\:qbint \20\:qbint) resistor r=69.7702 c=0
Rl23 (\2\:qbint qbint) resistor r=6.99 c=0
Rl25 (\2\:qbint \4\:qbint) resistor r=37.3411 c=0
Rl24 (\2\:qbint \3\:qbint) resistor r=129.214 c=0
Rz20 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz21 (\29\:VSS \28\:VSS) resistor r=75 c=0
Rz22 (\31\:VSS \30\:VSS) resistor r=75 c=0
Rz28 (VDD \3\:VDD) resistor r=75 c=0
Rz24 (\1\:VDD \3\:VDD) resistor r=3.9474 c=0
Rz25 (\24\:VDD \3\:VDD) resistor r=15 c=0
Rz26 (\28\:VDD \3\:VDD) resistor r=15 c=0
Rz27 (\32\:VDD \3\:VDD) resistor r=37.5 c=0
Rz2 (Db \2\:Db) resistor r=75 c=0
Rz3 (\7\:Db \8\:Db) resistor r=75 c=0
Rz1 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz6 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz4 (\6\:n20 \7\:n20) resistor r=75 c=0
Rz5 (\8\:mout \9\:mout) resistor r=75 c=0
Rz7 (\9\:n30 \8\:n30) resistor r=75 c=0
Rz12 (\25\:qbint \24\:qbint) resistor r=75 c=0
Rz13 (\16\:qint \15\:qint) resistor r=75 c=0
Ry15 (\1\:VSS \3\:VSS) resistor r=3.2632 c=0
Ry16 (\12\:VSS \3\:VSS) resistor r=62 c=0
Ry17 (\14\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry24 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry25 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry26 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry27 (\35\:VDD \34\:VDD) resistor r=62 c=0
Ry2 (\4\:Db \5\:Db) resistor r=62 c=0
Ry3 (\9\:Db \10\:Db) resistor r=62 c=0
Ry1 (\14\:CKb \15\:CKb) resistor r=62 c=0
Ry6 (\16\:CKbb \17\:CKbb) resistor r=62 c=0
Ry4 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry5 (\4\:mout \5\:mout) resistor r=62 c=0
Ry7 (\11\:n30 \10\:n30) resistor r=62 c=0
Ry12 (\31\:qbint \30\:qbint) resistor r=31 c=0
Ry13 (\20\:qint \19\:qint) resistor r=20.6667 c=0
Rx3 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:RN \4\:RN) resistor r=45 c=0
Rx4 (\6\:CKb \10\:CKb) resistor r=45 c=0
Rx7 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx8 (\6\:CKbb \13\:CKbb) resistor r=45 c=0
Rx9 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx10 (\2\:CKbb \15\:CKbb) resistor r=45 c=0
Rx5 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx6 (\2\:mout \7\:mout) resistor r=45 c=0
Rx11 (\6\:n30 n30) resistor r=45 c=0
Rx12 (\23\:qbint \21\:qbint) resistor r=45 c=0
Rx13 (\28\:qbint qbint) resistor r=45 c=0
Rx14 (\29\:qbint \5\:qbint) resistor r=45 c=0
Rx15 (\18\:qint qint) resistor r=45 c=0
mn0 (n0 \1\:RN \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn1 (Db \3\:D n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.4e-07 sd=160n sca=16.7245 scb=0.0178071 \
        scc=0.00133148 m=(1)
mn20 (\12\:CKb \3\:CK \28\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.828e-14 ad=5.728e-14 ps=6.8e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=3.85e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn21 (\11\:CKbb \9\:CKb \28\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.827e-14 ad=2.103e-14 ps=6.8e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=1.45e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn25 (\6\:n20 \7\:CKb \7\:Db VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.132e-14 ad=2.32e-14 ps=8.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn50 (n35 \3\:qbint \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.92e-14 ad=1.087e-14 ps=7.3e-07 pd=4.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn36 (\6\:n20 \3\:CKbb n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn35 (n25 \3\:mout \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.345e-14 ad=8.7e-15 ps=1.51e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn30 (\8\:mout \3\:n20 \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.345e-14 ad=3.625e-14 ps=1.51e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn40 (\8\:n30 \5\:CKbb \8\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.625e-14 ad=3.552e-14 ps=7.9e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn51 (\8\:n30 CKb n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.087e-14 ad=3.552e-14 ps=4.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.415e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn45_1__rcx (\24\:qbint n30 \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.592e-14 ad=3.28e-14 ps=1.08e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26e-06 sb=2e-06 sd=160n sca=11.814 scb=0.0116374 \
        scc=0.000520744 m=(2)
mn55_1__rcx (\4\:Q \5\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.471e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28288e-06 sb=2e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(4)
mn57_1__rcx (\1\:QN qint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.095e-14 ad=4.745e-14 ps=1.3325e-06 pd=8.85e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.69865e-06 sb=1.165e-06 sd=160n \
        sca=10.79 scb=0.0100512 scc=0.000418069 m=(4)
mn56 (\15\:qint \20\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.76e-14 ad=3.64e-14 ps=1.04e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mp1 (\4\:Db \1\:D \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.94e-14 ad=3.44e-14 ps=1.15e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1e-07 sd=160n sca=18.5149 scb=0.0187285 \
        scc=0.000914624 m=(1)
mp20 (\14\:CKb \1\:CK \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.665e-14 ad=2.89e-14 ps=1.51e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.34419e-07 sb=3.35e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp21 (\16\:CKbb \8\:CKb \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.665e-14 ad=3.01e-14 ps=1.51e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.29419e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp25 (\8\:n20 CKbb \9\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=4.515e-14 ps=7.1e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp36 (\8\:n20 \3\:CKb n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.515e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp40 (\10\:n30 \2\:CKb \4\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.848e-14 ad=3.44e-14 ps=1.16e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.145e-06 sb=2e-06 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp35 (n26 mout \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=1.29e-14 ps=8.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp30 (\4\:mout n20 \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.085e-14 ad=7.848e-14 ps=8.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp51 (\10\:n30 \7\:CKbb n36 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.44e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35e-06 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp50 (n36 \4\:qbint \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=3.118e-14 ps=1e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=2e-06 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp45 (\30\:qbint n30 \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.213e-14 ad=4.96e-14 ps=1.08e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27395e-06 sb=2e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(2)
mp55_1__rcx (\1\:Q \5\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.433e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.27256e-06 sb=1.805e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
mp57_1__rcx (\5\:QN qint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.728e-14 ps=1.1e-06 pd=1.125e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.64051e-06 sb=9.85e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
mp56 (\19\:qint \22\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.96e-06 sb=1.4e-07 sd=160n sca=32.2573 \
        scb=0.0215683 scc=0.00336427 m=(1)
ends DFFTRX4
// End of subcircuit definition.

// Generated for: spectre (May  9 14:35:55 2012 )
// Library name: gsclib045
// Cell name: DFFTRXL
// View name: extracted

simulator lang=spectre

subckt DFFTRXL CK D Q QN RN VDD VSS
mp57 (\1\:QN \4\:qint \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.762e-14 ps=1.45e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.35e-07 sd=160n sca=48.9651 \
        scb=0.0318882 scc=0.00591085 m=(1)
C1 (D VSS) capacitor c=5.54293e-17
C2 (QN VSS) capacitor c=2.29744e-17
C3 (RN VSS) capacitor c=6.46028e-17
C4 (VDD VSS) capacitor c=2.75149e-16
C5 (CK VSS) capacitor c=5.22366e-17
C6 (Q VSS) capacitor c=5.12946e-17
C7 (qint VSS) capacitor c=1.98768e-17
C8 (qbint VSS) capacitor c=1.68678e-17
C9 (CKb VSS) capacitor c=8.12466e-17
C10 (n30 VSS) capacitor c=3.72893e-17
C11 (n35 VSS) capacitor c=5.08221e-18
C12 (mout VSS) capacitor c=8.38654e-17
C13 (CKbb VSS) capacitor c=5.09831e-17
C14 (n20 VSS) capacitor c=4.97012e-17
C15 (Db VSS) capacitor c=6.19527e-17
C16 (n0 VSS) capacitor c=7.73859e-19
C17 (n36 VSS) capacitor c=1.63392e-18
C18 (\1\:D VSS) capacitor c=2.82817e-17
C19 (\4\:RN VSS) capacitor c=4.21992e-17
C20 (\8\:CKb VSS) capacitor c=4.22499e-17
C21 (\7\:CKbb VSS) capacitor c=4.13618e-17
C22 (\7\:CKb VSS) capacitor c=7.75901e-17
C23 (\3\:n20 VSS) capacitor c=3.55012e-17
C24 (\2\:CKb VSS) capacitor c=4.31766e-17
C25 (\2\:CKbb VSS) capacitor c=4.21166e-17
C26 (\8\:qbint VSS) capacitor c=5.34326e-17
C27 (\3\:n30 VSS) capacitor c=3.02826e-17
C28 (\3\:CK VSS) capacitor c=3.05695e-17
C29 (\5\:qbint VSS) capacitor c=3.94484e-17
C30 (\7\:qbint VSS) capacitor c=3.53328e-17
C31 (\4\:qint VSS) capacitor c=3.74603e-17
C32 (\3\:D VSS) capacitor c=3.03591e-17
C33 (\1\:RN VSS) capacitor c=3.98906e-17
C34 (\4\:CKb VSS) capacitor c=2.52232e-17
C35 (\9\:CKb VSS) capacitor c=2.78098e-17
C36 (\5\:CKbb VSS) capacitor c=9.16573e-17
C37 (\3\:mout VSS) capacitor c=5.52727e-17
C38 (\3\:CKbb VSS) capacitor c=3.63347e-17
C39 (\11\:qbint VSS) capacitor c=2.77764e-17
C40 (\1\:CK VSS) capacitor c=3.97356e-17
C41 (\4\:qbint VSS) capacitor c=2.60666e-17
C42 (\3\:qint VSS) capacitor c=3.06131e-17
C43 (\2\:D VSS) capacitor c=2.90306e-17
C44 (\3\:RN VSS) capacitor c=4.14714e-17
C45 (\8\:CKbb VSS) capacitor c=4.84314e-17
C46 (\10\:CKb VSS) capacitor c=3.18364e-17
C47 (\6\:CKbb VSS) capacitor c=3.06826e-17
C48 (\2\:mout VSS) capacitor c=6.60094e-17
C49 (\4\:n20 VSS) capacitor c=5.36584e-17
C50 (\4\:CKbb VSS) capacitor c=3.50469e-17
C51 (\3\:CKb VSS) capacitor c=2.19988e-17
C52 (\10\:qbint VSS) capacitor c=2.60336e-17
C53 (\2\:n30 VSS) capacitor c=3.87385e-17
C54 (\2\:CK VSS) capacitor c=3.137e-17
C55 (\14\:VDD VSS) capacitor c=1.07657e-17
C56 (\3\:Db VSS) capacitor c=8.98118e-17
C57 (\16\:VDD VSS) capacitor c=2.13378e-17
C58 (\9\:CKbb VSS) capacitor c=5.985e-17
C59 (\8\:Db VSS) capacitor c=2.24922e-17
C60 (\9\:n20 VSS) capacitor c=3.58153e-17
C61 (\18\:VDD VSS) capacitor c=2.3999e-17
C62 (\6\:mout VSS) capacitor c=3.69771e-17
C63 (\8\:n30 VSS) capacitor c=3.97471e-17
C64 (\20\:VDD VSS) capacitor c=2.48444e-17
C65 (\16\:qbint VSS) capacitor c=4.5587e-17
C66 (\13\:CKb VSS) capacitor c=1.45667e-16
C67 (\22\:VDD VSS) capacitor c=1.20148e-17
C68 (\3\:Q VSS) capacitor c=4.96447e-17
C69 (\5\:qint VSS) capacitor c=3.26833e-17
C70 (\24\:VDD VSS) capacitor c=1.16856e-17
C71 (\1\:QN VSS) capacitor c=1.58772e-17
C72 (\1\:VDD VSS) capacitor c=1.26027e-16
C73 (\11\:CKbb VSS) capacitor c=7.20454e-17
C74 (\6\:Db VSS) capacitor c=7.50046e-17
C75 (\7\:n20 VSS) capacitor c=5.07754e-17
C76 (\8\:mout VSS) capacitor c=3.70084e-17
C77 (\4\:n30 VSS) capacitor c=7.61875e-17
C78 (\14\:qbint VSS) capacitor c=8.56766e-17
C79 (\11\:CKb VSS) capacitor c=7.53991e-17
C80 (\1\:Q VSS) capacitor c=5.20757e-17
C81 (\9\:qint VSS) capacitor c=3.12687e-17
C82 (\3\:QN VSS) capacitor c=3.52809e-17
C83 (\2\:qint VSS) capacitor c=1.25983e-17
C84 (\2\:qbint VSS) capacitor c=3.84782e-17
C85 (\3\:qbint VSS) capacitor c=3.69577e-17
C86 (\9\:qbint VSS) capacitor c=2.8997e-17
C87 (\5\:CKb VSS) capacitor c=4.1002e-17
C88 (\6\:CKb VSS) capacitor c=7.13179e-17
C89 (\7\:qint VSS) capacitor c=3.28288e-17
C90 (\8\:qint VSS) capacitor c=2.90511e-17
C91 (\4\:CK VSS) capacitor c=8.10117e-17
C92 (\12\:qbint VSS) capacitor c=6.18338e-17
C93 (\13\:qbint VSS) capacitor c=4.37747e-17
C94 (\18\:qbint VSS) capacitor c=1.11876e-16
C95 (\6\:n30 VSS) capacitor c=8.40394e-17
C96 (\7\:n30 VSS) capacitor c=5.19926e-17
C97 (\4\:mout VSS) capacitor c=3.85905e-17
C98 (\5\:mout VSS) capacitor c=5.45455e-17
C99 (\15\:CKb VSS) capacitor c=1.55832e-16
C100 (\16\:CKb VSS) capacitor c=7.70153e-17
C101 (\5\:n20 VSS) capacitor c=4.57358e-17
C102 (\6\:n20 VSS) capacitor c=5.09087e-17
C103 (\13\:CKbb VSS) capacitor c=6.6298e-17
C104 (\14\:CKbb VSS) capacitor c=9.37803e-17
C105 (\15\:CKbb VSS) capacitor c=9.49206e-17
C106 (\16\:CKbb VSS) capacitor c=6.84971e-17
C107 (\17\:CKbb VSS) capacitor c=6.2892e-17
C108 (\5\:RN VSS) capacitor c=5.80637e-17
C109 (\4\:D VSS) capacitor c=7.663e-17
C110 (\5\:Db VSS) capacitor c=7.4776e-17
C111 (\3\:VDD VSS) capacitor c=4.65417e-18
C112 (\4\:VDD VSS) capacitor c=9.44944e-18
C113 (\6\:VDD VSS) capacitor c=1.77103e-17
C114 (\8\:VDD VSS) capacitor c=6.04581e-18
C115 (\12\:VDD VSS) capacitor c=9.87957e-19
Rk32 (\4\:D D) resistor r=0.1747 c=0
Rk2 (\4\:QN QN) resistor r=0.0927 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2238 c=0
Rk31 (RN \5\:RN) resistor r=0.187 c=0
Rk37 (\2\:VDD \3\:VDD) resistor r=0.03234 c=0
Rk38 (\3\:VDD \4\:VDD) resistor r=0.1723 c=0
Rk39 (\4\:VDD \5\:VDD) resistor r=0.195 c=0
Rk40 (\5\:VDD \6\:VDD) resistor r=0.3677 c=0
Rk41 (\6\:VDD \7\:VDD) resistor r=0.2325 c=0
Rk42 (\7\:VDD \8\:VDD) resistor r=0.2876 c=0
Rk43 (\8\:VDD \9\:VDD) resistor r=0.1625 c=0
Rk44 (\9\:VDD \10\:VDD) resistor r=0.2505 c=0
Rk45 (\10\:VDD \11\:VDD) resistor r=0.1505 c=0
Rk46 (\11\:VDD \12\:VDD) resistor r=0.1174 c=0
Rk48 (\13\:VDD VDD) resistor r=0.09985 c=0
Rk47 (\12\:VDD \13\:VDD) resistor r=0.1324 c=0
Rk49 (\3\:VDD \15\:VDD) resistor r=0.222 c=0
Rk50 (\4\:VDD \17\:VDD) resistor r=0.222 c=0
Rk51 (\6\:VDD \19\:VDD) resistor r=0.1017 c=0
Rk52 (\8\:VDD \21\:VDD) resistor r=0.1017 c=0
Rk53 (\10\:VDD \23\:VDD) resistor r=0.1191 c=0
Rk54 (\12\:VDD \25\:VDD) resistor r=0.222 c=0
Rk8 (\4\:CK CK) resistor r=0.2418 c=0
Rk6 (\2\:Q Q) resistor r=0.16 c=0
Rk7 (Q \4\:Q) resistor r=0.152 c=0
Rk55 (\2\:VSS \3\:VSS) resistor r=0.1399 c=0
Rk56 (\3\:VSS \4\:VSS) resistor r=0.5103 c=0
Rk57 (\4\:VSS \5\:VSS) resistor r=0.06142 c=0
Rk58 (\5\:VSS \6\:VSS) resistor r=0.4966 c=0
Rk59 (\6\:VSS \7\:VSS) resistor r=0.19 c=0
Rk60 (\7\:VSS \8\:VSS) resistor r=0.245 c=0
Rk61 (\8\:VSS \9\:VSS) resistor r=0.1049 c=0
Rk62 (\9\:VSS \10\:VSS) resistor r=0.1675 c=0
Rk64 (\11\:VSS VSS) resistor r=0.09985 c=0
Rk63 (\10\:VSS \11\:VSS) resistor r=0.1324 c=0
Rk65 (\3\:VSS \13\:VSS) resistor r=0.07311 c=0
Rk66 (\5\:VSS \15\:VSS) resistor r=0.04318 c=0
Rk67 (\6\:VSS \17\:VSS) resistor r=0.3694 c=0
Rk68 (\8\:VSS \19\:VSS) resistor r=0.07311 c=0
Rk69 (\10\:VSS \21\:VSS) resistor r=0.07311 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.1173 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1188 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.1053 c=0
Rk9 (\12\:qbint \13\:qbint) resistor r=0.2452 c=0
Rk10 (\13\:qbint \15\:qbint) resistor r=0.2569 c=0
Rk11 (\13\:qbint \17\:qbint) resistor r=0.287 c=0
Rk12 (\15\:qbint \18\:qbint) resistor r=0.8078 c=0
Rk19 (\12\:CKb \14\:CKb) resistor r=0.476 c=0
Rk20 (\14\:CKb \15\:CKb) resistor r=0.952 c=0
Rk21 (\15\:CKb \16\:CKb) resistor r=0.5262 c=0
Rk13 (\5\:n30 \6\:n30) resistor r=0.4647 c=0
Rk14 (\6\:n30 \7\:n30) resistor r=0.2175 c=0
Rk15 (\6\:n30 \9\:n30) resistor r=0.2739 c=0
Rk16 (\4\:mout \5\:mout) resistor r=0.1639 c=0
Rk17 (\5\:mout \7\:mout) resistor r=0.2791 c=0
Rk18 (\5\:mout \9\:mout) resistor r=0.08273 c=0
Rk25 (\10\:CKbb \12\:CKbb) resistor r=0.2997 c=0
Rk26 (\12\:CKbb \13\:CKbb) resistor r=0.3913 c=0
Rk27 (\13\:CKbb \14\:CKbb) resistor r=0.1843 c=0
Rk28 (\14\:CKbb \15\:CKbb) resistor r=0.682 c=0
Rk29 (\13\:CKbb \16\:CKbb) resistor r=0.3477 c=0
Rk30 (\15\:CKbb \17\:CKbb) resistor r=0.2586 c=0
Rk22 (\5\:n20 \6\:n20) resistor r=0.2083 c=0
Rk23 (\6\:n20 \8\:n20) resistor r=0.237 c=0
Rk24 (\6\:n20 \10\:n20) resistor r=0.176 c=0
Rk33 (\2\:Db \4\:Db) resistor r=0.4546 c=0
Rk34 (\4\:Db \5\:Db) resistor r=0.4775 c=0
Rk35 (\5\:Db \7\:Db) resistor r=0.3903 c=0
Rk36 (\5\:Db \9\:Db) resistor r=0.08888 c=0
Rl37 (\1\:D \2\:D) resistor r=33.7834 c=0
Rl38 (\2\:D \3\:D) resistor r=24.7951 c=0
Rl36 (\2\:RN \4\:RN) resistor r=43.2462 c=0
Rl34 (\1\:RN \2\:RN) resistor r=47.0924 c=0
Rl35 (\2\:RN \3\:RN) resistor r=2.9709 c=0
Rl11 (\2\:CK \3\:CK) resistor r=26.3736 c=0
Rl10 (\1\:CK \2\:CK) resistor r=100 c=0
Rl1 (qint \2\:qint) resistor r=0.5213 c=0
Rl3 (\2\:qint \4\:qint) resistor r=49.7141 c=0
Rl2 (\2\:qint \3\:qint) resistor r=34.3295 c=0
Rl4 (qbint \2\:qbint) resistor r=38.9161 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=104.301 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=3.9233 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=146.04 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=111.253 c=0
Rl16 (\9\:qbint \11\:qbint) resistor r=47.791 c=0
Rl15 (\9\:qbint \10\:qbint) resistor r=2.7666 c=0
Rl18 (CKb \2\:CKb) resistor r=199.566 c=0
Rl33 (\7\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl19 (\2\:CKb \3\:CKb) resistor r=24.2328 c=0
Rl31 (\5\:CKb \8\:CKb) resistor r=51.3446 c=0
Rl28 (\4\:CKb \5\:CKb) resistor r=47.0285 c=0
Rl30 (\6\:CKb \7\:CKb) resistor r=172.62 c=0
Rl32 (\6\:CKb \9\:CKb) resistor r=30.4507 c=0
Rl29 (\5\:CKb \6\:CKb) resistor r=201.946 c=0
Rl12 (n30 \2\:n30) resistor r=113.462 c=0
Rl13 (\2\:n30 \3\:n30) resistor r=29.9451 c=0
Rl24 (mout \2\:mout) resistor r=111.139 c=0
Rl25 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl17 (CKbb \2\:CKbb) resistor r=64.5404 c=0
Rl27 (\7\:CKbb \8\:CKbb) resistor r=64.6174 c=0
Rl26 (\5\:CKbb \6\:CKbb) resistor r=46.8456 c=0
Rl20 (\3\:CKbb \4\:CKbb) resistor r=37.2302 c=0
Rl21 (n20 \2\:n20) resistor r=85.2786 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=67.6161 c=0
Rl23 (\2\:n20 \4\:n20) resistor r=4.3511 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz12 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz13 (\1\:VDD \5\:VDD) resistor r=10.7143 c=0
Rz14 (\1\:VDD \7\:VDD) resistor r=15 c=0
Rz15 (\1\:VDD \9\:VDD) resistor r=18.75 c=0
Rz16 (\1\:VDD \10\:VDD) resistor r=75 c=0
Rz17 (\1\:VDD \11\:VDD) resistor r=37.5 c=0
Rz18 (\1\:VDD \13\:VDD) resistor r=25 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz19 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz20 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz21 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz22 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz23 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz4 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz7 (\11\:CKb \12\:CKb) resistor r=75 c=0
Rz5 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz6 (\8\:mout \9\:mout) resistor r=75 c=0
Rz9 (\11\:CKbb \12\:CKbb) resistor r=75 c=0
Rz8 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\6\:Db \7\:Db) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry12 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry13 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry14 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry15 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry16 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry17 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry3 (\3\:Q \4\:Q) resistor r=62 c=0
Ry18 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry19 (\1\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry20 (\1\:VSS \7\:VSS) resistor r=15.5 c=0
Ry21 (\1\:VSS \9\:VSS) resistor r=20.6667 c=0
Ry22 (\1\:VSS \11\:VSS) resistor r=20.6667 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry4 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry7 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry5 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry6 (\6\:mout \7\:mout) resistor r=62 c=0
Ry9 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry8 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry10 (\3\:Db \4\:Db) resistor r=62 c=0
Ry11 (\8\:Db \9\:Db) resistor r=62 c=0
Rx15 (\2\:D \4\:D) resistor r=45 c=0
Rx14 (\3\:RN \5\:RN) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx3 (\10\:qbint \12\:qbint) resistor r=45 c=0
Rx4 (\6\:qbint \18\:qbint) resistor r=45 c=0
Rx7 (\3\:CKb \15\:CKb) resistor r=45 c=0
Rx8 (\10\:CKb \16\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx10 (\6\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx12 (\8\:CKbb \16\:CKbb) resistor r=45 c=0
Rx13 (CKbb \17\:CKbb) resistor r=45 c=0
Rx9 (\4\:n20 \5\:n20) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.537e-14 ps=1.6e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:qint \4\:qbint \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\1\:Q qbint \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.132e-14 ad=2.03e-14 ps=1.73e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.2e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\11\:CKb \1\:CK \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.132e-14 ad=2.32e-14 ps=1.73e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=1.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn45 (\14\:qbint n30 \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.825e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn50 (n35 \11\:qbint \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=3.19e-14 ps=6.2e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.615e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn40 (\4\:n30 \3\:CKbb \8\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.06e-14 ad=2.755e-14 ps=8.5e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=1.115e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn36 (\7\:n20 \5\:CKbb n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=4.9e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn51 (\4\:n30 CKb n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.755e-14 ps=7.3e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=1.35e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn30 (\8\:mout n20 \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.165e-14 ad=4.06e-14 ps=1.59e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=7.9e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn35 (n25 \3\:mout \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.165e-14 ad=8.7e-15 ps=1.59e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=5.95e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn25 (\7\:n20 \9\:CKb \6\:Db VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.132e-14 ad=2.32e-14 ps=8.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.68e-06 sb=2.85e-07 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn21 (\11\:CKbb \4\:CKb \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn0 (n0 \1\:RN \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=1.232e-14 ps=1.6e-06 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=3.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (Db \3\:D n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=1.233e-14 \
        ad=3.263e-14 ps=4.6e-07 pd=7.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.65e-07 sb=2.25e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mp56 (\5\:qint \7\:qbint \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.515e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=46.9517 scb=0.029008 \
        scc=0.00588492 m=(1)
mp55 (\3\:Q \5\:qbint \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=3.117e-14 ps=1.6e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=3.35e-07 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp20 (\13\:CKb \3\:CK \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=3.01e-14 ps=1.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.4e-07 sb=1.4e-07 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp45 (\16\:qbint \3\:n30 \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.63e-14 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.755e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp50 (n36 \8\:qbint \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=3.118e-14 ps=1.52e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.49e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp51 (\8\:n30 \2\:CKbb n36 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.44e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=1.3e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp40 (\8\:n30 \2\:CKb \6\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.203e-14 ad=3.44e-14 ps=1.1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=1.095e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp36 (\9\:n20 \7\:CKb n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-06 sb=3.45e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp30 (\6\:mout \3\:n20 \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.63e-14 ad=7.203e-14 ps=1.52e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.18e-06 sb=7.15e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp35 (n26 mout \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=1.29e-14 ps=1.52e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=4.5e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp25 (\9\:n20 \7\:CKbb \8\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.755e-06 sb=1.4e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp21 (\9\:CKbb \8\:CKb \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.838e-14 ad=3.01e-14 ps=1.48e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.15e-07 sd=160n sca=46.8621 \
        scb=0.0289219 scc=0.00588474 m=(1)
mp0 (\3\:Db \4\:RN \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.838e-14 ad=3.44e-14 ps=1.48e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=3.05e-07 sd=160n sca=48.9651 \
        scb=0.0318882 scc=0.00591085 m=(1)
mp1 (\3\:Db \1\:D \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.44e-14 ad=3.44e-14 ps=1.35e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=1e-07 sd=160n sca=57.0065 scb=0.0445545 \
        scc=0.00681945 m=(1)
ends DFFTRXL
// End of subcircuit definition.

// Generated for: spectre (May  9 14:36:33 2012 )
// Library name: gsclib045
// Cell name: DFFX1
// View name: extracted

simulator lang=spectre

subckt DFFX1 CK D Q QN VDD VSS
mp57 (\1\:QN \4\:qint \18\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.142e-14 ad=5.46e-14 ps=1.52e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.49744e-07 sd=160n sca=35.2977 \
        scb=0.0266107 scc=0.00346222 m=(1)
C1 (D VSS) capacitor c=8.24941e-17
C2 (QN VSS) capacitor c=2.1175e-17
C3 (CK VSS) capacitor c=4.06523e-17
C4 (VDD VSS) capacitor c=2.38722e-16
C5 (Q VSS) capacitor c=4.06044e-17
C6 (qint VSS) capacitor c=2.13796e-17
C7 (qbint VSS) capacitor c=4.40291e-17
C8 (CKb VSS) capacitor c=2.26755e-17
C9 (n30 VSS) capacitor c=3.92857e-17
C10 (n35 VSS) capacitor c=2.55819e-18
C11 (mout VSS) capacitor c=5.05832e-17
C12 (CKbb VSS) capacitor c=5.1113e-17
C13 (n20 VSS) capacitor c=3.18318e-17
C14 (n25 VSS) capacitor c=1.73661e-18
C15 (n21 VSS) capacitor c=7.01524e-19
C16 (n36 VSS) capacitor c=1.1262e-18
C17 (n26 VSS) capacitor c=8.70796e-19
C18 (n22 VSS) capacitor c=7.32139e-19
C19 (\10\:CKb VSS) capacitor c=4.5175e-17
C20 (\1\:D VSS) capacitor c=3.08367e-17
C21 (\5\:CKbb VSS) capacitor c=6.97775e-17
C22 (\5\:CKb VSS) capacitor c=5.14125e-17
C23 (\4\:mout VSS) capacitor c=7.88187e-17
C24 (\4\:n20 VSS) capacitor c=3.56696e-17
C25 (\2\:CKbb VSS) capacitor c=4.83832e-17
C26 (\8\:qbint VSS) capacitor c=6.75011e-17
C27 (\3\:n30 VSS) capacitor c=3.88958e-17
C28 (\1\:CK VSS) capacitor c=3.06388e-17
C29 (\7\:qbint VSS) capacitor c=3.29312e-17
C30 (\4\:qint VSS) capacitor c=4.44659e-17
C31 (\8\:CKb VSS) capacitor c=2.88626e-17
C32 (\3\:D VSS) capacitor c=8.06785e-17
C33 (\6\:CKb VSS) capacitor c=7.12228e-17
C34 (\6\:CKbb VSS) capacitor c=6.34843e-17
C35 (\3\:n20 VSS) capacitor c=4.9931e-17
C36 (\3\:CKbb VSS) capacitor c=3.91409e-17
C37 (\3\:CKb VSS) capacitor c=5.85094e-17
C38 (\11\:qbint VSS) capacitor c=3.45726e-17
C39 (\3\:CK VSS) capacitor c=3.40768e-17
C40 (\5\:qbint VSS) capacitor c=3.08463e-17
C41 (\4\:qbint VSS) capacitor c=2.70517e-17
C42 (\3\:qint VSS) capacitor c=3.60773e-17
C43 (\9\:CKb VSS) capacitor c=3.98987e-17
C44 (\2\:D VSS) capacitor c=6.04845e-17
C45 (\7\:CKb VSS) capacitor c=5.27247e-17
C46 (\7\:CKbb VSS) capacitor c=2.97691e-17
C47 (\4\:CKb VSS) capacitor c=4.96719e-17
C48 (\3\:mout VSS) capacitor c=3.246e-17
C49 (\4\:CKbb VSS) capacitor c=3.89544e-17
C50 (\2\:CKb VSS) capacitor c=6.8252e-17
C51 (\10\:qbint VSS) capacitor c=2.65148e-17
C52 (\2\:n30 VSS) capacitor c=4.34274e-17
C53 (\2\:CK VSS) capacitor c=2.81664e-17
C54 (\13\:CKbb VSS) capacitor c=4.4655e-17
C55 (\10\:VDD VSS) capacitor c=3.62176e-17
C56 (\9\:n20 VSS) capacitor c=6.37846e-17
C57 (\12\:VDD VSS) capacitor c=1.41418e-17
C58 (\9\:mout VSS) capacitor c=6.49604e-17
C59 (\8\:n30 VSS) capacitor c=6.1282e-17
C60 (\14\:VDD VSS) capacitor c=1.49905e-17
C61 (\16\:qbint VSS) capacitor c=6.60517e-17
C62 (\15\:CKb VSS) capacitor c=1.46043e-16
C63 (\16\:VDD VSS) capacitor c=1.23225e-17
C64 (\1\:Q VSS) capacitor c=6.97008e-17
C65 (\5\:qint VSS) capacitor c=2.38028e-17
C66 (\18\:VDD VSS) capacitor c=1.97078e-17
C67 (\1\:QN VSS) capacitor c=3.58642e-17
C68 (\1\:VDD VSS) capacitor c=4.28697e-17
C69 (\8\:CKbb VSS) capacitor c=1.28848e-16
C70 (\5\:n20 VSS) capacitor c=8.66196e-17
C71 (\7\:mout VSS) capacitor c=4.4851e-17
C72 (\4\:n30 VSS) capacitor c=5.74147e-17
C73 (\13\:qbint VSS) capacitor c=7.42814e-17
C74 (\17\:CKb VSS) capacitor c=8.42124e-17
C75 (\3\:Q VSS) capacitor c=2.5077e-17
C76 (\9\:qint VSS) capacitor c=2.21311e-17
C77 (\3\:QN VSS) capacitor c=2.63086e-17
C78 (\2\:qint VSS) capacitor c=7.12383e-18
C79 (\2\:qbint VSS) capacitor c=4.00224e-17
C80 (\3\:qbint VSS) capacitor c=3.24519e-17
C81 (\9\:qbint VSS) capacitor c=3.08753e-17
C82 (\2\:n20 VSS) capacitor c=3.29945e-17
C83 (\2\:mout VSS) capacitor c=4.07293e-17
C84 (\7\:qint VSS) capacitor c=2.27044e-17
C85 (\8\:qint VSS) capacitor c=2.03518e-17
C86 (\4\:CK VSS) capacitor c=7.34637e-17
C87 (\12\:qbint VSS) capacitor c=1.32089e-16
C88 (\15\:qbint VSS) capacitor c=6.09553e-17
C89 (\18\:qbint VSS) capacitor c=5.78666e-17
C90 (\6\:n30 VSS) capacitor c=7.16957e-17
C91 (\7\:n30 VSS) capacitor c=4.95508e-17
C92 (\5\:mout VSS) capacitor c=3.56788e-17
C93 (\6\:mout VSS) capacitor c=5.23758e-17
C94 (\7\:n20 VSS) capacitor c=6.26735e-17
C95 (\8\:n20 VSS) capacitor c=4.48666e-17
C96 (\4\:D VSS) capacitor c=2.3406e-17
C97 (\11\:CKb VSS) capacitor c=6.47881e-17
C98 (\12\:CKb VSS) capacitor c=7.29627e-17
C99 (\13\:CKb VSS) capacitor c=1.02329e-16
C100 (\14\:CKb VSS) capacitor c=1.7401e-16
C101 (\19\:CKb VSS) capacitor c=4.04974e-17
C102 (\20\:CKb VSS) capacitor c=5.03199e-17
C103 (\10\:CKbb VSS) capacitor c=1.50573e-16
C104 (\11\:CKbb VSS) capacitor c=1.03238e-16
C105 (\12\:CKbb VSS) capacitor c=5.98042e-17
C106 (\15\:CKbb VSS) capacitor c=2.407e-17
C107 (\3\:VDD VSS) capacitor c=1.93791e-17
C108 (\4\:VDD VSS) capacitor c=2.624e-17
C109 (\6\:VDD VSS) capacitor c=2.45032e-17
C110 (\7\:VDD VSS) capacitor c=2.1041e-17
C111 (\9\:VDD VSS) capacitor c=5.07212e-18
Rk22 (\4\:D D) resistor r=0.03661 c=0
Rk2 (\4\:QN QN) resistor r=0.07346 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3051 c=0
Rk8 (CK \4\:CK) resistor r=0.1611 c=0
Rk35 (\2\:VDD \3\:VDD) resistor r=0.1026 c=0
Rk36 (\3\:VDD \4\:VDD) resistor r=0.4322 c=0
Rk37 (\4\:VDD \5\:VDD) resistor r=0.2144 c=0
Rk38 (\5\:VDD \6\:VDD) resistor r=0.2745 c=0
Rk39 (\6\:VDD \7\:VDD) resistor r=0.352 c=0
Rk40 (\7\:VDD \8\:VDD) resistor r=0.273 c=0
Rk42 (\9\:VDD VDD) resistor r=0.195 c=0
Rk41 (\8\:VDD \9\:VDD) resistor r=0.05494 c=0
Rk43 (\3\:VDD \11\:VDD) resistor r=0.2894 c=0
Rk44 (\4\:VDD \13\:VDD) resistor r=0.04327 c=0
Rk45 (\6\:VDD \15\:VDD) resistor r=0.04327 c=0
Rk46 (\7\:VDD \17\:VDD) resistor r=0.07346 c=0
Rk47 (\9\:VDD \19\:VDD) resistor r=0.223 c=0
Rk6 (\2\:Q Q) resistor r=0.3648 c=0
Rk7 (Q \4\:Q) resistor r=0.04326 c=0
Rk48 (\2\:VSS \4\:VSS) resistor r=0.2968 c=0
Rk49 (\4\:VSS \5\:VSS) resistor r=0.3513 c=0
Rk50 (\5\:VSS \6\:VSS) resistor r=0.5136 c=0
Rk51 (\6\:VSS \7\:VSS) resistor r=0.1376 c=0
Rk52 (\7\:VSS \8\:VSS) resistor r=0.2529 c=0
Rk53 (\8\:VSS \9\:VSS) resistor r=0.3029 c=0
Rk55 (\10\:VSS VSS) resistor r=0.04987 c=0
Rk54 (\9\:VSS \10\:VSS) resistor r=0.1452 c=0
Rk56 (\5\:VSS \12\:VSS) resistor r=0.1482 c=0
Rk57 (\6\:VSS \14\:VSS) resistor r=0.3552 c=0
Rk58 (\8\:VSS \16\:VSS) resistor r=0.292 c=0
Rk59 (\9\:VSS \18\:VSS) resistor r=0.07346 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.1175 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1191 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.1055 c=0
Rk9 (\12\:qbint \14\:qbint) resistor r=0.7584 c=0
Rk10 (\14\:qbint \15\:qbint) resistor r=0.2002 c=0
Rk11 (\15\:qbint \17\:qbint) resistor r=0.3184 c=0
Rk12 (\15\:qbint \18\:qbint) resistor r=0.2298 c=0
Rk23 (\11\:CKb \12\:CKb) resistor r=0.2903 c=0
Rk24 (\12\:CKb \13\:CKb) resistor r=0.1037 c=0
Rk25 (\13\:CKb \14\:CKb) resistor r=0.9093 c=0
Rk26 (\14\:CKb \16\:CKb) resistor r=0.8361 c=0
Rk27 (\16\:CKb \18\:CKb) resistor r=0.3728 c=0
Rk28 (\13\:CKb \19\:CKb) resistor r=0.09725 c=0
Rk29 (\14\:CKb \20\:CKb) resistor r=0.2089 c=0
Rk13 (\5\:n30 \6\:n30) resistor r=0.3928 c=0
Rk14 (\6\:n30 \7\:n30) resistor r=0.2191 c=0
Rk15 (\6\:n30 \9\:n30) resistor r=0.2438 c=0
Rk16 (\5\:mout \6\:mout) resistor r=0.1078 c=0
Rk17 (\6\:mout \8\:mout) resistor r=0.1663 c=0
Rk18 (\6\:mout \10\:mout) resistor r=0.3304 c=0
Rk30 (\9\:CKbb \10\:CKbb) resistor r=0.6479 c=0
Rk31 (\10\:CKbb \11\:CKbb) resistor r=0.817 c=0
Rk32 (\11\:CKbb \12\:CKbb) resistor r=0.2641 c=0
Rk33 (\9\:CKbb \14\:CKbb) resistor r=0.4353 c=0
Rk34 (\11\:CKbb \15\:CKbb) resistor r=0.03523 c=0
Rk19 (\6\:n20 \7\:n20) resistor r=0.4354 c=0
Rk20 (\7\:n20 \8\:n20) resistor r=0.1231 c=0
Rk21 (\7\:n20 \10\:n20) resistor r=0.2779 c=0
Rl31 (\1\:D \2\:D) resistor r=42.2849 c=0
Rl32 (\2\:D \3\:D) resistor r=126.284 c=0
Rl10 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl11 (\2\:CK \3\:CK) resistor r=56.461 c=0
Rl1 (qint \2\:qint) resistor r=5.915 c=0
Rl3 (\2\:qint \4\:qint) resistor r=49.7141 c=0
Rl2 (\2\:qint \3\:qint) resistor r=34.3295 c=0
Rl4 (qbint \2\:qbint) resistor r=74.7185 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=40.1031 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=6.4781 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=153.345 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=120.868 c=0
Rl16 (\9\:qbint \11\:qbint) resistor r=47.791 c=0
Rl15 (\9\:qbint \10\:qbint) resistor r=2.7666 c=0
Rl34 (\9\:CKb \10\:CKb) resistor r=110.713 c=0
Rl33 (\8\:CKb \9\:CKb) resistor r=33.7903 c=0
Rl30 (\6\:CKb \7\:CKb) resistor r=74.2328 c=0
Rl27 (\4\:CKb \5\:CKb) resistor r=52.0674 c=0
Rl18 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl19 (\2\:CKb \3\:CKb) resistor r=193.029 c=0
Rl12 (n30 \2\:n30) resistor r=101.923 c=0
Rl13 (\2\:n30 \3\:n30) resistor r=50.7948 c=0
Rl24 (mout \2\:mout) resistor r=73.3853 c=0
Rl26 (\2\:mout \4\:mout) resistor r=114.125 c=0
Rl25 (\2\:mout \3\:mout) resistor r=15.3298 c=0
Rl17 (CKbb \2\:CKbb) resistor r=61.5157 c=0
Rl28 (\5\:CKbb \6\:CKbb) resistor r=197.643 c=0
Rl29 (\6\:CKbb \7\:CKbb) resistor r=26.1559 c=0
Rl20 (\3\:CKbb \4\:CKbb) resistor r=41.0764 c=0
Rl21 (n20 \2\:n20) resistor r=11.5001 c=0
Rl23 (\2\:n20 \4\:n20) resistor r=51.6372 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=117.022 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz10 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz11 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz12 (\1\:VDD \8\:VDD) resistor r=12.5 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz13 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz14 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz15 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz16 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz17 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz8 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz5 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz6 (\7\:mout \8\:mout) resistor r=75 c=0
Rz9 (\8\:CKbb \9\:CKbb) resistor r=75 c=0
Rz7 (\5\:n20 \6\:n20) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry10 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry11 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry12 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry13 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry14 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry3 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry15 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry16 (\3\:VSS \5\:VSS) resistor r=62 c=0
Ry17 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry18 (\3\:VSS \10\:VSS) resistor r=31 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry4 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry8 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry5 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry6 (\9\:mout \10\:mout) resistor r=62 c=0
Ry9 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry7 (\9\:n20 \10\:n20) resistor r=62 c=0
Rx8 (\2\:D \4\:D) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx3 (\6\:qbint \12\:qbint) resistor r=45 c=0
Rx4 (\10\:qbint \18\:qbint) resistor r=45 c=0
Rx9 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx10 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx11 (\4\:CKb \19\:CKb) resistor r=45 c=0
Rx12 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx6 (\3\:mout \5\:mout) resistor r=45 c=0
Rx13 (\7\:CKbb \10\:CKbb) resistor r=45 c=0
Rx14 (CKbb \12\:CKbb) resistor r=45 c=0
Rx15 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx7 (n20 \8\:n20) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.273e-14 ad=3.64e-14 ps=1.67e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\9\:qint \4\:qbint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\3\:Q \5\:qbint \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=3.64e-14 ps=9.8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.18462e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (\17\:CKb \3\:CK \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=2.682e-14 ps=9.8e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=1.85e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\13\:qbint n30 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.4982 scb=0.0194884 \
        scc=0.00168796 m=(1)
mn50 (n35 \11\:qbint \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=1.667e-14 ps=6.2e-07 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.965e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn36 (\5\:n20 \6\:CKbb n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.595e-14 ad=2.32e-14 ps=5.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-06 sb=7.15e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn51 (\4\:n30 \3\:CKb n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.667e-14 ad=4.132e-14 ps=5.2e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.805e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn40 (\4\:n30 \3\:CKbb \7\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.61e-14 ad=4.132e-14 ps=6.5e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.475e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn30 (\7\:mout \3\:n20 \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=9.718e-14 ad=2.61e-14 ps=1.77e-06 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=1.25e-06 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn35 (n25 mout \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.718e-14 ad=1.595e-14 ps=1.77e-06 pd=5.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=8.7e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn26 (\5\:n20 \6\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.805e-06 sb=5.1e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn25 (n21 \3\:D \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.81e-14 ad=8.7e-15 ps=1e-06 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.91e-06 sb=4.05e-07 sd=160n sca=18.4982 scb=0.0194884 \
        scc=0.00168796 m=(1)
mn21 (\8\:CKbb \8\:CKb \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.81e-14 ad=2.03e-14 ps=1e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=18.4982 scb=0.0194884 \
        scc=0.00168796 m=(1)
mp56 (\5\:qint \7\:qbint \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.142e-14 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=47.2218 \
        scb=0.0292973 scc=0.00588575 m=(1)
mp55 (\1\:Q qbint \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.555e-14 ad=5.46e-14 ps=1.92e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.87436e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp20 (\15\:CKb \1\:CK \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.555e-14 ad=3.977e-14 ps=1.92e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=1.85e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp45 (\16\:qbint \3\:n30 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.63e-14 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp50 (n36 \8\:qbint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=1.827e-14 ps=1.52e-06 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-06 sd=160n sca=12.1244 scb=0.0107968 \
        scc=0.000332109 m=(1)
mp51 (\8\:n30 \2\:CKbb n36 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.827e-14 ad=4.515e-14 ps=6e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=1.935e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp40 (\8\:n30 CKb \9\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.127e-14 ad=4.515e-14 ps=1e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=1.68e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp30 (\9\:mout \4\:n20 \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.63e-14 ad=6.127e-14 ps=1.52e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=1.35e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp36 (\9\:n20 \5\:CKb n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.397e-14 ad=4.622e-14 ps=5.6e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.495e-06 sb=9.75e-07 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp35 (n26 \4\:mout \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.63e-14 ad=1.397e-14 ps=1.52e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=1.085e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp26 (\9\:n20 \5\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.622e-14 ad=4.622e-14 ps=8.6e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.755e-06 sb=7.15e-07 sd=160n sca=12.3306 \
        scb=0.010847 scc=0.000332116 m=(1)
mp25 (n22 \1\:D \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.622e-14 ps=7.5e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.55e-07 sd=160n sca=13.4144 scb=0.0116069 \
        scc=0.000333202 m=(1)
mp21 (\13\:CKbb \10\:CKb \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=5.375e-14 ps=7.5e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.5e-07 sd=160n sca=15.8535 scb=0.0153154 \
        scc=0.000377744 m=(1)
ends DFFX1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:37:10 2012 )
// Library name: gsclib045
// Cell name: DFFX2
// View name: extracted

simulator lang=spectre

subckt DFFX2 CK D Q QN VDD VSS
mp21 (\13\:CKbb CKb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=27.3372 scb=0.0320686 \
        scc=0.00199675 m=(1)
C1 (CK VSS) capacitor c=4.5491e-17
C2 (Q VSS) capacitor c=3.71768e-17
C3 (D VSS) capacitor c=4.67865e-17
C4 (QN VSS) capacitor c=3.35474e-17
C5 (VDD VSS) capacitor c=2.49387e-16
C6 (CKb VSS) capacitor c=4.77541e-17
C7 (CKbb VSS) capacitor c=6.81132e-17
C8 (n20 VSS) capacitor c=4.42892e-17
C9 (mout VSS) capacitor c=7.33155e-17
C10 (n30 VSS) capacitor c=5.40307e-17
C11 (qbint VSS) capacitor c=2.64656e-17
C12 (qint VSS) capacitor c=1.59242e-16
C13 (n26 VSS) capacitor c=3.60107e-19
C14 (n36 VSS) capacitor c=1.11793e-18
C15 (\12\:qbint VSS) capacitor c=5.78437e-17
C16 (\5\:qbint VSS) capacitor c=4.44902e-16
C17 (\1\:CK VSS) capacitor c=2.22717e-17
C18 (\4\:qbint VSS) capacitor c=5.88058e-17
C19 (\7\:CKbb VSS) capacitor c=5.64563e-17
C20 (\7\:CKb VSS) capacitor c=4.69764e-17
C21 (\3\:mout VSS) capacitor c=4.77953e-17
C22 (\4\:CKb VSS) capacitor c=6.55744e-17
C23 (\1\:D VSS) capacitor c=5.41182e-17
C24 (\13\:qbint VSS) capacitor c=2.4472e-17
C25 (\3\:CK VSS) capacitor c=2.99994e-17
C26 (\3\:n30 VSS) capacitor c=3.07817e-17
C27 (\3\:qbint VSS) capacitor c=4.02734e-17
C28 (\6\:CKb VSS) capacitor c=7.45584e-17
C29 (\5\:CKbb VSS) capacitor c=3.39661e-17
C30 (\4\:n20 VSS) capacitor c=3.31274e-17
C31 (\3\:CKbb VSS) capacitor c=6.02129e-17
C32 (\3\:CKb VSS) capacitor c=1.12247e-16
C33 (\3\:D VSS) capacitor c=7.13314e-17
C34 (\2\:CKb VSS) capacitor c=5.82597e-17
C35 (\14\:qbint VSS) capacitor c=1.93543e-17
C36 (\2\:CK VSS) capacitor c=2.33635e-17
C37 (\2\:n30 VSS) capacitor c=3.13348e-17
C38 (\8\:CKbb VSS) capacitor c=5.8313e-17
C39 (\8\:CKb VSS) capacitor c=2.04242e-17
C40 (\6\:CKbb VSS) capacitor c=3.74907e-17
C41 (\3\:n20 VSS) capacitor c=2.67094e-17
C42 (\2\:mout VSS) capacitor c=4.87743e-17
C43 (\4\:CKbb VSS) capacitor c=2.73345e-17
C44 (\5\:CKb VSS) capacitor c=2.95308e-17
C45 (\2\:CKbb VSS) capacitor c=5.6658e-17
C46 (\2\:D VSS) capacitor c=5.32101e-17
C47 (\7\:qint VSS) capacitor c=1.53459e-17
C48 (\1\:VDD VSS) capacitor c=2.08548e-16
C49 (\1\:QN VSS) capacitor c=7.03903e-17
C50 (\3\:Q VSS) capacitor c=9.86759e-17
C51 (\9\:CKb VSS) capacitor c=1.29205e-16
C52 (\24\:qbint VSS) capacitor c=2.5778e-17
C53 (\14\:VDD VSS) capacitor c=2.45465e-17
C54 (\4\:n30 VSS) capacitor c=5.75264e-17
C55 (\8\:mout VSS) capacitor c=2.57193e-17
C56 (\16\:VDD VSS) capacitor c=2.48029e-17
C57 (\7\:n20 VSS) capacitor c=5.05998e-17
C58 (\19\:VDD VSS) capacitor c=2.75269e-17
C59 (\13\:CKbb VSS) capacitor c=3.13775e-17
C60 (\3\:VDD VSS) capacitor c=9.18503e-17
C61 (\11\:qint VSS) capacitor c=3.31125e-17
C62 (\4\:QN VSS) capacitor c=3.25469e-17
C63 (\1\:Q VSS) capacitor c=4.27596e-17
C64 (\13\:CKb VSS) capacitor c=7.09198e-17
C65 (\18\:qbint VSS) capacitor c=8.89806e-17
C66 (\7\:n30 VSS) capacitor c=5.824e-17
C67 (\4\:mout VSS) capacitor c=5.84317e-17
C68 (\9\:n20 VSS) capacitor c=3.09065e-17
C69 (\18\:CKbb VSS) capacitor c=1.72412e-17
C70 (\2\:n20 VSS) capacitor c=2.45941e-17
C71 (\2\:qbint VSS) capacitor c=2.94275e-17
C72 (\4\:D VSS) capacitor c=5.78236e-17
C73 (\5\:n20 VSS) capacitor c=4.53477e-17
C74 (\6\:n20 VSS) capacitor c=5.53472e-17
C75 (\6\:mout VSS) capacitor c=5.02037e-17
C76 (\7\:mout VSS) capacitor c=4.67258e-17
C77 (\9\:CKbb VSS) capacitor c=1.68185e-17
C78 (\10\:CKbb VSS) capacitor c=1.05188e-16
C79 (\11\:CKbb VSS) capacitor c=5.99744e-17
C80 (\12\:CKbb VSS) capacitor c=4.32058e-17
C81 (\15\:CKbb VSS) capacitor c=1.16928e-16
C82 (\16\:CKbb VSS) capacitor c=5.48658e-17
C83 (\17\:CKbb VSS) capacitor c=3.11051e-17
C84 (\6\:n30 VSS) capacitor c=6.13071e-17
C85 (\9\:n30 VSS) capacitor c=6.3491e-17
C86 (\11\:CKb VSS) capacitor c=1.5307e-16
C87 (\12\:CKb VSS) capacitor c=7.34723e-17
C88 (\4\:CK VSS) capacitor c=6.62342e-17
C89 (\3\:QN VSS) capacitor c=2.81921e-17
C90 (\20\:qbint VSS) capacitor c=1.50096e-16
C91 (\22\:qbint VSS) capacitor c=5.84896e-17
C92 (\23\:qbint VSS) capacitor c=4.20859e-17
C93 (\9\:qint VSS) capacitor c=4.84745e-17
C94 (\10\:qint VSS) capacitor c=4.24449e-17
C95 (\8\:VDD VSS) capacitor c=3.82581e-17
C96 (\18\:VDD VSS) capacitor c=1.67734e-17
Rk22 (CK \4\:CK) resistor r=0.07473 c=0
Rk23 (Q \2\:Q) resistor r=0.04484 c=0
Rk24 (Q \4\:Q) resistor r=0.2571 c=0
Rk1 (\4\:D D) resistor r=0.1894 c=0
Rk26 (\3\:QN QN) resistor r=0.08956 c=0
Rk25 (\2\:QN \3\:QN) resistor r=0.307 c=0
Rk27 (\3\:QN \5\:QN) resistor r=0.07512 c=0
Rk56 (\1\:VDD \7\:VDD) resistor r=0.2025 c=0
Rk57 (\7\:VDD \8\:VDD) resistor r=0.2976 c=0
Rk58 (\8\:VDD \9\:VDD) resistor r=0.5028 c=0
Rk61 (\8\:VDD \15\:VDD) resistor r=0.1017 c=0
Rk62 (\9\:VDD \17\:VDD) resistor r=0.1477 c=0
Rk65 (\18\:VDD VDD) resistor r=0.1172 c=0
Rk63 (\9\:VDD \18\:VDD) resistor r=0.3833 c=0
Rk64 (\18\:VDD \20\:VDD) resistor r=0.1624 c=0
Rk39 (\2\:VSS \3\:VSS) resistor r=0.155 c=0
Rk43 (\3\:VSS \7\:VSS) resistor r=0.4541 c=0
Rk44 (\7\:VSS \8\:VSS) resistor r=0.534 c=0
Rk48 (\7\:VSS \16\:VSS) resistor r=0.3319 c=0
Rk50 (\17\:VSS VSS) resistor r=0.1047 c=0
Rk49 (\8\:VSS \17\:VSS) resistor r=0.3952 c=0
Rk51 (\8\:VSS \19\:VSS) resistor r=0.07132 c=0
Rk52 (\17\:VSS \21\:VSS) resistor r=0.3635 c=0
Rk19 (\10\:CKb \11\:CKb) resistor r=0.9655 c=0
Rk20 (\11\:CKb \12\:CKb) resistor r=0.5379 c=0
Rk21 (\10\:CKb \14\:CKb) resistor r=0.3446 c=0
Rk8 (\9\:CKbb \10\:CKbb) resistor r=0.0378 c=0
Rk9 (\10\:CKbb \11\:CKbb) resistor r=0.4739 c=0
Rk10 (\11\:CKbb \12\:CKbb) resistor r=0.3013 c=0
Rk11 (\12\:CKbb \14\:CKbb) resistor r=0.2545 c=0
Rk12 (\10\:CKbb \15\:CKbb) resistor r=0.7637 c=0
Rk13 (\15\:CKbb \16\:CKbb) resistor r=0.239 c=0
Rk14 (\11\:CKbb \17\:CKbb) resistor r=0.09366 c=0
Rk15 (\12\:CKbb \19\:CKbb) resistor r=0.121 c=0
Rk2 (\5\:n20 \6\:n20) resistor r=0.2396 c=0
Rk3 (\6\:n20 \8\:n20) resistor r=0.3054 c=0
Rk4 (\6\:n20 \10\:n20) resistor r=0.1335 c=0
Rk5 (\5\:mout \6\:mout) resistor r=0.2787 c=0
Rk6 (\6\:mout \7\:mout) resistor r=0.2396 c=0
Rk7 (\6\:mout \9\:mout) resistor r=0.112 c=0
Rk16 (\5\:n30 \6\:n30) resistor r=0.3462 c=0
Rk17 (\6\:n30 \8\:n30) resistor r=0.2937 c=0
Rk18 (\6\:n30 \9\:n30) resistor r=0.2642 c=0
Rk30 (\5\:qbint \19\:qbint) resistor r=0.6139 c=0
Rk31 (\5\:qbint \20\:qbint) resistor r=0.9605 c=0
Rk33 (\19\:qbint \22\:qbint) resistor r=0.4051 c=0
Rk34 (\22\:qbint \23\:qbint) resistor r=0.2148 c=0
Rk35 (\22\:qbint \25\:qbint) resistor r=0.08579 c=0
Rk36 (\8\:qint \9\:qint) resistor r=0.09136 c=0
Rk37 (\9\:qint \10\:qint) resistor r=0.1964 c=0
Rk38 (\9\:qint \12\:qint) resistor r=0.2833 c=0
Rl23 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl24 (\2\:CK \3\:CK) resistor r=41.0764 c=0
Rl1 (\1\:D \2\:D) resistor r=24.2328 c=0
Rl2 (\2\:D \3\:D) resistor r=99.2328 c=0
Rl15 (\6\:CKb \7\:CKb) resistor r=184.181 c=0
Rl6 (\3\:CKb \4\:CKb) resistor r=208.814 c=0
Rl4 (CKb \2\:CKb) resistor r=150.37 c=0
Rl5 (\2\:CKb \3\:CKb) resistor r=278.412 c=0
Rl16 (\7\:CKb \8\:CKb) resistor r=24.2328 c=0
Rl7 (\4\:CKb \5\:CKb) resistor r=24.2328 c=0
Rl17 (\7\:CKbb \8\:CKbb) resistor r=53.0848 c=0
Rl14 (\5\:CKbb \6\:CKbb) resistor r=46.8456 c=0
Rl8 (\3\:CKbb \4\:CKbb) resistor r=68.4636 c=0
Rl3 (CKbb \2\:CKbb) resistor r=49.2328 c=0
Rl11 (n20 \2\:n20) resistor r=104.649 c=0
Rl13 (\2\:n20 \4\:n20) resistor r=37.3411 c=0
Rl12 (\2\:n20 \3\:n20) resistor r=1.8551 c=0
Rl9 (mout \2\:mout) resistor r=101.923 c=0
Rl10 (\2\:mout \3\:mout) resistor r=25.8439 c=0
Rl21 (n30 \2\:n30) resistor r=87.2302 c=0
Rl22 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl35 (\13\:qbint \12\:qbint) resistor r=134.181 c=0
Rl36 (\14\:qbint \13\:qbint) resistor r=29.5379 c=0
Rl18 (\2\:qbint qbint) resistor r=11.5001 c=0
Rl20 (\2\:qbint \4\:qbint) resistor r=43.9449 c=0
Rl19 (\2\:qbint \3\:qbint) resistor r=99.7141 c=0
Rz6 (\2\:Q \1\:Q) resistor r=75 c=0
Rz7 (\5\:QN \4\:QN) resistor r=75 c=0
Rz16 (\1\:VDD \3\:VDD) resistor r=9.375 c=0
Rz17 (\7\:VDD \3\:VDD) resistor r=15 c=0
Rz18 (\9\:VDD \3\:VDD) resistor r=6.8182 c=0
Rz13 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz14 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz15 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz5 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz3 (\18\:CKbb \19\:CKbb) resistor r=75 c=0
Rz1 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz2 (\4\:mout \5\:mout) resistor r=75 c=0
Rz4 (\7\:n30 \8\:n30) resistor r=75 c=0
Rz8 (\19\:qbint \18\:qbint) resistor r=75 c=0
Rz9 (\12\:qint \11\:qint) resistor r=75 c=0
Ry6 (\4\:Q \3\:Q) resistor r=20.6667 c=0
Ry7 (\2\:QN \1\:QN) resistor r=20.6667 c=0
Ry16 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry17 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry18 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry10 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry11 (\3\:VSS \1\:VSS) resistor r=6.2 c=0
Ry12 (\8\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry5 (\9\:CKb \10\:CKb) resistor r=62 c=0
Ry3 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry1 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry2 (\8\:mout \9\:mout) resistor r=62 c=0
Ry4 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry8 (\25\:qbint \24\:qbint) resistor r=62 c=0
Ry9 (\8\:qint \7\:qint) resistor r=62 c=0
Rx11 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx9 (\8\:CKb \11\:CKb) resistor r=45 c=0
Rx10 (\5\:CKb \12\:CKb) resistor r=45 c=0
Rx4 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx5 (\6\:CKbb \15\:CKbb) resistor r=45 c=0
Rx6 (\8\:CKbb \16\:CKbb) resistor r=45 c=0
Rx7 (\2\:CKbb \17\:CKbb) resistor r=45 c=0
Rx2 (\3\:n20 \5\:n20) resistor r=45 c=0
Rx3 (\2\:mout \7\:mout) resistor r=45 c=0
Rx8 (\2\:n30 \9\:n30) resistor r=45 c=0
Rx13 (\20\:qbint \14\:qbint) resistor r=45 c=0
Rx15 (\23\:qbint qbint) resistor r=45 c=0
Rx16 (\10\:qint qint) resistor r=45 c=0
mn21 (\18\:CKbb \2\:CKb \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.118e-14 ad=2.03e-14 ps=7.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn25 (n21 \3\:D \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=8.7e-15 ps=7.2e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=1.94e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn26 (\9\:n20 \3\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.132e-14 ps=4.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=1.835e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\9\:n20 \3\:CKbb n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.16e-14 ad=4.132e-14 ps=4.5e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.35e-07 sb=1.505e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (n25 mout \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=1.16e-14 ps=1.6e-06 pd=4.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.6e-07 sb=1.38e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\4\:mout \4\:n20 \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=3.915e-14 ps=1.6e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.155e-06 sb=1.185e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\7\:n30 \5\:CKbb \4\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.915e-14 ad=2.755e-14 ps=8.3e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47e-06 sb=8.7e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\7\:n30 \6\:CKb n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.755e-14 ps=6.6e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.705e-06 sb=6.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (n35 \3\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=2.682e-14 ps=8.5e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.935e-06 sb=4.05e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\18\:qbint \3\:n30 \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.03e-14 ad=2.87e-14 ps=8.5e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45561e-06 sb=1.4e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn20 (\13\:CKb \3\:CK \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.89e-14 ad=2.465e-14 ps=1.88e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.715e-06 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn55_1__rcx (\1\:Q \5\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=9.575e-14 ad=4.68e-14 ps=1.8e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.31442e-07 sb=1.21519e-06 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(2)
mn57 (\4\:QN qint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.875e-14 ad=5.46e-14 ps=1.405e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.91442e-07 sb=6.55192e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(2)
mn56 (\11\:qint \13\:qbint \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.49e-14 ad=3.263e-14 ps=1.09e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.66e-06 sb=2.25e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mp25 (n22 \1\:D \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=1.29e-14 ps=1.32e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.94e-06 sd=160n sca=16.3177 \
        scb=0.0157291 scc=0.00060458 m=(1)
mp26 (\7\:n20 CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.835e-06 sd=160n sca=15.2202 \
        scb=0.0141545 scc=0.000592469 m=(1)
mp36 (\7\:n20 \4\:CKb n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.63e-06 sd=160n sca=14.1441 \
        scb=0.0132095 scc=0.000590428 m=(1)
mp35 (n26 \3\:mout \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.05e-14 ad=2.902e-14 ps=1.59e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=1.45e-06 sd=160n sca=13.6837 \
        scb=0.0130542 scc=0.000590384 m=(1)
mp30 (\8\:mout n20 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.05e-14 ad=8.062e-14 ps=1.59e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.16e-06 sb=1.185e-06 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp40 (\4\:n30 \7\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.062e-14 ad=4.515e-14 ps=1.18e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.58e-06 sb=7.65e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp51 (\4\:n30 \7\:CKbb n36 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.515e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.835e-06 sb=5.1e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp50 (n36 \4\:qbint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.65e-14 ad=1.29e-14 ps=1.64e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.94e-06 sb=4.05e-07 sd=160n sca=13.6743 \
        scb=0.0130525 scc=0.000590384 m=(1)
mp45 (\24\:qbint n30 \14\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.65e-14 ad=4.34e-14 ps=1.64e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43355e-06 sb=1.4e-07 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(1)
mp20 (\9\:CKb \1\:CK \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.9e-14 ad=3.655e-14 ps=1.38e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.485e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp55_1__rcx (\3\:Q \5\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.0105e-13 ad=7.02e-14 ps=1.37e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.46731e-07 sb=1.03455e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp57 (\1\:QN qint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.922e-14 ad=6.24e-14 ps=1.26e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.06731e-07 sb=4.74551e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp56 (\7\:qint \12\:qbint \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.515e-06 sb=1.4e-07 sd=160n sca=47.1852 \
        scb=0.0292558 scc=0.00588561 m=(1)
ends DFFX2
// End of subcircuit definition.

// Generated for: spectre (May  9 14:37:48 2012 )
// Library name: gsclib045
// Cell name: DFFX4
// View name: extracted

simulator lang=spectre

subckt DFFX4 CK D Q QN VDD VSS
mp20 (\21\:CKb \1\:CK \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=5.15e-14 ps=7.1e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.39535e-07 sd=160n sca=35.6444 \
        scb=0.0398802 scc=0.00365724 m=(1)
C1 (D VSS) capacitor c=3.4856e-17
C2 (Q VSS) capacitor c=3.67342e-17
C3 (CK VSS) capacitor c=9.59378e-17
C4 (QN VSS) capacitor c=1.78931e-17
C5 (VDD VSS) capacitor c=3.01319e-16
C6 (CKb VSS) capacitor c=5.04211e-17
C7 (CKbb VSS) capacitor c=7.99463e-17
C8 (n20 VSS) capacitor c=3.34289e-17
C9 (n25 VSS) capacitor c=1.45671e-19
C10 (mout VSS) capacitor c=8.22485e-17
C11 (n30 VSS) capacitor c=2.08254e-16
C12 (qbint VSS) capacitor c=6.69787e-17
C13 (qint VSS) capacitor c=2.84815e-16
C14 (n22 VSS) capacitor c=2.69352e-19
C15 (n26 VSS) capacitor c=2.60756e-18
C16 (n36 VSS) capacitor c=4.50931e-21
C17 (\22\:qbint VSS) capacitor c=5.0465e-17
C18 (\5\:qbint VSS) capacitor c=2.65919e-16
C19 (\4\:CKbb VSS) capacitor c=4.78955e-17
C20 (\8\:CKb VSS) capacitor c=2.94243e-17
C21 (\6\:CKb VSS) capacitor c=5.01059e-17
C22 (\3\:CKbb VSS) capacitor c=3.50268e-17
C23 (\1\:D VSS) capacitor c=7.09786e-17
C24 (\1\:CK VSS) capacitor c=2.75126e-17
C25 (\20\:qbint VSS) capacitor c=3.06939e-17
C26 (\3\:qbint VSS) capacitor c=7.23176e-17
C27 (\10\:CKb VSS) capacitor c=7.26597e-17
C28 (\6\:CKbb VSS) capacitor c=5.85194e-17
C29 (\3\:n20 VSS) capacitor c=5.10467e-17
C30 (\3\:mout VSS) capacitor c=5.14167e-17
C31 (\5\:CKb VSS) capacitor c=5.41174e-17
C32 (\3\:D VSS) capacitor c=4.50939e-17
C33 (\2\:CKb VSS) capacitor c=4.62541e-17
C34 (\3\:CK VSS) capacitor c=2.04473e-17
C35 (\21\:qbint VSS) capacitor c=4.23603e-17
C36 (\4\:qbint VSS) capacitor c=2.14371e-17
C37 (\5\:CKbb VSS) capacitor c=7.17361e-17
C38 (\11\:CKb VSS) capacitor c=2.92865e-17
C39 (\9\:CKb VSS) capacitor c=3.63349e-17
C40 (\2\:n20 VSS) capacitor c=5.47049e-17
C41 (\2\:mout VSS) capacitor c=6.64106e-17
C42 (\7\:CKb VSS) capacitor c=3.90921e-17
C43 (\4\:CKb VSS) capacitor c=2.11618e-17
C44 (\2\:CKbb VSS) capacitor c=6.25265e-17
C45 (\2\:D VSS) capacitor c=5.23602e-17
C46 (\3\:CKb VSS) capacitor c=2.13124e-17
C47 (\2\:CK VSS) capacitor c=2.65056e-17
C48 (\19\:qint VSS) capacitor c=3.9395e-17
C49 (\1\:VDD VSS) capacitor c=5.09241e-16
C50 (\1\:Q VSS) capacitor c=1.77988e-16
C51 (\31\:qbint VSS) capacitor c=5.95725e-17
C52 (\12\:n30 VSS) capacitor c=8.0199e-17
C53 (\7\:mout VSS) capacitor c=8.04281e-17
C54 (\24\:VDD VSS) capacitor c=2.68911e-17
C55 (\5\:n20 VSS) capacitor c=1.17641e-16
C56 (\27\:VDD VSS) capacitor c=3.555e-17
C57 (\13\:CKbb VSS) capacitor c=1.77113e-17
C58 (\21\:CKb VSS) capacitor c=6.03888e-17
C59 (\30\:VDD VSS) capacitor c=3.0114e-17
C60 (\3\:VDD VSS) capacitor c=7.73972e-17
C61 (\15\:qint VSS) capacitor c=4.89357e-17
C62 (\1\:QN VSS) capacitor c=7.35224e-17
C63 (\28\:qbint VSS) capacitor c=1.98607e-17
C64 (\10\:n30 VSS) capacitor c=3.17929e-17
C65 (\4\:mout VSS) capacitor c=3.66652e-17
C66 (\7\:n20 VSS) capacitor c=7.96303e-17
C67 (\10\:CKbb VSS) capacitor c=9.74502e-17
C68 (\17\:CKb VSS) capacitor c=9.56984e-17
C69 (\2\:qbint VSS) capacitor c=5.48601e-17
C70 (\4\:D VSS) capacitor c=5.21328e-17
C71 (\4\:n20 VSS) capacitor c=6.65334e-17
C72 (\6\:mout VSS) capacitor c=6.86413e-17
C73 (\9\:mout VSS) capacitor c=4.20511e-17
C74 (\12\:CKb VSS) capacitor c=9.47646e-17
C75 (\13\:CKb VSS) capacitor c=9.33833e-17
C76 (\14\:CKb VSS) capacitor c=8.65461e-17
C77 (\15\:CKb VSS) capacitor c=5.40442e-17
C78 (\16\:CKb VSS) capacitor c=7.61431e-17
C79 (\19\:CKb VSS) capacitor c=4.2162e-17
C80 (\20\:CKb VSS) capacitor c=9.45021e-17
C81 (\7\:CKbb VSS) capacitor c=1.91628e-16
C82 (\8\:CKbb VSS) capacitor c=1.86589e-16
C83 (\9\:CKbb VSS) capacitor c=5.29205e-17
C84 (\12\:CKbb VSS) capacitor c=2.52927e-17
C85 (\8\:n30 VSS) capacitor c=5.1243e-17
C86 (\9\:n30 VSS) capacitor c=5.68677e-17
C87 (\4\:Q VSS) capacitor c=9.88118e-17
C88 (\5\:QN VSS) capacitor c=1.76365e-16
C89 (\23\:qbint VSS) capacitor c=2.34064e-16
C90 (\24\:qbint VSS) capacitor c=2.09848e-16
C91 (\26\:qbint VSS) capacitor c=3.90607e-17
C92 (\27\:qbint VSS) capacitor c=4.19843e-17
C93 (\30\:qbint VSS) capacitor c=3.97771e-17
C94 (\17\:qint VSS) capacitor c=4.33752e-17
C95 (\18\:qint VSS) capacitor c=3.05854e-17
C96 (\23\:VDD VSS) capacitor c=3.20815e-17
C97 (\26\:VDD VSS) capacitor c=3.309e-17
Rk2 (D \4\:D) resistor r=0.06305 c=0
Rk25 (\1\:Q Q) resistor r=0.2391 c=0
Rk26 (Q \4\:Q) resistor r=0.1104 c=0
Rk45 (\2\:VSS \3\:VSS) resistor r=0.07253 c=0
Rk52 (\3\:VSS \10\:VSS) resistor r=0.2456 c=0
Rk53 (\10\:VSS \11\:VSS) resistor r=0.2255 c=0
Rk54 (\11\:VSS \12\:VSS) resistor r=0.1252 c=0
Rk55 (\12\:VSS \13\:VSS) resistor r=0.1678 c=0
Rk57 (\14\:VSS VSS) resistor r=0.2007 c=0
Rk56 (\13\:VSS \14\:VSS) resistor r=0.233 c=0
Rk58 (VSS \16\:VSS) resistor r=0.2596 c=0
Rk65 (\11\:VSS \30\:VSS) resistor r=0.07393 c=0
Rk66 (\13\:VSS \32\:VSS) resistor r=0.07393 c=0
Rk1 (CK \4\:CK) resistor r=0.02238 c=0
Rk31 (\1\:QN QN) resistor r=0.1689 c=0
Rk32 (QN \5\:QN) resistor r=0.1167 c=0
Rk80 (\1\:VDD \22\:VDD) resistor r=0.3258 c=0
Rk81 (\22\:VDD \23\:VDD) resistor r=0.1719 c=0
Rk82 (\23\:VDD \25\:VDD) resistor r=0.04331 c=0
Rk83 (\23\:VDD \26\:VDD) resistor r=0.4099 c=0
Rk84 (\26\:VDD \28\:VDD) resistor r=0.2276 c=0
Rk86 (\29\:VDD VDD) resistor r=0.1505 c=0
Rk85 (\26\:VDD \29\:VDD) resistor r=0.218 c=0
Rk87 (VDD \31\:VDD) resistor r=0.3799 c=0
Rk8 (\12\:CKb \13\:CKb) resistor r=0.548 c=0
Rk9 (\13\:CKb \14\:CKb) resistor r=0.4552 c=0
Rk10 (\14\:CKb \15\:CKb) resistor r=0.1638 c=0
Rk11 (\15\:CKb \16\:CKb) resistor r=0.3716 c=0
Rk12 (\16\:CKb \18\:CKb) resistor r=0.3725 c=0
Rk13 (\13\:CKb \19\:CKb) resistor r=0.2036 c=0
Rk14 (\14\:CKb \20\:CKb) resistor r=0.5096 c=0
Rk15 (\18\:CKb \22\:CKb) resistor r=0.4523 c=0
Rk16 (\7\:CKbb \8\:CKbb) resistor r=1.4506 c=0
Rk17 (\8\:CKbb \9\:CKbb) resistor r=0.2802 c=0
Rk18 (\9\:CKbb \11\:CKbb) resistor r=0.3846 c=0
Rk19 (\8\:CKbb \12\:CKbb) resistor r=0.06427 c=0
Rk20 (\9\:CKbb \14\:CKbb) resistor r=0.05841 c=0
Rk3 (\4\:n20 \6\:n20) resistor r=0.4128 c=0
Rk4 (\6\:n20 \8\:n20) resistor r=0.4737 c=0
Rk5 (\5\:mout \6\:mout) resistor r=0.1682 c=0
Rk6 (\6\:mout \8\:mout) resistor r=0.432 c=0
Rk7 (\6\:mout \9\:mout) resistor r=0.1869 c=0
Rk21 (\8\:n30 \9\:n30) resistor r=0.275 c=0
Rk22 (\9\:n30 \11\:n30) resistor r=0.0958 c=0
Rk23 (\9\:n30 \13\:n30) resistor r=0.3467 c=0
Rk35 (\23\:qbint \24\:qbint) resistor r=1.8995 c=0
Rk36 (\24\:qbint \25\:qbint) resistor r=0.2576 c=0
Rk37 (\25\:qbint \26\:qbint) resistor r=0.04668 c=0
Rk38 (\26\:qbint \27\:qbint) resistor r=0.1992 c=0
Rk39 (\24\:qbint \29\:qbint) resistor r=0.08669 c=0
Rk40 (\25\:qbint \30\:qbint) resistor r=0.1728 c=0
Rk41 (\26\:qbint \32\:qbint) resistor r=0.2428 c=0
Rk42 (\16\:qint \17\:qint) resistor r=0.3721 c=0
Rk43 (\17\:qint \18\:qint) resistor r=0.225 c=0
Rk44 (\17\:qint \20\:qint) resistor r=0.1493 c=0
Rl5 (\1\:D \2\:D) resistor r=148.769 c=0
Rl6 (\2\:D \3\:D) resistor r=29.5379 c=0
Rl1 (\1\:CK \2\:CK) resistor r=118.464 c=0
Rl2 (\2\:CK \3\:CK) resistor r=37.6944 c=0
Rl3 (CKb \2\:CKb) resistor r=203.846 c=0
Rl16 (\10\:CKb \11\:CKb) resistor r=81.461 c=0
Rl15 (\8\:CKb \9\:CKb) resistor r=57.6695 c=0
Rl10 (\6\:CKb \7\:CKb) resistor r=42.9995 c=0
Rl7 (\4\:CKb \5\:CKb) resistor r=74.2923 c=0
Rl4 (\2\:CKb \3\:CKb) resistor r=94.9225 c=0
Rl17 (\4\:CKbb \5\:CKbb) resistor r=35.6627 c=0
Rl18 (\5\:CKbb \6\:CKbb) resistor r=199.169 c=0
Rl8 (CKbb \2\:CKbb) resistor r=209.873 c=0
Rl9 (\2\:CKbb \3\:CKbb) resistor r=29.5379 c=0
Rl13 (n20 \2\:n20) resistor r=53.4003 c=0
Rl14 (\2\:n20 \3\:n20) resistor r=141.541 c=0
Rl11 (mout \2\:mout) resistor r=141.541 c=0
Rl12 (\2\:mout \3\:mout) resistor r=66.8618 c=0
Rl56 (\21\:qbint \22\:qbint) resistor r=74.2328 c=0
Rl55 (\21\:qbint \20\:qbint) resistor r=83.2317 c=0
Rl19 (\2\:qbint qbint) resistor r=82.1542 c=0
Rl20 (\2\:qbint \3\:qbint) resistor r=116.817 c=0
Rl21 (\2\:qbint \4\:qbint) resistor r=4.5402 c=0
Rz12 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz19 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz20 (\32\:VSS \31\:VSS) resistor r=75 c=0
Rz22 (\1\:VDD \3\:VDD) resistor r=6.8182 c=0
Rz23 (\22\:VDD \3\:VDD) resistor r=6.25 c=0
Rz24 (\29\:VDD \3\:VDD) resistor r=18.75 c=0
Rz3 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz4 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\4\:mout \5\:mout) resistor r=75 c=0
Rz5 (\11\:n30 \10\:n30) resistor r=75 c=0
Rz10 (\29\:qbint \28\:qbint) resistor r=75 c=0
Rz11 (\16\:qint \15\:qint) resistor r=75 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry13 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry14 (\10\:VSS \1\:VSS) resistor r=15.5 c=0
Ry15 (\12\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry16 (\14\:VSS \1\:VSS) resistor r=12.4 c=0
Ry24 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry25 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry26 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry3 (\21\:CKb \22\:CKb) resistor r=62 c=0
Ry4 (\13\:CKbb \14\:CKbb) resistor r=62 c=0
Ry1 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry2 (\7\:mout \8\:mout) resistor r=62 c=0
Ry5 (\13\:n30 \12\:n30) resistor r=62 c=0
Ry10 (\32\:qbint \31\:qbint) resistor r=31 c=0
Ry11 (\20\:qint \19\:qint) resistor r=20.6667 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx5 (\9\:CKb \12\:CKb) resistor r=45 c=0
Rx6 (\4\:CKb \15\:CKb) resistor r=45 c=0
Rx7 (\3\:CKb \16\:CKb) resistor r=45 c=0
Rx8 (\11\:CKb \19\:CKb) resistor r=45 c=0
Rx9 (\7\:CKb \20\:CKb) resistor r=45 c=0
Rx10 (\5\:CKbb \7\:CKbb) resistor r=45 c=0
Rx11 (\2\:CKbb \12\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx4 (\2\:mout \9\:mout) resistor r=45 c=0
Rx12 (\8\:n30 n30) resistor r=45 c=0
Rx13 (\23\:qbint \21\:qbint) resistor r=45 c=0
Rx14 (\27\:qbint \4\:qbint) resistor r=45 c=0
Rx15 (\30\:qbint \5\:qbint) resistor r=45 c=0
Rx16 (\18\:qint qint) resistor r=45 c=0
mn20 (\17\:CKb \3\:CK \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.05e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn21 (\10\:CKbb \2\:CKb \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.415e-14 ad=2.9e-14 ps=1.8e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn25 (n21 \3\:D \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.415e-14 ad=1.667e-14 ps=1.8e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn26 (\7\:n20 \5\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.667e-14 ad=2.32e-14 ps=5.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn36 (\7\:n20 CKbb n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=2.32e-14 ps=4.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn35 (n25 \3\:mout \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.918e-14 ad=1.015e-14 ps=1.67e-06 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn30 (\4\:mout \3\:n20 \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.918e-14 ad=5.147e-14 ps=1.67e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn40 (\10\:n30 \6\:CKbb \4\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.148e-14 ad=2.32e-14 ps=1e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn51 (\10\:n30 \10\:CKb n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn50 (n35 \3\:qbint \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.49e-14 ad=8.7e-15 ps=1.6e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.895e-06 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn45_1__rcx (\28\:qbint n30 \3\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.388e-14 ad=3.28e-14 ps=1.6e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4439e-06 sb=2e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(2)
mn55_1__rcx (\4\:Q \5\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=9.491e-14 ad=4.16e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28288e-06 sb=2e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn57_1__rcx (\1\:QN qint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=9.055e-14 ad=4.355e-14 ps=1.475e-06 pd=8.55e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.69865e-06 sb=1.165e-06 sd=160n \
        sca=17.5885 scb=0.0172826 scc=0.00162584 m=(4)
mn56 (\15\:qint \20\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.54e-14 ad=3.64e-14 ps=1.1e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mp21 (\13\:CKbb CKb \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.8469 scb=0.00772406 \
        scc=8.06202e-05 m=(1)
mp25 (n22 \1\:D \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.472e-14 ps=7.5e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=10.2589 \
        scb=0.00748244 scc=8.05157e-05 m=(1)
mp26 (\5\:n20 \3\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=4.73e-14 ps=6.6e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.05e-07 sb=2e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp36 (\5\:n20 \6\:CKb n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=4.73e-14 ps=6.6e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=2e-06 sd=160n sca=10.2104 scb=0.00747301 \
        scc=8.05149e-05 m=(1)
mp35 (n26 mout \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=2.472e-14 ps=1.32e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=2e-06 sd=160n sca=10.2104 scb=0.00747301 \
        scc=8.05149e-05 m=(1)
mp30 (\7\:mout n20 \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=6.558e-14 ps=1.32e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.195e-06 sb=2e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp40 (\12\:n30 \8\:CKb \7\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.558e-14 ad=4.945e-14 ps=1.04e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.545e-06 sb=2e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp51 (\12\:n30 \4\:CKbb n36 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.945e-14 ps=5.5e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.82e-06 sb=2e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp50 (n36 qbint \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.415e-14 ad=1.29e-14 ps=1e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.925e-06 sb=2e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp45_1__rcx (\31\:qbint n30 \1\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=6.213e-14 ad=4.96e-14 ps=1.08e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=2e-06 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(2)
mp55_1__rcx (\1\:Q \5\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.433e-14 ad=6.24e-14 ps=1.115e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.27256e-06 sb=1.78e-06 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(4)
mp57_1__rcx (\5\:QN qint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.24e-14 ps=1.1e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.64051e-06 sb=9.6e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(4)
mp56 (\19\:qint \22\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.95487e-06 sb=1.4e-07 sd=160n sca=15.1531 \
        scb=0.0133339 scc=0.000649799 m=(1)
ends DFFX4
// End of subcircuit definition.

// Generated for: spectre (May  9 14:38:25 2012 )
// Library name: gsclib045
// Cell name: DFFXL
// View name: extracted

simulator lang=spectre

subckt DFFXL CK D Q QN VDD VSS
mp57 (\4\:QN qint \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=49.1385 \
        scb=0.0321853 scc=0.00591609 m=(1)
C1 (D VSS) capacitor c=1.34817e-16
C2 (QN VSS) capacitor c=2.03731e-17
C3 (CK VSS) capacitor c=4.53814e-17
C4 (Q VSS) capacitor c=2.7789e-17
C5 (VDD VSS) capacitor c=2.80188e-16
C6 (qint VSS) capacitor c=2.80342e-17
C7 (qbint VSS) capacitor c=2.27589e-17
C8 (CKb VSS) capacitor c=2.19486e-17
C9 (n30 VSS) capacitor c=4.56468e-17
C10 (n35 VSS) capacitor c=6.99755e-18
C11 (mout VSS) capacitor c=4.17341e-17
C12 (CKbb VSS) capacitor c=3.89426e-17
C13 (n20 VSS) capacitor c=4.85076e-17
C14 (n25 VSS) capacitor c=1.70374e-18
C15 (n21 VSS) capacitor c=1.28589e-18
C16 (n36 VSS) capacitor c=2.02629e-18
C17 (n26 VSS) capacitor c=1.81666e-18
C18 (n22 VSS) capacitor c=2.87857e-18
C19 (\8\:CKb VSS) capacitor c=4.58078e-17
C20 (\1\:D VSS) capacitor c=4.04629e-17
C21 (\5\:CKbb VSS) capacitor c=7.75921e-17
C22 (\5\:CKb VSS) capacitor c=4.1682e-17
C23 (\4\:mout VSS) capacitor c=7.89853e-17
C24 (\7\:qbint VSS) capacitor c=8.01688e-17
C25 (\1\:CK VSS) capacitor c=2.44446e-17
C26 (\6\:qbint VSS) capacitor c=2.39003e-17
C27 (\11\:CKb VSS) capacitor c=3.80931e-17
C28 (\3\:D VSS) capacitor c=8.94735e-17
C29 (\6\:CKb VSS) capacitor c=6.60205e-17
C30 (\6\:CKbb VSS) capacitor c=7.93542e-17
C31 (\3\:n20 VSS) capacitor c=4.98389e-17
C32 (\3\:CKbb VSS) capacitor c=3.69073e-17
C33 (\3\:CKb VSS) capacitor c=6.80266e-17
C34 (\10\:qbint VSS) capacitor c=2.58921e-17
C35 (\3\:n30 VSS) capacitor c=4.22325e-17
C36 (\3\:CK VSS) capacitor c=2.23205e-17
C37 (\5\:qbint VSS) capacitor c=1.60842e-17
C38 (\4\:qbint VSS) capacitor c=2.31253e-17
C39 (\3\:qint VSS) capacitor c=2.64702e-17
C40 (\10\:CKb VSS) capacitor c=2.97532e-17
C41 (\2\:D VSS) capacitor c=7.60896e-17
C42 (\7\:CKb VSS) capacitor c=5.65721e-17
C43 (\7\:CKbb VSS) capacitor c=3.10754e-17
C44 (\4\:CKb VSS) capacitor c=4.77815e-17
C45 (\3\:mout VSS) capacitor c=2.98118e-17
C46 (\2\:n20 VSS) capacitor c=5.2697e-17
C47 (\2\:CKb VSS) capacitor c=8.51271e-17
C48 (\4\:CKbb VSS) capacitor c=3.46294e-17
C49 (\2\:CKbb VSS) capacitor c=5.49299e-17
C50 (\9\:qbint VSS) capacitor c=3.05954e-17
C51 (\4\:n30 VSS) capacitor c=2.84512e-17
C52 (\2\:CK VSS) capacitor c=2.01762e-17
C53 (\2\:qbint VSS) capacitor c=3.12239e-17
C54 (\2\:qint VSS) capacitor c=2.44212e-17
C55 (\8\:CKbb VSS) capacitor c=6.50325e-17
C56 (\1\:VDD VSS) capacitor c=3.52693e-17
C57 (\4\:n20 VSS) capacitor c=7.69121e-17
C58 (\7\:VDD VSS) capacitor c=2.4646e-17
C59 (\7\:mout VSS) capacitor c=7.27688e-17
C60 (\9\:n30 VSS) capacitor c=7.65596e-17
C61 (\9\:VDD VSS) capacitor c=2.36844e-17
C62 (\15\:qbint VSS) capacitor c=6.23653e-17
C63 (\18\:CKb VSS) capacitor c=1.58677e-16
C64 (\12\:VDD VSS) capacitor c=5.35638e-17
C65 (\1\:Q VSS) capacitor c=2.33176e-17
C66 (\4\:qint VSS) capacitor c=3.55029e-17
C67 (\16\:VDD VSS) capacitor c=4.57447e-17
C68 (\4\:QN VSS) capacitor c=3.67525e-17
C69 (\3\:VDD VSS) capacitor c=1.18907e-16
C70 (\14\:CKbb VSS) capacitor c=1.41225e-17
C71 (\7\:n20 VSS) capacitor c=8.11598e-17
C72 (\9\:mout VSS) capacitor c=4.88457e-17
C73 (\5\:n30 VSS) capacitor c=7.54053e-17
C74 (\13\:qbint VSS) capacitor c=7.34684e-17
C75 (\20\:CKb VSS) capacitor c=7.52254e-17
C76 (\4\:Q VSS) capacitor c=8.67405e-17
C77 (\8\:qint VSS) capacitor c=4.09139e-17
C78 (\1\:QN VSS) capacitor c=1.86643e-17
C79 (\3\:qbint VSS) capacitor c=2.84154e-17
C80 (\2\:n30 VSS) capacitor c=3.71582e-17
C81 (\8\:qbint VSS) capacitor c=4.5408e-17
C82 (\2\:mout VSS) capacitor c=4.62327e-17
C83 (\9\:CKb VSS) capacitor c=4.18174e-17
C84 (\3\:QN VSS) capacitor c=2.31495e-17
C85 (\6\:qint VSS) capacitor c=3.32685e-17
C86 (\7\:qint VSS) capacitor c=3.1774e-17
C87 (\3\:Q VSS) capacitor c=4.77493e-17
C88 (\4\:CK VSS) capacitor c=5.90877e-17
C89 (\11\:qbint VSS) capacitor c=4.03361e-17
C90 (\12\:qbint VSS) capacitor c=7.0257e-17
C91 (\17\:qbint VSS) capacitor c=1.22079e-16
C92 (\7\:n30 VSS) capacitor c=1.09416e-16
C93 (\8\:n30 VSS) capacitor c=3.53303e-17
C94 (\5\:mout VSS) capacitor c=4.71506e-17
C95 (\6\:mout VSS) capacitor c=6.82468e-17
C96 (\6\:n20 VSS) capacitor c=7.9739e-17
C97 (\9\:n20 VSS) capacitor c=4.86032e-17
C98 (\12\:CKb VSS) capacitor c=4.80111e-17
C99 (\13\:CKb VSS) capacitor c=6.35333e-17
C100 (\14\:CKb VSS) capacitor c=1.35903e-16
C101 (\15\:CKb VSS) capacitor c=3.95651e-17
C102 (\16\:CKb VSS) capacitor c=2.50272e-16
C103 (\17\:CKb VSS) capacitor c=5.19988e-17
C104 (\10\:CKbb VSS) capacitor c=1.23439e-16
C105 (\11\:CKbb VSS) capacitor c=2.18841e-16
C106 (\12\:CKbb VSS) capacitor c=1.647e-16
C107 (\13\:CKbb VSS) capacitor c=5.99884e-17
C108 (\5\:VDD VSS) capacitor c=4.79811e-17
C109 (\11\:VDD VSS) capacitor c=3.99033e-17
C110 (\15\:VDD VSS) capacitor c=4.47019e-18
Rk24 (\4\:D D) resistor r=0.01595 c=0
Rk2 (\3\:QN QN) resistor r=0.04422 c=0
Rk1 (\2\:QN \3\:QN) resistor r=0.04806 c=0
Rk3 (\3\:QN \5\:QN) resistor r=0.2045 c=0
Rk10 (CK \4\:CK) resistor r=0.1371 c=0
Rk48 (\2\:VSS \4\:VSS) resistor r=0.2489 c=0
Rk49 (\4\:VSS \5\:VSS) resistor r=0.341 c=0
Rk50 (\5\:VSS \6\:VSS) resistor r=0.4615 c=0
Rk51 (\6\:VSS \7\:VSS) resistor r=0.1629 c=0
Rk52 (\7\:VSS \8\:VSS) resistor r=0.4713 c=0
Rk53 (\8\:VSS \9\:VSS) resistor r=0.2683 c=0
Rk55 (\10\:VSS VSS) resistor r=0.2128 c=0
Rk54 (\9\:VSS \10\:VSS) resistor r=0.03744 c=0
Rk56 (\5\:VSS \12\:VSS) resistor r=0.1257 c=0
Rk57 (\7\:VSS \14\:VSS) resistor r=0.2317 c=0
Rk58 (\8\:VSS \16\:VSS) resistor r=0.07428 c=0
Rk59 (\10\:VSS \18\:VSS) resistor r=0.3721 c=0
Rk8 (\3\:Q Q) resistor r=0.1133 c=0
Rk7 (\2\:Q \3\:Q) resistor r=0.04292 c=0
Rk9 (\3\:Q \5\:Q) resistor r=0.3038 c=0
Rk37 (\2\:VDD \4\:VDD) resistor r=0.3639 c=0
Rk38 (\4\:VDD \5\:VDD) resistor r=0.305 c=0
Rk39 (\5\:VDD \6\:VDD) resistor r=0.4957 c=0
Rk40 (\5\:VDD \8\:VDD) resistor r=0.04334 c=0
Rk41 (\6\:VDD \10\:VDD) resistor r=0.07151 c=0
Rk42 (\6\:VDD \11\:VDD) resistor r=0.4878 c=0
Rk43 (\11\:VDD \13\:VDD) resistor r=0.443 c=0
Rk44 (\11\:VDD \14\:VDD) resistor r=0.3159 c=0
Rk47 (\15\:VDD VDD) resistor r=0.2128 c=0
Rk45 (\14\:VDD \15\:VDD) resistor r=0.03744 c=0
Rk46 (\15\:VDD \17\:VDD) resistor r=0.4203 c=0
Rk4 (\5\:qint \6\:qint) resistor r=0.09998 c=0
Rk5 (\6\:qint \7\:qint) resistor r=0.1347 c=0
Rk6 (\6\:qint \9\:qint) resistor r=0.124 c=0
Rk11 (\11\:qbint \12\:qbint) resistor r=0.1344 c=0
Rk12 (\12\:qbint \14\:qbint) resistor r=0.2037 c=0
Rk13 (\12\:qbint \16\:qbint) resistor r=0.4439 c=0
Rk14 (\14\:qbint \17\:qbint) resistor r=0.773 c=0
Rk25 (\12\:CKb \13\:CKb) resistor r=0.2246 c=0
Rk26 (\13\:CKb \14\:CKb) resistor r=0.2437 c=0
Rk27 (\14\:CKb \15\:CKb) resistor r=0.1623 c=0
Rk28 (\14\:CKb \16\:CKb) resistor r=1.1478 c=0
Rk29 (\16\:CKb \17\:CKb) resistor r=0.2328 c=0
Rk30 (\16\:CKb \19\:CKb) resistor r=1.2308 c=0
Rk31 (\19\:CKb \21\:CKb) resistor r=0.5628 c=0
Rk15 (\6\:n30 \7\:n30) resistor r=0.5455 c=0
Rk16 (\7\:n30 \8\:n30) resistor r=0.1057 c=0
Rk17 (\7\:n30 \10\:n30) resistor r=0.5067 c=0
Rk18 (\5\:mout \6\:mout) resistor r=0.1675 c=0
Rk19 (\6\:mout \8\:mout) resistor r=0.4479 c=0
Rk20 (\6\:mout \10\:mout) resistor r=0.1703 c=0
Rk32 (\9\:CKbb \10\:CKbb) resistor r=0.5433 c=0
Rk33 (\10\:CKbb \11\:CKbb) resistor r=0.7331 c=0
Rk34 (\11\:CKbb \12\:CKbb) resistor r=1.1779 c=0
Rk35 (\12\:CKbb \13\:CKbb) resistor r=0.4168 c=0
Rk36 (\10\:CKbb \15\:CKbb) resistor r=0.06511 c=0
Rk21 (\5\:n20 \6\:n20) resistor r=0.4732 c=0
Rk22 (\6\:n20 \8\:n20) resistor r=0.4662 c=0
Rk23 (\6\:n20 \9\:n20) resistor r=0.188 c=0
Rl29 (\1\:D \2\:D) resistor r=103.365 c=0
Rl30 (\2\:D \3\:D) resistor r=158.414 c=0
Rl8 (\1\:CK \2\:CK) resistor r=39.6174 c=0
Rl9 (\2\:CK \3\:CK) resistor r=24.2328 c=0
Rl1 (qint \2\:qint) resistor r=28.079 c=0
Rl2 (\2\:qint \3\:qint) resistor r=35.7713 c=0
Rl3 (qbint \2\:qbint) resistor r=33.4251 c=0
Rl6 (\2\:qbint \5\:qbint) resistor r=24.7951 c=0
Rl7 (\3\:qbint \6\:qbint) resistor r=33.8489 c=0
Rl5 (\3\:qbint \4\:qbint) resistor r=55.0028 c=0
Rl4 (\2\:qbint \3\:qbint) resistor r=160.453 c=0
Rl13 (\7\:qbint \8\:qbint) resistor r=226.203 c=0
Rl15 (\8\:qbint \10\:qbint) resistor r=47.791 c=0
Rl14 (\8\:qbint \9\:qbint) resistor r=9.1017 c=0
Rl28 (\6\:CKb \7\:CKb) resistor r=74.2328 c=0
Rl25 (\4\:CKb \5\:CKb) resistor r=64.5404 c=0
Rl18 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl19 (\2\:CKb \3\:CKb) resistor r=291.427 c=0
Rl31 (\8\:CKb \9\:CKb) resistor r=177.726 c=0
Rl33 (\9\:CKb \11\:CKb) resistor r=95.0334 c=0
Rl32 (\9\:CKb \10\:CKb) resistor r=2.4801 c=0
Rl10 (n30 \2\:n30) resistor r=131.606 c=0
Rl11 (\2\:n30 \3\:n30) resistor r=141.815 c=0
Rl12 (\2\:n30 \4\:n30) resistor r=7.6417 c=0
Rl22 (mout \2\:mout) resistor r=67.6161 c=0
Rl24 (\2\:mout \4\:mout) resistor r=219.894 c=0
Rl23 (\2\:mout \3\:mout) resistor r=15.3298 c=0
Rl26 (\5\:CKbb \6\:CKbb) resistor r=303.412 c=0
Rl27 (\6\:CKbb \7\:CKbb) resistor r=26.1559 c=0
Rl17 (\3\:CKbb \4\:CKbb) resistor r=62.6944 c=0
Rl16 (CKbb \2\:CKbb) resistor r=74.2328 c=0
Rl20 (n20 \2\:n20) resistor r=133.79 c=0
Rl21 (\2\:n20 \3\:n20) resistor r=116.483 c=0
Rz1 (\1\:QN \2\:QN) resistor r=75 c=0
Rz13 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz14 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz15 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz16 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz17 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz3 (\4\:Q \5\:Q) resistor r=75 c=0
Rz10 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz11 (\3\:VDD \6\:VDD) resistor r=7.5 c=0
Rz12 (\3\:VDD \14\:VDD) resistor r=12.5 c=0
Rz2 (\8\:qint \9\:qint) resistor r=75 c=0
Rz4 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz8 (\20\:CKb \21\:CKb) resistor r=75 c=0
Rz5 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz6 (\9\:mout \10\:mout) resistor r=75 c=0
Rz9 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz7 (\7\:n20 \8\:n20) resistor r=75 c=0
Ry1 (\4\:QN \5\:QN) resistor r=62 c=0
Ry15 (\3\:VSS \4\:VSS) resistor r=15.5 c=0
Ry16 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry17 (\3\:VSS \9\:VSS) resistor r=10.3333 c=0
Ry3 (\1\:Q \2\:Q) resistor r=62 c=0
Ry10 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry11 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry12 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry13 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry14 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry2 (\4\:qint \5\:qint) resistor r=62 c=0
Ry4 (\15\:qbint \16\:qbint) resistor r=62 c=0
Ry8 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry5 (\9\:n30 \10\:n30) resistor r=62 c=0
Ry6 (\7\:mout \8\:mout) resistor r=62 c=0
Ry9 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=62 c=0
Rx8 (\2\:D \4\:D) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (\2\:qint \7\:qint) resistor r=45 c=0
Rx3 (\9\:qbint \11\:qbint) resistor r=45 c=0
Rx4 (\2\:qbint \17\:qbint) resistor r=45 c=0
Rx9 (\10\:CKb \12\:CKb) resistor r=45 c=0
Rx10 (\7\:CKb \13\:CKb) resistor r=45 c=0
Rx11 (\4\:CKb \15\:CKb) resistor r=45 c=0
Rx12 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx5 (\4\:n30 \8\:n30) resistor r=45 c=0
Rx6 (\3\:mout \5\:mout) resistor r=45 c=0
Rx13 (\7\:CKbb \11\:CKbb) resistor r=45 c=0
Rx14 (\4\:CKbb \12\:CKbb) resistor r=45 c=0
Rx15 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \9\:n20) resistor r=45 c=0
mn57 (\1\:QN \3\:qint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\8\:qint \4\:qbint \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn55 (\4\:Q \5\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.495e-14 ad=2.03e-14 ps=1.78e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\20\:CKb \3\:CK \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.495e-14 ad=3.698e-14 ps=1.78e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=2.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\13\:qbint \3\:n30 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.973e-14 ad=2.03e-14 ps=7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=8.15925 scb=0.00587019 \
        scc=8.94977e-05 m=(1)
mn50 (n35 \10\:qbint \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.973e-14 ad=3.407e-14 ps=7e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.9e-07 sb=2e-06 sd=160n sca=8.15925 scb=0.00587019 \
        scc=8.94977e-05 m=(1)
mn51 (\5\:n30 \3\:CKb n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.407e-14 ad=2.32e-14 ps=7.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.83e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn40 (\5\:n30 \3\:CKbb \9\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.64e-14 ad=2.32e-14 ps=9.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=1.625e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn30 (\9\:mout \3\:n20 \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.44e-14 ad=4.64e-14 ps=1.23e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24e-06 sb=1.26e-06 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn35 (n25 mout \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.44e-14 ad=1.813e-14 ps=1.23e-06 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.605e-06 sb=8.95e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn26 (\7\:n20 \6\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=2.32e-14 ps=4.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.98e-06 sb=5.2e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn36 (\7\:n20 \6\:CKbb n25 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.813e-14 ad=2.32e-14 ps=5.4e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.775e-06 sb=7.25e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn25 (n21 \3\:D \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.61e-14 ad=1.015e-14 ps=8e-07 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.05e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn21 (\14\:CKbb \11\:CKb \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.61e-14 ad=2.03e-14 ps=8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=8.15925 scb=0.00587019 \
        scc=8.94977e-05 m=(1)
mp56 (\4\:qint \6\:qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=46.9517 \
        scb=0.029008 scc=0.00588492 m=(1)
mp55 (\1\:Q qbint \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.978e-14 ad=3.01e-14 ps=8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.7e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\18\:CKb \1\:CK \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.978e-14 ad=3.01e-14 ps=8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp45 (\15\:qbint n30 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=10.2104 scb=0.00747301 \
        scc=8.05149e-05 m=(1)
mp50 (n36 \7\:qbint \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=3.44e-14 ps=1.32e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp51 (\9\:n30 CKbb n36 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.515e-14 ps=7.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1.88e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp40 (\9\:n30 CKb \7\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.45e-14 ad=4.515e-14 ps=1.03e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.625e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp30 (\7\:mout n20 \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=6.45e-14 ps=1.32e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.21e-06 sb=1.28e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp35 (n26 \4\:mout \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.43e-14 ad=2.58e-14 ps=1.32e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=1.015e-06 sd=160n sca=10.2104 \
        scb=0.00747301 scc=8.05149e-05 m=(1)
mp36 (\4\:n20 \5\:CKb n26 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.58e-14 ad=3.44e-14 ps=6.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.64e-06 sb=8.5e-07 sd=160n sca=10.3113 \
        scb=0.00749421 scc=8.05171e-05 m=(1)
mp26 (\4\:n20 \5\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.053e-14 ad=3.44e-14 ps=9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=6.45e-07 sd=160n sca=10.9525 \
        scb=0.00779426 scc=8.06839e-05 m=(1)
mp25 (n22 \1\:D \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.053e-14 ps=7.5e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.65e-07 sd=160n sca=13.4702 scb=0.0111763 \
        scc=0.0001097 m=(1)
mp21 (\8\:CKbb \8\:CKb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.6e-07 sd=160n sca=21.8638 scb=0.0242315 \
        scc=0.00109598 m=(1)
ends DFFXL
// End of subcircuit definition.

// Generated for: spectre (May  9 14:39:02 2012 )
// Library name: gsclib045
// Cell name: DLY1X1
// View name: extracted

simulator lang=spectre

subckt DLY1X1 A VDD VSS Y
mp0 (\8\:n0 \1\:A \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.655e-14 ps=7.5e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.85e-07 sd=160n sca=34.7345 \
        scb=0.0347529 scc=0.00361149 m=(1)
C1 (Y VSS) capacitor c=2.54243e-17
C2 (VDD VSS) capacitor c=7.55279e-17
C3 (A VSS) capacitor c=8.45592e-17
C4 (n0 VSS) capacitor c=5.78006e-17
C5 (n1 VSS) capacitor c=3.80802e-17
C6 (n2 VSS) capacitor c=4.54306e-17
C7 (n5 VSS) capacitor c=2.62229e-18
C8 (\1\:A VSS) capacitor c=2.80019e-17
C9 (\4\:n2 VSS) capacitor c=3.47173e-17
C10 (\3\:n1 VSS) capacitor c=3.15426e-17
C11 (\1\:VDD VSS) capacitor c=4.48904e-17
C12 (\3\:n0 VSS) capacitor c=3.09528e-17
C13 (\3\:A VSS) capacitor c=4.97104e-17
C14 (\3\:n2 VSS) capacitor c=1.72025e-17
C15 (\2\:n1 VSS) capacitor c=2.64255e-17
C16 (\2\:VDD VSS) capacitor c=3.95169e-17
C17 (\2\:n0 VSS) capacitor c=5.21043e-17
C18 (\2\:A VSS) capacitor c=3.84238e-17
C19 (\3\:Y VSS) capacitor c=6.38913e-17
C20 (\3\:VDD VSS) capacitor c=4.5898e-17
C21 (\8\:n2 VSS) capacitor c=5.29312e-17
C22 (\8\:n1 VSS) capacitor c=5.04036e-17
C23 (\11\:VDD VSS) capacitor c=2.26986e-17
C24 (\8\:n0 VSS) capacitor c=4.12191e-17
C25 (\5\:VDD VSS) capacitor c=2.41585e-17
C26 (\1\:Y VSS) capacitor c=1.56048e-17
C27 (\5\:n2 VSS) capacitor c=5.01267e-17
C28 (\6\:n1 VSS) capacitor c=7.52873e-17
C29 (\6\:n0 VSS) capacitor c=2.13991e-17
C30 (\2\:n2 VSS) capacitor c=1.37892e-17
C31 (\4\:n0 VSS) capacitor c=4.66214e-17
C32 (\5\:n0 VSS) capacitor c=3.46901e-17
C33 (\4\:A VSS) capacitor c=3.26326e-17
C34 (\4\:n1 VSS) capacitor c=5.18803e-17
C35 (\5\:n1 VSS) capacitor c=9.19376e-17
C36 (\7\:n2 VSS) capacitor c=9.01484e-17
C37 (\7\:VDD VSS) capacitor c=9.80445e-18
C38 (\8\:VDD VSS) capacitor c=4.06627e-18
C39 (\10\:VDD VSS) capacitor c=1.21859e-16
Rk10 (Y \2\:Y) resistor r=0.05091 c=0
Rk11 (Y \4\:Y) resistor r=0.2575 c=0
Rk12 (\4\:VDD \6\:VDD) resistor r=0.5313 c=0
Rk13 (\6\:VDD \7\:VDD) resistor r=0.2153 c=0
Rk14 (\7\:VDD \8\:VDD) resistor r=0.1425 c=0
Rk16 (\9\:VDD VDD) resistor r=0.04987 c=0
Rk15 (\8\:VDD \9\:VDD) resistor r=0.09253 c=0
Rk17 (\7\:VDD \10\:VDD) resistor r=0.7156 c=0
Rk18 (\8\:VDD \12\:VDD) resistor r=0.3858 c=0
Rk4 (\4\:A A) resistor r=0.08652 c=0
Rk19 (\4\:VSS \6\:VSS) resistor r=0.4665 c=0
Rk20 (\6\:VSS \7\:VSS) resistor r=0.2153 c=0
Rk21 (\7\:VSS \8\:VSS) resistor r=0.1425 c=0
Rk23 (\9\:VSS VSS) resistor r=0.04987 c=0
Rk22 (\8\:VSS \9\:VSS) resistor r=0.09253 c=0
Rk24 (\7\:VSS \10\:VSS) resistor r=0.7178 c=0
Rk25 (\8\:VSS \12\:VSS) resistor r=0.1777 c=0
Rk1 (\4\:n0 \5\:n0) resistor r=0.1949 c=0
Rk2 (\5\:n0 \7\:n0) resistor r=0.1249 c=0
Rk3 (\5\:n0 \9\:n0) resistor r=0.3618 c=0
Rk5 (\4\:n1 \5\:n1) resistor r=0.1846 c=0
Rk6 (\5\:n1 \7\:n1) resistor r=0.4884 c=0
Rk7 (\5\:n1 \9\:n1) resistor r=0.2867 c=0
Rk8 (\6\:n2 \7\:n2) resistor r=0.2686 c=0
Rk9 (\7\:n2 \9\:n2) resistor r=0.3492 c=0
Rl5 (\1\:VDD \2\:VDD) resistor r=93.4636 c=0
Rl1 (\1\:A \2\:A) resistor r=29.5379 c=0
Rl2 (\2\:A \3\:A) resistor r=162.23 c=0
Rl6 (\1\:VSS \2\:VSS) resistor r=66.8207 c=0
Rl3 (n0 \2\:n0) resistor r=162.23 c=0
Rl4 (\2\:n0 \3\:n0) resistor r=29.5379 c=0
Rl7 (n1 \2\:n1) resistor r=29.5379 c=0
Rl8 (\2\:n1 \3\:n1) resistor r=44.9225 c=0
Rl9 (n2 \2\:n2) resistor r=57.4064 c=0
Rl11 (\2\:n2 \4\:n2) resistor r=34.3295 c=0
Rl10 (\2\:n2 \3\:n2) resistor r=1.2666 c=0
Rz4 (\1\:Y \2\:Y) resistor r=75 c=0
Rz5 (\5\:VDD \6\:VDD) resistor r=10.7143 c=0
Rz6 (\5\:VDD \9\:VDD) resistor r=37.5 c=0
Rz7 (\3\:VSS \4\:VSS) resistor r=75 c=0
Rz8 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz1 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz2 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz3 (\5\:n2 \6\:n2) resistor r=75 c=0
Ry4 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry5 (\3\:VDD \4\:VDD) resistor r=62 c=0
Ry6 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry7 (\5\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry8 (\5\:VSS \9\:VSS) resistor r=31 c=0
Ry1 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry2 (\8\:n1 \9\:n1) resistor r=62 c=0
Ry3 (\8\:n2 \9\:n2) resistor r=62 c=0
Rx5 (\2\:VDD \10\:VDD) resistor r=45 c=0
Rx2 (\2\:A \4\:A) resistor r=45 c=0
Rx6 (\1\:VSS \10\:VSS) resistor r=45 c=0
Rx1 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx4 (\3\:n2 \7\:n2) resistor r=45 c=0
mn0 (\6\:n0 \3\:A \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.465e-14 ps=6.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=5.85e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn1 (n4 \3\:n0 \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.885e-14 ps=6.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=3.8e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn2 (\6\:n1 \1\:VDD n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.885e-14 ad=2.973e-14 ps=5.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=2.05e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn3 (\5\:n2 \3\:n1 \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn4 (\1\:Y \4\:n2 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.71058e-07 sb=1.4e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mp1 (n5 n0 \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.193e-14 ps=7.5e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=3.8e-07 sd=160n sca=29.5145 \
        scb=0.0258721 scc=0.00324978 m=(1)
mp2 (\8\:n1 \2\:VSS n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.193e-14 ad=3.01e-14 ps=8.2e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.15e-07 sb=1.4e-07 sd=160n sca=27.7866 \
        scb=0.0238669 scc=0.00324002 m=(1)
mp3 (\8\:n2 n1 \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=48.724 scb=0.031482 \
        scc=0.00590454 m=(1)
mp4 (\3\:Y n2 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.4e-07 sd=160n sca=43.1032 \
        scb=0.0380646 scc=0.00455683 m=(1)
ends DLY1X1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:39:40 2012 )
// Library name: gsclib045
// Cell name: DLY1X4
// View name: extracted

simulator lang=spectre

subckt DLY1X4 A VDD VSS Y
mp0 (\8\:n0 \1\:A \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.75e-07 sd=160n sca=17.5351 \
        scb=0.0182864 scc=0.000415857 m=(1)
C1 (Y VSS) capacitor c=1.8401e-17
C2 (VDD VSS) capacitor c=1.26184e-16
C3 (n0 VSS) capacitor c=8.11031e-17
C4 (n1 VSS) capacitor c=4.16373e-17
C5 (n2 VSS) capacitor c=2.03713e-16
C6 (n5 VSS) capacitor c=9.53257e-19
C7 (\1\:A VSS) capacitor c=4.00784e-17
C8 (\3\:n1 VSS) capacitor c=2.84362e-17
C9 (\1\:VDD VSS) capacitor c=6.26888e-17
C10 (\3\:n0 VSS) capacitor c=4.63327e-17
C11 (\3\:A VSS) capacitor c=4.25577e-17
C12 (\6\:n2 VSS) capacitor c=2.34896e-17
C13 (\2\:n1 VSS) capacitor c=3.6828e-17
C14 (\2\:VDD VSS) capacitor c=3.85971e-17
C15 (\2\:n0 VSS) capacitor c=8.21296e-17
C16 (\2\:A VSS) capacitor c=5.74401e-17
C17 (\3\:VDD VSS) capacitor c=1.90338e-16
C18 (\1\:Y VSS) capacitor c=1.58989e-16
C19 (\14\:n2 VSS) capacitor c=9.46272e-17
C20 (\8\:n1 VSS) capacitor c=8.32536e-17
C21 (\18\:VDD VSS) capacitor c=2.68493e-17
C22 (\8\:n0 VSS) capacitor c=6.85186e-17
C23 (\6\:VDD VSS) capacitor c=1.48594e-17
C24 (\4\:Y VSS) capacitor c=7.21677e-17
C25 (\17\:n2 VSS) capacitor c=5.06606e-17
C26 (\6\:n1 VSS) capacitor c=6.71267e-17
C27 (\6\:n0 VSS) capacitor c=2.65721e-17
C28 (\4\:A VSS) capacitor c=1.17187e-16
C29 (\4\:n0 VSS) capacitor c=4.90236e-17
C30 (\5\:n0 VSS) capacitor c=5.16659e-17
C31 (\4\:n1 VSS) capacitor c=4.57089e-17
C32 (\5\:n1 VSS) capacitor c=8.50203e-17
C33 (\16\:n2 VSS) capacitor c=9.13499e-17
C34 (\9\:VDD VSS) capacitor c=2.63031e-17
C35 (\17\:VDD VSS) capacitor c=9.60568e-17
Rk11 (\1\:Y Y) resistor r=0.04849 c=0
Rk12 (Y \4\:Y) resistor r=0.1952 c=0
Rk1 (A \4\:A) resistor r=0.004953 c=0
Rk30 (\3\:VSS \9\:VSS) resistor r=0.3432 c=0
Rk35 (\10\:VSS VSS) resistor r=0.1001 c=0
Rk31 (\9\:VSS \10\:VSS) resistor r=0.1384 c=0
Rk34 (\9\:VSS \15\:VSS) resistor r=0.8216 c=0
Rk36 (\10\:VSS \17\:VSS) resistor r=0.3548 c=0
Rk18 (\3\:VDD \9\:VDD) resistor r=0.3432 c=0
Rk19 (\9\:VDD \10\:VDD) resistor r=0.03743 c=0
Rk20 (\10\:VDD \11\:VDD) resistor r=0.04997 c=0
Rk22 (\12\:VDD VDD) resistor r=0.04991 c=0
Rk21 (\11\:VDD \12\:VDD) resistor r=0.1001 c=0
Rk25 (\9\:VDD \17\:VDD) resistor r=0.6293 c=0
Rk26 (\11\:VDD \19\:VDD) resistor r=0.2826 c=0
Rk2 (\4\:n0 \5\:n0) resistor r=0.1912 c=0
Rk3 (\5\:n0 \7\:n0) resistor r=0.1365 c=0
Rk4 (\5\:n0 \9\:n0) resistor r=0.5147 c=0
Rk5 (\4\:n1 \5\:n1) resistor r=0.1467 c=0
Rk6 (\5\:n1 \7\:n1) resistor r=0.3376 c=0
Rk7 (\5\:n1 \9\:n1) resistor r=0.4299 c=0
Rk8 (\15\:n2 \16\:n2) resistor r=0.4506 c=0
Rk9 (\16\:n2 \18\:n2) resistor r=0.2492 c=0
Rl1 (\1\:A \2\:A) resistor r=109.615 c=0
Rl2 (\2\:A \3\:A) resistor r=101.099 c=0
Rl6 (\1\:VSS \2\:VSS) resistor r=57.6695 c=0
Rl5 (\2\:VDD \1\:VDD) resistor r=97.2519 c=0
Rl3 (n0 \2\:n0) resistor r=196.982 c=0
Rl4 (\2\:n0 \3\:n0) resistor r=47.2144 c=0
Rl7 (n1 \2\:n1) resistor r=26.098 c=0
Rl8 (\2\:n1 \3\:n1) resistor r=41.4826 c=0
Rl13 (n2 \6\:n2) resistor r=4.8851 c=0
Rz12 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz6 (\3\:VDD \6\:VDD) resistor r=9.375 c=0
Rz7 (\10\:VDD \6\:VDD) resistor r=75 c=0
Rz8 (\12\:VDD \6\:VDD) resistor r=37.5 c=0
Rz1 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz2 (\6\:n1 \7\:n1) resistor r=75 c=0
Rz3 (\18\:n2 \17\:n2) resistor r=75 c=0
Ry10 (\3\:VSS \6\:VSS) resistor r=7.75 c=0
Ry11 (\10\:VSS \6\:VSS) resistor r=20.6667 c=0
Ry9 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry1 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry2 (\8\:n1 \9\:n1) resistor r=62 c=0
Ry3 (\15\:n2 \14\:n2) resistor r=20.6667 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx6 (\15\:VSS \1\:VSS) resistor r=45 c=0
Rx5 (\17\:VDD \2\:VDD) resistor r=45 c=0
Rx2 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx3 (\2\:n1 \4\:n1) resistor r=45 c=0
Rx4 (\16\:n2 \6\:n2) resistor r=45 c=0
mn0 (\6\:n0 \3\:A \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.3e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn1 (n4 \3\:n0 \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.25e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn2 (\6\:n1 \1\:VDD n4 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.19e-14 ps=4.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2.2e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn3 (\17\:n2 \3\:n1 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.6e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn4 (\4\:Y n2 \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.03e-14 ad=4.16e-14 ps=8.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.55e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(4)
mp1 (n5 n0 \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.613e-14 ps=7.5e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.7e-07 sd=160n sca=12.8452 \
        scb=0.0102734 scc=0.000135926 m=(1)
mp2 (\8\:n1 \2\:VSS n5 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.613e-14 ad=3.225e-14 ps=5.8e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.65e-07 sb=1.5e-07 sd=160n sca=11.8288 \
        scb=0.00897951 scc=0.000129234 m=(1)
mp3 (\14\:n2 n1 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.6e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp4 (\1\:Y n2 \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.55e-07 sd=160n sca=30.7862 \
        scb=0.0202776 scc=0.00336099 m=(4)
ends DLY1X4
// End of subcircuit definition.

// Generated for: spectre (May  9 14:40:17 2012 )
// Library name: gsclib045
// Cell name: DLY2X1
// View name: extracted

simulator lang=spectre

subckt DLY2X1 A VDD VSS Y
mp8 (\1\:Y n4 \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.008e-14 ad=5.46e-14 ps=1.39e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.21154e-07 sd=160n sca=17.8302 \
        scb=0.0172414 scc=0.000800052 m=(1)
C1 (A VSS) capacitor c=2.88147e-17
C2 (Y VSS) capacitor c=8.76733e-17
C3 (VDD VSS) capacitor c=2.54021e-16
C4 (n4 VSS) capacitor c=3.76458e-17
C5 (n0 VSS) capacitor c=3.64102e-17
C6 (n1 VSS) capacitor c=8.90144e-17
C7 (n8 VSS) capacitor c=5.89322e-18
C8 (n2 VSS) capacitor c=1.02939e-16
C9 (n3 VSS) capacitor c=3.61434e-17
C10 (n10 VSS) capacitor c=1.374e-18
C11 (n7 VSS) capacitor c=1.80608e-18
C12 (n11 VSS) capacitor c=1.58096e-18
C13 (\4\:A VSS) capacitor c=3.73379e-17
C14 (\5\:VDD VSS) capacitor c=4.67968e-17
C15 (\2\:n2 VSS) capacitor c=6.96069e-17
C16 (\3\:n3 VSS) capacitor c=5.13987e-17
C17 (\3\:VDD VSS) capacitor c=3.68464e-17
C18 (\2\:n1 VSS) capacitor c=3.10497e-17
C19 (\3\:A VSS) capacitor c=3.23406e-17
C20 (\1\:VDD VSS) capacitor c=4.00704e-17
C21 (\3\:n0 VSS) capacitor c=6.53935e-17
C22 (\3\:n4 VSS) capacitor c=4.40357e-17
C23 (\6\:VDD VSS) capacitor c=5.5464e-17
C24 (\3\:n2 VSS) capacitor c=3.14165e-17
C25 (\2\:n3 VSS) capacitor c=4.82514e-17
C26 (\4\:VDD VSS) capacitor c=3.52207e-17
C27 (\3\:n1 VSS) capacitor c=2.27983e-17
C28 (\1\:A VSS) capacitor c=1.67944e-17
C29 (\2\:n0 VSS) capacitor c=6.61003e-17
C30 (\2\:VDD VSS) capacitor c=3.91761e-17
C31 (\2\:n4 VSS) capacitor c=3.12622e-17
C32 (\5\:n3 VSS) capacitor c=1.09142e-16
C33 (\9\:VDD VSS) capacitor c=7.52774e-17
C34 (\8\:n4 VSS) capacitor c=4.70375e-17
C35 (\7\:n2 VSS) capacitor c=7.92792e-17
C36 (\17\:VDD VSS) capacitor c=2.92915e-17
C37 (\4\:n0 VSS) capacitor c=1.45996e-16
C38 (\7\:n1 VSS) capacitor c=8.85556e-17
C39 (\19\:VDD VSS) capacitor c=1.7397e-16
C40 (\1\:Y VSS) capacitor c=7.74304e-17
C41 (\11\:VDD VSS) capacitor c=9.09585e-17
C42 (\7\:n3 VSS) capacitor c=9.56567e-17
C43 (\4\:n4 VSS) capacitor c=1.36798e-16
C44 (\5\:n2 VSS) capacitor c=2.06461e-16
C45 (\7\:n0 VSS) capacitor c=6.69076e-17
C46 (\5\:n1 VSS) capacitor c=1.12379e-16
C47 (\3\:Y VSS) capacitor c=4.34501e-17
C48 (\2\:A VSS) capacitor c=1.54622e-17
C49 (\6\:n0 VSS) capacitor c=1.09087e-16
C50 (\5\:A VSS) capacitor c=7.5353e-17
C51 (\4\:n1 VSS) capacitor c=5.47412e-17
C52 (\6\:n4 VSS) capacitor c=2.5777e-16
C53 (\7\:n4 VSS) capacitor c=2.61131e-16
C54 (\4\:n2 VSS) capacitor c=1.78176e-16
C55 (\4\:n3 VSS) capacitor c=8.00049e-17
C56 (\7\:VDD VSS) capacitor c=7.93021e-17
C57 (\8\:VDD VSS) capacitor c=9.73257e-17
C58 (\13\:VDD VSS) capacitor c=4.02486e-17
C59 (\15\:VDD VSS) capacitor c=7.88869e-18
C60 (\16\:VDD VSS) capacitor c=2.42823e-17
C61 (\21\:VDD VSS) capacitor c=1.27465e-16
Rk5 (A \5\:A) resistor r=0.06206 c=0
Rk1 (\2\:Y Y) resistor r=0.5484 c=0
Rk2 (Y \4\:Y) resistor r=0.2699 c=0
Rk28 (\7\:VDD \8\:VDD) resistor r=0.408 c=0
Rk29 (\8\:VDD \10\:VDD) resistor r=0.5772 c=0
Rk30 (\10\:VDD \12\:VDD) resistor r=0.31 c=0
Rk31 (\12\:VDD \13\:VDD) resistor r=0.4943 c=0
Rk32 (\13\:VDD \14\:VDD) resistor r=0.3587 c=0
Rk34 (\15\:VDD VDD) resistor r=0.1909 c=0
Rk33 (\14\:VDD \15\:VDD) resistor r=0.1585 c=0
Rk35 (\8\:VDD \16\:VDD) resistor r=0.07969 c=0
Rk36 (\13\:VDD \18\:VDD) resistor r=0.1033 c=0
Rk37 (\15\:VDD \20\:VDD) resistor r=0.1731 c=0
Rk38 (\20\:VDD \21\:VDD) resistor r=1.0471 c=0
Rk15 (\7\:VSS \9\:VSS) resistor r=0.9259 c=0
Rk16 (\9\:VSS \10\:VSS) resistor r=0.1985 c=0
Rk17 (\10\:VSS \11\:VSS) resistor r=0.1529 c=0
Rk18 (\11\:VSS \12\:VSS) resistor r=0.2483 c=0
Rk19 (\12\:VSS \13\:VSS) resistor r=0.2145 c=0
Rk20 (\13\:VSS \14\:VSS) resistor r=0.2373 c=0
Rk22 (\15\:VSS VSS) resistor r=0.2029 c=0
Rk21 (\14\:VSS \15\:VSS) resistor r=0.2489 c=0
Rk23 (\10\:VSS \17\:VSS) resistor r=0.3595 c=0
Rk24 (\12\:VSS \18\:VSS) resistor r=0.6569 c=0
Rk25 (\13\:VSS \20\:VSS) resistor r=0.04336 c=0
Rk26 (\14\:VSS \21\:VSS) resistor r=0.5986 c=0
Rk27 (\15\:VSS \23\:VSS) resistor r=0.2641 c=0
Rk8 (\5\:n4 \6\:n4) resistor r=0.6869 c=0
Rk9 (\6\:n4 \7\:n4) resistor r=1.7436 c=0
Rk10 (\6\:n4 \9\:n4) resistor r=0.1881 c=0
Rk3 (\5\:n0 \6\:n0) resistor r=0.7599 c=0
Rk4 (\5\:n0 \8\:n0) resistor r=0.3786 c=0
Rk6 (\4\:n1 \6\:n1) resistor r=0.4229 c=0
Rk7 (\6\:n1 \8\:n1) resistor r=0.5321 c=0
Rk11 (\4\:n2 \6\:n2) resistor r=1.2506 c=0
Rk12 (\6\:n2 \8\:n2) resistor r=0.4933 c=0
Rk13 (\4\:n3 \6\:n3) resistor r=0.4346 c=0
Rk14 (\6\:n3 \8\:n3) resistor r=0.7515 c=0
Rl9 (\2\:A \4\:A) resistor r=79.6488 c=0
Rl8 (\2\:A \3\:A) resistor r=37.3411 c=0
Rl7 (\1\:A \2\:A) resistor r=1.2334 c=0
Rl18 (\5\:VDD \6\:VDD) resistor r=98.7985 c=0
Rl13 (\3\:VDD \4\:VDD) resistor r=178.359 c=0
Rl5 (\1\:VDD \2\:VDD) resistor r=36.8016 c=0
Rl19 (\5\:VSS \6\:VSS) resistor r=53.1926 c=0
Rl12 (\3\:VSS \4\:VSS) resistor r=24.2328 c=0
Rl6 (\1\:VSS \2\:VSS) resistor r=66.5405 c=0
Rl1 (n4 \2\:n4) resistor r=67.9995 c=0
Rl2 (\2\:n4 \3\:n4) resistor r=56.461 c=0
Rl3 (n0 \2\:n0) resistor r=24.7951 c=0
Rl4 (\2\:n0 \3\:n0) resistor r=176.9 c=0
Rl10 (n1 \2\:n1) resistor r=126.923 c=0
Rl11 (\2\:n1 \3\:n1) resistor r=26.1559 c=0
Rl16 (n2 \2\:n2) resistor r=238.027 c=0
Rl17 (\2\:n2 \3\:n2) resistor r=24.2328 c=0
Rl14 (n3 \2\:n3) resistor r=49.2328 c=0
Rl15 (\2\:n3 \3\:n3) resistor r=149.233 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz10 (\11\:VDD \12\:VDD) resistor r=8.3333 c=0
Rz11 (\11\:VDD \14\:VDD) resistor r=9.375 c=0
Rz7 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz8 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz9 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz4 (\4\:n4 \5\:n4) resistor r=75 c=0
Rz2 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz3 (\5\:n1 \6\:n1) resistor r=75 c=0
Rz5 (\5\:n2 \6\:n2) resistor r=75 c=0
Rz6 (\7\:n3 \8\:n3) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=31 c=0
Ry10 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry11 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry12 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry7 (\8\:VSS \9\:VSS) resistor r=20.6667 c=0
Ry8 (\8\:VSS \11\:VSS) resistor r=15.5 c=0
Ry9 (\8\:VSS \14\:VSS) resistor r=6.2 c=0
Ry4 (\8\:n4 \9\:n4) resistor r=62 c=0
Ry2 (\4\:n0 \5\:n0) resistor r=62 c=0
Ry3 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry5 (\7\:n2 \8\:n2) resistor r=62 c=0
Ry6 (\5\:n3 \6\:n3) resistor r=62 c=0
Rx2 (\1\:A \5\:A) resistor r=45 c=0
Rx10 (\6\:VDD \7\:VDD) resistor r=45 c=0
Rx11 (\4\:VDD \16\:VDD) resistor r=45 c=0
Rx12 (\2\:VDD \21\:VDD) resistor r=45 c=0
Rx7 (\5\:VSS \7\:VSS) resistor r=45 c=0
Rx8 (\4\:VSS \18\:VSS) resistor r=45 c=0
Rx9 (\2\:VSS \21\:VSS) resistor r=45 c=0
Rx4 (\2\:n4 \7\:n4) resistor r=45 c=0
Rx1 (\2\:n0 \6\:n0) resistor r=45 c=0
Rx3 (\3\:n1 \4\:n1) resistor r=45 c=0
Rx5 (\3\:n2 \4\:n2) resistor r=45 c=0
Rx6 (\2\:n3 \4\:n3) resistor r=45 c=0
mn8 (\3\:Y \3\:n4 \22\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=3.64e-14 ps=8.6e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.59712e-07 sd=160n sca=13.198 \
        scb=0.0131159 scc=0.000803647 m=(1)
mn1 (n6 \3\:n0 \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=2.683e-14 ps=8.6e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=5.3e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn2 (\5\:n1 \1\:VDD n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.683e-14 ad=4.35e-14 ps=6.6e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=3e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn0 (\7\:n0 \3\:A \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.205e-14 ad=2.03e-14 ps=1.74e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn3 (n8 \2\:n1 \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.205e-14 ad=3.48e-14 ps=1.74e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=4.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn4 (\5\:n2 \3\:VDD n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.03e-14 ps=7.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn7 (\4\:n4 \3\:n3 \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.408e-14 ad=3.335e-14 ps=7.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.3e-07 sb=7.05e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn5 (n10 \2\:n2 \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.408e-14 ad=1.958e-14 ps=7.6e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=4.25e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mn6 (\7\:n3 \5\:VDD n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=3.553e-14 ps=5.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=2.45e-07 sd=160n sca=16.7245 \
        scb=0.0178071 scc=0.00133148 m=(1)
mp1 (n7 n0 \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.008e-14 ad=2.473e-14 ps=1.39e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=3e-07 sd=160n sca=17.9735 scb=0.0174913 \
        scc=0.0013169 m=(1)
mp2 (\7\:n1 \1\:VSS n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=3.01e-14 ps=6.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.5e-07 sb=1.4e-07 sd=160n sca=17.5155 \
        scb=0.0173077 scc=0.00131683 m=(1)
mp0 (\4\:n0 \4\:A \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.83e-14 ad=3.01e-14 ps=1.72e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.1e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp3 (n9 n1 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.83e-14 ad=1.29e-14 ps=1.72e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2.45e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp4 (\7\:n2 \3\:VSS n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.4e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp7 (\8\:n4 n3 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=10.4732 \
        scb=0.00744141 scc=7.36981e-05 m=(1)
mp5 (n11 n2 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=11.3694 \
        scb=0.00808912 scc=7.45876e-05 m=(1)
mp6 (\5\:n3 \6\:VSS n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.2441 \
        scb=0.00918936 scc=7.99464e-05 m=(1)
ends DLY2X1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:40:54 2012 )
// Library name: gsclib045
// Cell name: DLY2X4
// View name: extracted

simulator lang=spectre

subckt DLY2X4 A VDD VSS Y
mp8 (Y \2\:n4 \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.737e-14 ad=6.24e-14 ps=1.1625e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.03615e-06 sd=160n sca=26.8544 \
        scb=0.027116 scc=0.00215592 m=(4)
C1 (A VSS) capacitor c=3.71468e-17
C2 (Y VSS) capacitor c=3.37758e-16
C3 (VDD VSS) capacitor c=2.2425e-16
C4 (n4 VSS) capacitor c=2.78573e-17
C5 (n0 VSS) capacitor c=3.74454e-17
C6 (n1 VSS) capacitor c=9.30698e-17
C7 (n8 VSS) capacitor c=1.61637e-18
C8 (n2 VSS) capacitor c=9.78491e-17
C9 (n3 VSS) capacitor c=6.48898e-17
C10 (n10 VSS) capacitor c=1.37378e-18
C11 (n7 VSS) capacitor c=1.68372e-18
C12 (n11 VSS) capacitor c=2.16144e-18
C13 (\3\:n3 VSS) capacitor c=5.04543e-17
C14 (\4\:A VSS) capacitor c=3.33919e-17
C15 (\5\:VDD VSS) capacitor c=5.02304e-17
C16 (\2\:n2 VSS) capacitor c=5.82691e-17
C17 (\3\:VDD VSS) capacitor c=3.94838e-17
C18 (\2\:n1 VSS) capacitor c=2.66143e-17
C19 (\3\:A VSS) capacitor c=3.72041e-17
C20 (\1\:VDD VSS) capacitor c=4.11937e-17
C21 (\3\:n0 VSS) capacitor c=5.48783e-17
C22 (\6\:VDD VSS) capacitor c=5.15102e-17
C23 (\3\:n2 VSS) capacitor c=3.04328e-17
C24 (\2\:n3 VSS) capacitor c=4.59485e-17
C25 (\4\:VDD VSS) capacitor c=4.67804e-17
C26 (\3\:n1 VSS) capacitor c=2.2835e-17
C27 (\1\:A VSS) capacitor c=1.77485e-17
C28 (\2\:VDD VSS) capacitor c=4.37895e-17
C29 (\2\:n0 VSS) capacitor c=6.51048e-17
C30 (\6\:n3 VSS) capacitor c=9.98707e-17
C31 (\9\:VDD VSS) capacitor c=6.42345e-17
C32 (\17\:n4 VSS) capacitor c=2.40255e-16
C33 (\7\:n2 VSS) capacitor c=9.5508e-17
C34 (\23\:VDD VSS) capacitor c=1.47993e-17
C35 (\4\:n0 VSS) capacitor c=1.72597e-19
C36 (\7\:n1 VSS) capacitor c=1.02879e-16
C37 (\12\:VDD VSS) capacitor c=1.25859e-16
C38 (\4\:n3 VSS) capacitor c=9.15425e-17
C39 (\15\:n4 VSS) capacitor c=1.20675e-16
C40 (\5\:n2 VSS) capacitor c=1.90839e-16
C41 (\6\:n0 VSS) capacitor c=6.59733e-17
C42 (\5\:n1 VSS) capacitor c=1.12686e-16
C43 (\2\:n4 VSS) capacitor c=2.33826e-16
C44 (\2\:A VSS) capacitor c=1.49746e-17
C45 (\5\:n0 VSS) capacitor c=1.54935e-16
C46 (\8\:n0 VSS) capacitor c=1.07078e-16
C47 (\5\:A VSS) capacitor c=7.06216e-17
C48 (\4\:n1 VSS) capacitor c=5.93285e-17
C49 (\19\:n4 VSS) capacitor c=2.4207e-16
C50 (\4\:n2 VSS) capacitor c=1.58221e-16
C51 (\8\:n3 VSS) capacitor c=7.17008e-17
C52 (\7\:VDD VSS) capacitor c=6.25269e-17
C53 (\8\:VDD VSS) capacitor c=9.47249e-17
C54 (\14\:VDD VSS) capacitor c=1.03251e-17
C55 (\16\:VDD VSS) capacitor c=3.13534e-16
C56 (\27\:VDD VSS) capacitor c=9.53397e-17
Rk9 (A \5\:A) resistor r=0.1424 c=0
Rk38 (\7\:VDD \8\:VDD) resistor r=0.4079 c=0
Rk39 (\8\:VDD \10\:VDD) resistor r=0.4547 c=0
Rk40 (\10\:VDD \11\:VDD) resistor r=0.1878 c=0
Rk41 (\11\:VDD \13\:VDD) resistor r=0.2205 c=0
Rk42 (\13\:VDD \14\:VDD) resistor r=0.2306 c=0
Rk43 (\14\:VDD \15\:VDD) resistor r=0.2707 c=0
Rk49 (\16\:VDD VDD) resistor r=0.0447 c=0
Rk44 (\15\:VDD \16\:VDD) resistor r=0.3184 c=0
Rk51 (\11\:VDD \22\:VDD) resistor r=0.2306 c=0
Rk52 (\14\:VDD \24\:VDD) resistor r=0.07405 c=0
Rk54 (\16\:VDD \27\:VDD) resistor r=0.8613 c=0
Rk18 (\7\:VSS \9\:VSS) resistor r=0.8509 c=0
Rk19 (\9\:VSS \10\:VSS) resistor r=0.1704 c=0
Rk20 (\10\:VSS \11\:VSS) resistor r=0.431 c=0
Rk21 (\11\:VSS \12\:VSS) resistor r=0.1001 c=0
Rk22 (\12\:VSS \13\:VSS) resistor r=0.1142 c=0
Rk23 (\13\:VSS \14\:VSS) resistor r=0.262 c=0
Rk29 (\15\:VSS VSS) resistor r=0.0447 c=0
Rk24 (\14\:VSS \15\:VSS) resistor r=0.2178 c=0
Rk31 (\10\:VSS \22\:VSS) resistor r=0.2972 c=0
Rk32 (\11\:VSS \23\:VSS) resistor r=0.6852 c=0
Rk33 (\13\:VSS \25\:VSS) resistor r=0.04332 c=0
Rk34 (\14\:VSS \26\:VSS) resistor r=0.5703 c=0
Rk12 (\16\:n4 \18\:n4) resistor r=0.6454 c=0
Rk13 (\18\:n4 \19\:n4) resistor r=1.6567 c=0
Rk7 (\5\:n0 \7\:n0) resistor r=0.3857 c=0
Rk8 (\5\:n0 \8\:n0) resistor r=0.753 c=0
Rk10 (\4\:n1 \6\:n1) resistor r=0.4203 c=0
Rk11 (\6\:n1 \8\:n1) resistor r=0.5313 c=0
Rk14 (\4\:n2 \6\:n2) resistor r=1.1301 c=0
Rk15 (\6\:n2 \8\:n2) resistor r=0.5162 c=0
Rk16 (\5\:n3 \7\:n3) resistor r=0.7346 c=0
Rk17 (\7\:n3 \8\:n3) resistor r=0.423 c=0
Rl20 (\2\:A \4\:A) resistor r=37.3411 c=0
Rl19 (\2\:A \3\:A) resistor r=87.3411 c=0
Rl18 (\1\:A \2\:A) resistor r=1.2334 c=0
Rl30 (\6\:VDD \5\:VDD) resistor r=117.762 c=0
Rl24 (\4\:VDD \3\:VDD) resistor r=189.898 c=0
Rl16 (\2\:VDD \1\:VDD) resistor r=36.8016 c=0
Rl27 (\6\:VSS \5\:VSS) resistor r=24.2328 c=0
Rl23 (\4\:VSS \3\:VSS) resistor r=29.5379 c=0
Rl17 (\1\:VSS \2\:VSS) resistor r=61.8673 c=0
Rl1 (\2\:n4 n4) resistor r=4.1279 c=0
Rl14 (n0 \2\:n0) resistor r=24.7951 c=0
Rl15 (\2\:n0 \3\:n0) resistor r=119.208 c=0
Rl21 (n1 \2\:n1) resistor r=134.615 c=0
Rl22 (\2\:n1 \3\:n1) resistor r=26.1559 c=0
Rl28 (n2 \2\:n2) resistor r=236.104 c=0
Rl29 (\2\:n2 \3\:n2) resistor r=24.2328 c=0
Rl25 (n3 \2\:n3) resistor r=117.559 c=0
Rl26 (\2\:n3 \3\:n3) resistor r=113.016 c=0
Rz17 (VDD \12\:VDD) resistor r=75 c=0
Rz13 (\13\:VDD \12\:VDD) resistor r=18.75 c=0
Rz14 (\15\:VDD \12\:VDD) resistor r=12.5 c=0
Rz15 (\16\:VDD \12\:VDD) resistor r=18.75 c=0
Rz18 (\22\:VDD \12\:VDD) resistor r=15 c=0
Rz8 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz9 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz5 (\16\:n4 \15\:n4) resistor r=75 c=0
Rz3 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz4 (\5\:n1 \6\:n1) resistor r=75 c=0
Rz6 (\5\:n2 \6\:n2) resistor r=75 c=0
Rz7 (\4\:n3 \5\:n3) resistor r=75 c=0
Ry13 (\10\:VDD \9\:VDD) resistor r=62 c=0
Ry14 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry12 (VSS \8\:VSS) resistor r=62 c=0
Ry8 (\9\:VSS \8\:VSS) resistor r=20.6667 c=0
Ry9 (\12\:VSS \8\:VSS) resistor r=5.6364 c=0
Ry11 (\15\:VSS \8\:VSS) resistor r=12.4 c=0
Ry5 (\18\:n4 \17\:n4) resistor r=20.6667 c=0
Ry3 (\4\:n0 \5\:n0) resistor r=62 c=0
Ry4 (\7\:n1 \8\:n1) resistor r=62 c=0
Ry6 (\7\:n2 \8\:n2) resistor r=62 c=0
Ry7 (\6\:n3 \7\:n3) resistor r=62 c=0
Rx2 (\1\:A \5\:A) resistor r=45 c=0
Rx10 (\7\:VDD \6\:VDD) resistor r=45 c=0
Rx11 (\8\:VDD \4\:VDD) resistor r=45 c=0
Rx12 (\27\:VDD \2\:VDD) resistor r=45 c=0
Rx7 (\7\:VSS \6\:VSS) resistor r=45 c=0
Rx8 (\23\:VSS \4\:VSS) resistor r=45 c=0
Rx9 (\26\:VSS \1\:VSS) resistor r=45 c=0
Rx4 (\19\:n4 n4) resistor r=45 c=0
Rx1 (\2\:n0 \8\:n0) resistor r=45 c=0
Rx3 (\3\:n1 \4\:n1) resistor r=45 c=0
Rx5 (\3\:n2 \4\:n2) resistor r=45 c=0
Rx6 (\2\:n3 \8\:n3) resistor r=45 c=0
mn8 (Y \2\:n4 \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.857e-14 ad=5.46e-14 ps=8.3e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.16913e-06 sd=160n sca=13.198 \
        scb=0.0131159 scc=0.000803647 m=(4)
mn1 (n6 \3\:n0 \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.682e-14 ps=8.4e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=5.3e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn2 (\5\:n1 \1\:VDD n6 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=4.35e-14 ps=6.6e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.29e-06 sb=3e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn0 (\6\:n0 \3\:A \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.205e-14 ad=2.03e-14 ps=1.74e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn3 (n8 \2\:n1 \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.205e-14 ad=3.48e-14 ps=1.74e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=4.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn4 (\5\:n2 \3\:VDD n8 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.03e-14 ps=7.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn7 (\15\:n4 n3 \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.717e-14 ad=4.68e-14 ps=1.15e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=4.82019e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn5 (n10 \2\:n2 \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.717e-14 ad=1.957e-14 ps=1.15e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=4.25e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn6 (\4\:n3 \5\:VDD n10 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=3.552e-14 ps=5.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=2.45e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mp1 (n7 n0 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.008e-14 ad=2.472e-14 ps=1.39e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.105e-06 sb=3e-07 sd=160n sca=27.1298 scb=0.023603 \
        scc=0.0032399 m=(1)
mp2 (\7\:n1 \2\:VSS n7 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.473e-14 ad=3.01e-14 ps=6.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.265e-06 sb=1.4e-07 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp0 (\4\:n0 \4\:A \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.59e-14 ad=3.01e-14 ps=1.68e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.1e-07 sd=160n sca=16.925 scb=0.0168124 \
        scc=0.00121732 m=(1)
mp3 (n9 n1 \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.59e-14 ad=1.29e-14 ps=1.68e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2.45e-07 sd=160n sca=16.925 \
        scb=0.0168124 scc=0.00121732 m=(1)
mp4 (\7\:n2 \3\:VSS n9 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.4e-07 sd=160n sca=16.925 scb=0.0168124 \
        scc=0.00121732 m=(1)
mp7 (\17\:n4 \3\:n3 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1468e-13 ad=5.46e-14 ps=1.63e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5391e-07 sd=160n sca=11.7201 \
        scb=0.00999512 scc=0.000291798 m=(1)
mp5 (n11 n2 \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1468e-13 ad=1.29e-14 ps=1.63e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=2.45e-07 sd=160n sca=13.1834 \
        scb=0.0111853 scc=0.000283211 m=(1)
mp6 (\6\:n3 \5\:VSS n11 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=1.4e-07 sd=160n sca=14.1736 \
        scb=0.0125294 scc=0.000291648 m=(1)
ends DLY2X4
// End of subcircuit definition.

// Generated for: spectre (May  9 14:41:32 2012 )
// Library name: gsclib045
// Cell name: DLY3X1
// View name: extracted

simulator lang=spectre

subckt DLY3X1 A VDD VSS Y
mp2 (\9\:n1 \1\:VSS n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.55e-07 sd=160n sca=22.1455 \
        scb=0.0211116 scc=0.00193954 m=(1)
C1 (Y VSS) capacitor c=4.10046e-17
C2 (A VSS) capacitor c=5.12649e-17
C3 (VDD VSS) capacitor c=2.61534e-16
C4 (n1 VSS) capacitor c=3.71813e-17
C5 (n0 VSS) capacitor c=3.67104e-17
C6 (n2 VSS) capacitor c=3.57847e-17
C7 (n11 VSS) capacitor c=1.53359e-18
C8 (n3 VSS) capacitor c=9.48685e-17
C9 (n6 VSS) capacitor c=2.42278e-17
C10 (n13 VSS) capacitor c=4.72305e-18
C11 (n4 VSS) capacitor c=1.02778e-16
C12 (n5 VSS) capacitor c=4.56936e-17
C13 (n15 VSS) capacitor c=1.41579e-18
C14 (n8 VSS) capacitor c=1.53039e-18
C15 (n10 VSS) capacitor c=3.20763e-18
C16 (n12 VSS) capacitor c=2.28512e-18
C17 (n14 VSS) capacitor c=6.09855e-19
C18 (n16 VSS) capacitor c=1.92136e-18
C19 (\3\:n5 VSS) capacitor c=2.54372e-17
C20 (\4\:n6 VSS) capacitor c=4.33699e-17
C21 (\3\:n2 VSS) capacitor c=7.84319e-17
C22 (\1\:A VSS) capacitor c=2.89271e-17
C23 (\2\:n0 VSS) capacitor c=1.32653e-16
C24 (\9\:VDD VSS) capacitor c=5.26711e-17
C25 (\2\:n4 VSS) capacitor c=6.79408e-17
C26 (\7\:VDD VSS) capacitor c=3.72789e-17
C27 (\2\:n3 VSS) capacitor c=2.67652e-17
C28 (\3\:n6 VSS) capacitor c=3.71807e-17
C29 (\5\:VDD VSS) capacitor c=3.74578e-17
C30 (\2\:n2 VSS) capacitor c=4.63289e-17
C31 (\3\:A VSS) capacitor c=4.02008e-17
C32 (\3\:VDD VSS) capacitor c=3.64245e-17
C33 (\4\:n1 VSS) capacitor c=5.88131e-17
C34 (\3\:n0 VSS) capacitor c=9.84475e-17
C35 (\1\:VDD VSS) capacitor c=5.44872e-17
C36 (\10\:VDD VSS) capacitor c=4.79142e-17
C37 (\3\:n4 VSS) capacitor c=3.35552e-17
C38 (\2\:n5 VSS) capacitor c=6.08236e-17
C39 (\8\:VDD VSS) capacitor c=4.61171e-17
C40 (\3\:n3 VSS) capacitor c=2.18895e-17
C41 (\6\:VDD VSS) capacitor c=4.78103e-17
C42 (\2\:A VSS) capacitor c=4.1006e-17
C43 (\4\:VDD VSS) capacitor c=3.94307e-17
C44 (\3\:n1 VSS) capacitor c=2.37854e-17
C45 (\2\:VDD VSS) capacitor c=5.18378e-17
C46 (\6\:n5 VSS) capacitor c=1.00307e-16
C47 (\16\:VDD VSS) capacitor c=2.48785e-17
C48 (\6\:n6 VSS) capacitor c=1.27318e-16
C49 (\7\:n4 VSS) capacitor c=8.91117e-17
C50 (\20\:VDD VSS) capacitor c=3.46178e-17
C51 (\1\:Y VSS) capacitor c=6.69143e-17
C52 (\7\:n3 VSS) capacitor c=8.87836e-17
C53 (\27\:VDD VSS) capacitor c=3.99147e-17
C54 (\6\:n0 VSS) capacitor c=1.25035e-16
C55 (\4\:n2 VSS) capacitor c=8.90129e-17
C56 (\31\:VDD VSS) capacitor c=1.97326e-17
C57 (\9\:n1 VSS) capacitor c=7.74017e-18
C58 (\11\:VDD VSS) capacitor c=3.5995e-17
C59 (\4\:n5 VSS) capacitor c=1.02072e-16
C60 (\8\:n6 VSS) capacitor c=1.15222e-16
C61 (\5\:n4 VSS) capacitor c=2.24146e-16
C62 (\3\:Y VSS) capacitor c=5.7031e-17
C63 (\5\:n3 VSS) capacitor c=1.97268e-16
C64 (\4\:n0 VSS) capacitor c=1.18073e-16
C65 (\6\:n2 VSS) capacitor c=1.94263e-16
C66 (\7\:n1 VSS) capacitor c=8.38303e-17
C67 (\2\:n1 VSS) capacitor c=4.12773e-17
C68 (\2\:n6 VSS) capacitor c=1.17089e-17
C69 (\5\:n1 VSS) capacitor c=5.33682e-17
C70 (\6\:n1 VSS) capacitor c=7.77708e-17
C71 (\8\:n0 VSS) capacitor c=6.01637e-17
C72 (\4\:A VSS) capacitor c=7.89702e-17
C73 (\8\:n2 VSS) capacitor c=1.33511e-16
C74 (\4\:n3 VSS) capacitor c=1.26249e-16
C75 (\5\:n6 VSS) capacitor c=9.56018e-17
C76 (\4\:n4 VSS) capacitor c=1.90762e-16
C77 (\8\:n5 VSS) capacitor c=7.26858e-17
C78 (\13\:VDD VSS) capacitor c=5.17444e-18
C79 (\14\:VDD VSS) capacitor c=5.95199e-18
C80 (\15\:VDD VSS) capacitor c=1.3452e-16
C81 (\19\:VDD VSS) capacitor c=2.29484e-17
C82 (\22\:VDD VSS) capacitor c=7.20208e-17
C83 (\23\:VDD VSS) capacitor c=2.19698e-17
C84 (\24\:VDD VSS) capacitor c=1.02773e-16
C85 (\26\:VDD VSS) capacitor c=2.36851e-17
C86 (\29\:VDD VSS) capacitor c=2.44573e-17
C87 (\30\:VDD VSS) capacitor c=5.88353e-17
C88 (\34\:VDD VSS) capacitor c=7.97553e-17
C89 (\35\:VDD VSS) capacitor c=5.50135e-17
Rk19 (\11\:VSS \13\:VSS) resistor r=0.9621 c=0
Rk20 (\13\:VSS \14\:VSS) resistor r=0.3385 c=0
Rk21 (\14\:VSS \15\:VSS) resistor r=0.1903 c=0
Rk22 (\15\:VSS \16\:VSS) resistor r=0.3737 c=0
Rk23 (\16\:VSS \17\:VSS) resistor r=0.2261 c=0
Rk24 (\17\:VSS \18\:VSS) resistor r=0.3408 c=0
Rk25 (\18\:VSS \19\:VSS) resistor r=0.08511 c=0
Rk26 (\19\:VSS \20\:VSS) resistor r=0.1202 c=0
Rk27 (\20\:VSS \21\:VSS) resistor r=0.1805 c=0
Rk29 (\22\:VSS VSS) resistor r=0.1125 c=0
Rk28 (\21\:VSS \22\:VSS) resistor r=0.03744 c=0
Rk30 (\13\:VSS \24\:VSS) resistor r=0.32 c=0
Rk31 (\14\:VSS \25\:VSS) resistor r=0.6302 c=0
Rk32 (\15\:VSS \27\:VSS) resistor r=0.3005 c=0
Rk33 (\16\:VSS \28\:VSS) resistor r=0.705 c=0
Rk34 (\17\:VSS \30\:VSS) resistor r=0.3079 c=0
Rk35 (\18\:VSS \31\:VSS) resistor r=0.5831 c=0
Rk36 (\20\:VSS \33\:VSS) resistor r=0.185 c=0
Rk37 (\22\:VSS \34\:VSS) resistor r=0.7146 c=0
Rk9 (\2\:Y Y) resistor r=0.2502 c=0
Rk10 (Y \4\:Y) resistor r=0.2028 c=0
Rk6 (A \4\:A) resistor r=0.0194 c=0
Rk38 (\12\:VDD \13\:VDD) resistor r=0.1278 c=0
Rk39 (\13\:VDD \14\:VDD) resistor r=0.12 c=0
Rk40 (\14\:VDD \15\:VDD) resistor r=0.6978 c=0
Rk41 (\13\:VDD \17\:VDD) resistor r=0.3509 c=0
Rk42 (\14\:VDD \18\:VDD) resistor r=0.1529 c=0
Rk43 (\18\:VDD \19\:VDD) resistor r=0.2532 c=0
Rk44 (\19\:VDD \21\:VDD) resistor r=0.2988 c=0
Rk45 (\15\:VDD \22\:VDD) resistor r=0.3658 c=0
Rk46 (\19\:VDD \23\:VDD) resistor r=0.5165 c=0
Rk47 (\23\:VDD \24\:VDD) resistor r=0.6347 c=0
Rk48 (\23\:VDD \25\:VDD) resistor r=0.03242 c=0
Rk49 (\25\:VDD \26\:VDD) resistor r=0.07508 c=0
Rk50 (\26\:VDD \28\:VDD) resistor r=0.3538 c=0
Rk51 (\26\:VDD \29\:VDD) resistor r=0.519 c=0
Rk52 (\29\:VDD \30\:VDD) resistor r=0.3312 c=0
Rk53 (\30\:VDD \32\:VDD) resistor r=0.05479 c=0
Rk55 (\33\:VDD VDD) resistor r=0.1503 c=0
Rk54 (\29\:VDD \33\:VDD) resistor r=0.2081 c=0
Rk56 (\30\:VDD \34\:VDD) resistor r=0.4901 c=0
Rk57 (\34\:VDD \35\:VDD) resistor r=0.3549 c=0
Rk1 (\5\:n1 \6\:n1) resistor r=0.3194 c=0
Rk2 (\6\:n1 \8\:n1) resistor r=0.6819 c=0
Rk3 (\6\:n1 \10\:n1) resistor r=0.02809 c=0
Rk4 (\5\:n0 \7\:n0) resistor r=0.6105 c=0
Rk5 (\7\:n0 \8\:n0) resistor r=0.5443 c=0
Rk7 (\5\:n2 \7\:n2) resistor r=0.5746 c=0
Rk8 (\7\:n2 \8\:n2) resistor r=0.9837 c=0
Rk11 (\4\:n3 \6\:n3) resistor r=0.9337 c=0
Rk12 (\6\:n3 \8\:n3) resistor r=0.7382 c=0
Rk13 (\5\:n6 \7\:n6) resistor r=0.7079 c=0
Rk14 (\7\:n6 \9\:n6) resistor r=0.6169 c=0
Rk15 (\4\:n4 \6\:n4) resistor r=1.3173 c=0
Rk16 (\6\:n4 \8\:n4) resistor r=0.5008 c=0
Rk17 (\5\:n5 \7\:n5) resistor r=0.7564 c=0
Rk18 (\7\:n5 \8\:n5) resistor r=0.4045 c=0
Rl28 (\9\:VSS \10\:VSS) resistor r=39.7311 c=0
Rl21 (\7\:VSS \8\:VSS) resistor r=31.9251 c=0
Rl15 (\5\:VSS \6\:VSS) resistor r=89.8977 c=0
Rl9 (\3\:VSS \4\:VSS) resistor r=71.8456 c=0
Rl1 (\1\:VSS \2\:VSS) resistor r=49.2328 c=0
Rl10 (\1\:A \2\:A) resistor r=24.2328 c=0
Rl11 (\2\:A \3\:A) resistor r=156.925 c=0
Rl27 (\9\:VDD \10\:VDD) resistor r=91.2131 c=0
Rl22 (\7\:VDD \8\:VDD) resistor r=196.875 c=0
Rl14 (\5\:VDD \6\:VDD) resistor r=103.359 c=0
Rl8 (\3\:VDD \4\:VDD) resistor r=87.6944 c=0
Rl2 (\1\:VDD \2\:VDD) resistor r=87.6944 c=0
Rl3 (n1 \2\:n1) resistor r=34.3295 c=0
Rl5 (\2\:n1 \4\:n1) resistor r=184.329 c=0
Rl4 (\2\:n1 \3\:n1) resistor r=2.0166 c=0
Rl6 (n0 \2\:n0) resistor r=189.898 c=0
Rl7 (\2\:n0 \3\:n0) resistor r=226.923 c=0
Rl12 (n2 \2\:n2) resistor r=36.2715 c=0
Rl13 (\2\:n2 \3\:n2) resistor r=209.615 c=0
Rl19 (n3 \2\:n3) resistor r=134.615 c=0
Rl20 (\2\:n3 \3\:n3) resistor r=24.2328 c=0
Rl16 (n6 \2\:n6) resistor r=12.8731 c=0
Rl18 (\2\:n6 \4\:n6) resistor r=22.3936 c=0
Rl17 (\2\:n6 \3\:n6) resistor r=65.8358 c=0
Rl25 (n4 \2\:n4) resistor r=214.045 c=0
Rl26 (\2\:n4 \3\:n4) resistor r=35.7713 c=0
Rl23 (n5 \2\:n5) resistor r=152.174 c=0
Rl24 (\2\:n5 \3\:n5) resistor r=51.2624 c=0
Rz9 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz10 (\26\:VSS \27\:VSS) resistor r=75 c=0
Rz11 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz12 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz4 (\3\:Y \4\:Y) resistor r=75 c=0
Rz13 (\11\:VDD \12\:VDD) resistor r=18.75 c=0
Rz14 (\11\:VDD \18\:VDD) resistor r=18.75 c=0
Rz15 (\11\:VDD \25\:VDD) resistor r=6.25 c=0
Rz16 (\11\:VDD \33\:VDD) resistor r=18.75 c=0
Rz1 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz3 (\6\:n2 \7\:n2) resistor r=75 c=0
Rz5 (\5\:n3 \6\:n3) resistor r=75 c=0
Rz6 (\8\:n6 \9\:n6) resistor r=75 c=0
Rz7 (\5\:n4 \6\:n4) resistor r=75 c=0
Rz8 (\4\:n5 \5\:n5) resistor r=75 c=0
Ry9 (\12\:VSS \13\:VSS) resistor r=8.8571 c=0
Ry10 (\12\:VSS \16\:VSS) resistor r=5.6364 c=0
Ry11 (\12\:VSS \19\:VSS) resistor r=31 c=0
Ry12 (\12\:VSS \21\:VSS) resistor r=15.5 c=0
Ry4 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry13 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry14 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry15 (\27\:VDD \28\:VDD) resistor r=62 c=0
Ry16 (\31\:VDD \32\:VDD) resistor r=62 c=0
Ry1 (\9\:n1 \10\:n1) resistor r=62 c=0
Ry2 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\4\:n2 \5\:n2) resistor r=62 c=0
Ry5 (\7\:n3 \8\:n3) resistor r=62 c=0
Ry6 (\6\:n6 \7\:n6) resistor r=62 c=0
Ry7 (\7\:n4 \8\:n4) resistor r=62 c=0
Ry8 (\6\:n5 \7\:n5) resistor r=62 c=0
Rx9 (\9\:VSS \11\:VSS) resistor r=45 c=0
Rx10 (\8\:VSS \25\:VSS) resistor r=45 c=0
Rx11 (\5\:VSS \28\:VSS) resistor r=45 c=0
Rx12 (\4\:VSS \31\:VSS) resistor r=45 c=0
Rx13 (\2\:VSS \34\:VSS) resistor r=45 c=0
Rx3 (\2\:A \4\:A) resistor r=45 c=0
Rx14 (\8\:VDD \15\:VDD) resistor r=45 c=0
Rx15 (\10\:VDD \22\:VDD) resistor r=45 c=0
Rx16 (\6\:VDD \24\:VDD) resistor r=45 c=0
Rx17 (\4\:VDD \34\:VDD) resistor r=45 c=0
Rx18 (\2\:VDD \35\:VDD) resistor r=45 c=0
Rx1 (\3\:n1 \5\:n1) resistor r=45 c=0
Rx2 (n0 \8\:n0) resistor r=45 c=0
Rx4 (n2 \8\:n2) resistor r=45 c=0
Rx5 (\3\:n3 \4\:n3) resistor r=45 c=0
Rx6 (n6 \5\:n6) resistor r=45 c=0
Rx7 (\3\:n4 \4\:n4) resistor r=45 c=0
Rx8 (\2\:n5 \8\:n5) resistor r=45 c=0
mn2 (\7\:n1 \1\:VDD n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=6.163e-14 ps=4.1e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=8.15e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn1 (n7 \3\:n0 \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=7.1e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn3 (n9 \4\:n1 \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.175e-14 ps=6.1e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=5.05e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn4 (\6\:n2 \3\:VDD n9 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.175e-14 ad=4.495e-14 ps=5.9e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=3.1e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn0 (\4\:n0 \3\:A \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.698e-14 ps=6.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=7.35e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn5 (n11 \2\:n2 \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.682e-14 ps=6.1e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=5.3e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn6 (\5\:n3 \5\:VDD n11 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=4.35e-14 ps=6.6e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=3e-07 sd=160n sca=10.4914 scb=0.00978575 \
        scc=0.000300434 m=(1)
mn12 (\3\:Y \3\:n6 \26\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.725e-14 ad=7.28e-14 ps=1.01e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.8e-07 sb=4.43846e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn7 (n13 \2\:n3 \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.725e-14 ad=3.48e-14 ps=1.01e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=4.25e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn8 (\5\:n4 \7\:VDD n13 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.03e-14 ps=7.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (\8\:n6 n5 \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.567e-14 ps=6.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=6.2e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn10 (\4\:n5 \9\:VDD n15 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.812e-14 ad=3.552e-14 ps=5.4e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=2.45e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mn9 (n15 \2\:n4 \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=1.812e-14 ps=6.1e-07 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=4.15e-07 sd=160n sca=8.42104 \
        scb=0.00632542 scc=0.000106623 m=(1)
mp1 (n8 \2\:n0 \31\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.5e-07 sd=160n sca=21.4207 \
        scb=0.0203168 scc=0.00193696 m=(1)
mp3 (n10 n1 \31\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.913e-14 ps=7.5e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=5.45e-07 sd=160n sca=20.6521 \
        scb=0.0198557 scc=0.00193653 m=(1)
mp4 (\4\:n2 \3\:VSS n10 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.912e-14 ad=4.837e-14 ps=9.8e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=2.25e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp0 (\6\:n0 \1\:A \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.15e-07 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp5 (n12 \3\:n2 \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.687e-14 ps=7.5e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.1e-07 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp6 (\7\:n3 \6\:VSS n12 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.687e-14 ad=3.01e-14 ps=6.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.15e-07 sb=1.4e-07 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp12 (\1\:Y \4\:n6 \20\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.32949e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp7 (n14 n3 \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=1.505e-14 ps=1.16e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2.55e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp8 (\7\:n4 \7\:VSS n14 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=3.01e-14 ps=5.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp11 (\6\:n6 \3\:n5 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=7.847e-14 ps=7.5e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=4.5e-07 sd=160n sca=16.5775 \
        scb=0.0160907 scc=0.00103906 m=(1)
mp9 (n16 n4 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=2.45e-07 sd=160n sca=17.7492 \
        scb=0.0172065 scc=0.001042 m=(1)
mp10 (\6\:n5 \10\:VSS n16 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=1.4e-07 sd=160n sca=18.9703 \
        scb=0.0190477 scc=0.00105936 m=(1)
ends DLY3X1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:42:09 2012 )
// Library name: gsclib045
// Cell name: DLY3X4
// View name: extracted

simulator lang=spectre

subckt DLY3X4 A VDD VSS Y
mp2 (\9\:n1 \1\:VSS n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=3.01e-14 ps=7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.8e-07 sd=160n sca=23.8898 \
        scb=0.0257238 scc=0.00168255 m=(1)
C1 (A VSS) capacitor c=4.56851e-17
C2 (Y VSS) capacitor c=3.24807e-16
C3 (VDD VSS) capacitor c=2.50483e-16
C4 (n1 VSS) capacitor c=8.94527e-17
C5 (n0 VSS) capacitor c=3.88102e-17
C6 (n9 VSS) capacitor c=7.26019e-19
C7 (n2 VSS) capacitor c=5.91422e-17
C8 (n11 VSS) capacitor c=1.08923e-18
C9 (n3 VSS) capacitor c=7.54616e-17
C10 (n6 VSS) capacitor c=2.32627e-16
C11 (n13 VSS) capacitor c=4.85131e-18
C12 (n4 VSS) capacitor c=9.86262e-17
C13 (n5 VSS) capacitor c=4.78408e-17
C14 (n15 VSS) capacitor c=1.91808e-19
C15 (n8 VSS) capacitor c=3.4105e-18
C16 (n10 VSS) capacitor c=1.46957e-18
C17 (n12 VSS) capacitor c=2.47056e-18
C18 (\3\:n5 VSS) capacitor c=5.1724e-17
C19 (\4\:A VSS) capacitor c=3.64612e-17
C20 (\4\:n1 VSS) capacitor c=3.94724e-17
C21 (\2\:n0 VSS) capacitor c=1.13808e-16
C22 (\9\:VDD VSS) capacitor c=4.46716e-17
C23 (\2\:n4 VSS) capacitor c=5.45746e-17
C24 (\7\:VDD VSS) capacitor c=4.56825e-17
C25 (\2\:n3 VSS) capacitor c=2.19398e-17
C26 (\5\:VDD VSS) capacitor c=5.85297e-17
C27 (\2\:n2 VSS) capacitor c=5.62013e-17
C28 (\3\:A VSS) capacitor c=3.19362e-17
C29 (\3\:VDD VSS) capacitor c=5.69493e-17
C30 (\3\:n0 VSS) capacitor c=9.85849e-17
C31 (\1\:VDD VSS) capacitor c=5.50197e-17
C32 (\10\:VDD VSS) capacitor c=4.89856e-17
C33 (\3\:n4 VSS) capacitor c=3.21122e-17
C34 (\4\:n5 VSS) capacitor c=3.31204e-17
C35 (\8\:VDD VSS) capacitor c=4.86255e-17
C36 (\3\:n3 VSS) capacitor c=2.03476e-17
C37 (\9\:n6 VSS) capacitor c=1.65895e-17
C38 (\6\:VDD VSS) capacitor c=4.62653e-17
C39 (\3\:n2 VSS) capacitor c=2.94009e-17
C40 (\1\:A VSS) capacitor c=2.36839e-17
C41 (\4\:VDD VSS) capacitor c=4.21249e-17
C42 (\3\:n1 VSS) capacitor c=2.71632e-17
C43 (\2\:VDD VSS) capacitor c=4.32844e-17
C44 (\7\:n5 VSS) capacitor c=9.8294e-17
C45 (\13\:VDD VSS) capacitor c=4.42208e-17
C46 (\16\:n6 VSS) capacitor c=1.49801e-16
C47 (\7\:n4 VSS) capacitor c=1.02007e-16
C48 (\8\:n3 VSS) capacitor c=5.89257e-17
C49 (\34\:VDD VSS) capacitor c=4.20985e-17
C50 (\6\:n0 VSS) capacitor c=1.07642e-16
C51 (\8\:n2 VSS) capacitor c=8.37545e-17
C52 (\36\:VDD VSS) capacitor c=8.02967e-17
C53 (\9\:n1 VSS) capacitor c=1.8238e-17
C54 (\15\:VDD VSS) capacitor c=9.88915e-17
C55 (\5\:n5 VSS) capacitor c=8.78149e-17
C56 (\18\:n6 VSS) capacitor c=1.03651e-16
C57 (\5\:n4 VSS) capacitor c=2.02659e-16
C58 (\6\:n3 VSS) capacitor c=2.9325e-17
C59 (\4\:n0 VSS) capacitor c=7.29379e-17
C60 (\6\:n2 VSS) capacitor c=4.30428e-17
C61 (\7\:n1 VSS) capacitor c=6.33075e-17
C62 (\2\:n1 VSS) capacitor c=4.62908e-17
C63 (\2\:A VSS) capacitor c=1.85453e-17
C64 (\2\:n5 VSS) capacitor c=2.76898e-17
C65 (\5\:n1 VSS) capacitor c=7.25825e-17
C66 (\6\:n1 VSS) capacitor c=6.39754e-17
C67 (\8\:n0 VSS) capacitor c=7.01875e-17
C68 (\5\:A VSS) capacitor c=6.84647e-17
C69 (\4\:n2 VSS) capacitor c=5.57005e-17
C70 (\5\:n2 VSS) capacitor c=8.85053e-17
C71 (\4\:n3 VSS) capacitor c=2.11777e-16
C72 (\5\:n3 VSS) capacitor c=1.94228e-16
C73 (\15\:n6 VSS) capacitor c=1.25528e-16
C74 (\4\:n4 VSS) capacitor c=1.45012e-16
C75 (\9\:n5 VSS) capacitor c=6.14507e-17
C76 (\11\:VDD VSS) capacitor c=1.87007e-17
C77 (\12\:VDD VSS) capacitor c=8.63057e-17
C78 (\17\:VDD VSS) capacitor c=2.06162e-16
C79 (\22\:VDD VSS) capacitor c=7.31045e-18
C80 (\23\:VDD VSS) capacitor c=1.17598e-17
C81 (\25\:VDD VSS) capacitor c=1.82184e-17
C82 (\26\:VDD VSS) capacitor c=7.89664e-17
C83 (\33\:VDD VSS) capacitor c=4.80326e-17
C84 (\38\:VDD VSS) capacitor c=7.69511e-17
C85 (\39\:VDD VSS) capacitor c=7.0305e-17
Rk25 (\11\:VSS \13\:VSS) resistor r=0.7298 c=0
Rk26 (\13\:VSS \14\:VSS) resistor r=0.2086 c=0
Rk27 (\14\:VSS \15\:VSS) resistor r=0.3934 c=0
Rk28 (\15\:VSS \16\:VSS) resistor r=0.1503 c=0
Rk29 (\16\:VSS \17\:VSS) resistor r=0.03994 c=0
Rk32 (\17\:VSS \20\:VSS) resistor r=0.06251 c=0
Rk33 (\20\:VSS \21\:VSS) resistor r=0.1793 c=0
Rk34 (\21\:VSS \22\:VSS) resistor r=0.1067 c=0
Rk35 (\22\:VSS \23\:VSS) resistor r=0.2607 c=0
Rk36 (\23\:VSS \24\:VSS) resistor r=0.07987 c=0
Rk37 (\24\:VSS \25\:VSS) resistor r=0.1603 c=0
Rk39 (\26\:VSS VSS) resistor r=0.09236 c=0
Rk38 (\25\:VSS \26\:VSS) resistor r=0.05749 c=0
Rk40 (\14\:VSS \28\:VSS) resistor r=0.237 c=0
Rk41 (\15\:VSS \29\:VSS) resistor r=0.6114 c=0
Rk45 (\20\:VSS \36\:VSS) resistor r=0.5823 c=0
Rk46 (\21\:VSS \38\:VSS) resistor r=0.04332 c=0
Rk47 (\23\:VSS \39\:VSS) resistor r=0.7478 c=0
Rk48 (\24\:VSS \41\:VSS) resistor r=0.2622 c=0
Rk49 (\26\:VSS \42\:VSS) resistor r=0.5645 c=0
Rk6 (\5\:A A) resistor r=0.07297 c=0
Rk50 (\11\:VDD \12\:VDD) resistor r=0.06622 c=0
Rk51 (\12\:VDD \14\:VDD) resistor r=0.3931 c=0
Rk52 (\14\:VDD \16\:VDD) resistor r=0.3403 c=0
Rk53 (\16\:VDD \17\:VDD) resistor r=0.509 c=0
Rk58 (\17\:VDD \22\:VDD) resistor r=0.2479 c=0
Rk59 (\22\:VDD \23\:VDD) resistor r=0.1075 c=0
Rk60 (\23\:VDD \24\:VDD) resistor r=0.2281 c=0
Rk62 (\25\:VDD VDD) resistor r=0.288 c=0
Rk61 (\24\:VDD \25\:VDD) resistor r=0.2632 c=0
Rk63 (\12\:VDD \26\:VDD) resistor r=0.3785 c=0
Rk67 (\22\:VDD \33\:VDD) resistor r=0.5025 c=0
Rk68 (\23\:VDD \35\:VDD) resistor r=0.3918 c=0
Rk69 (\25\:VDD \37\:VDD) resistor r=0.3521 c=0
Rk70 (\37\:VDD \38\:VDD) resistor r=0.4008 c=0
Rk71 (\38\:VDD \39\:VDD) resistor r=0.3206 c=0
Rk1 (\5\:n1 \6\:n1) resistor r=0.3436 c=0
Rk2 (\6\:n1 \8\:n1) resistor r=0.4134 c=0
Rk3 (\6\:n1 \10\:n1) resistor r=0.02292 c=0
Rk4 (\5\:n0 \7\:n0) resistor r=0.3899 c=0
Rk5 (\7\:n0 \8\:n0) resistor r=0.6089 c=0
Rk7 (\4\:n2 \5\:n2) resistor r=0.4021 c=0
Rk8 (\5\:n2 \7\:n2) resistor r=0.1355 c=0
Rk9 (\5\:n2 \9\:n2) resistor r=0.517 c=0
Rk16 (\4\:n3 \5\:n3) resistor r=1.5123 c=0
Rk17 (\5\:n3 \7\:n3) resistor r=0.06035 c=0
Rk18 (\5\:n3 \9\:n3) resistor r=0.3849 c=0
Rk19 (\15\:n6 \17\:n6) resistor r=0.9667 c=0
Rk20 (\17\:n6 \19\:n6) resistor r=0.4137 c=0
Rk21 (\4\:n4 \6\:n4) resistor r=1.0255 c=0
Rk22 (\6\:n4 \8\:n4) resistor r=0.5622 c=0
Rk23 (\6\:n5 \8\:n5) resistor r=0.689 c=0
Rk24 (\8\:n5 \9\:n5) resistor r=0.3794 c=0
Rl40 (\9\:VSS \10\:VSS) resistor r=90.3618 c=0
Rl32 (\7\:VSS \8\:VSS) resistor r=57.6695 c=0
Rl16 (\6\:VSS \5\:VSS) resistor r=71.8456 c=0
Rl9 (\4\:VSS \3\:VSS) resistor r=24.2328 c=0
Rl1 (\2\:VSS \1\:VSS) resistor r=66.0234 c=0
Rl12 (\2\:A \4\:A) resistor r=97.7911 c=0
Rl11 (\2\:A \3\:A) resistor r=34.3295 c=0
Rl10 (\1\:A \2\:A) resistor r=1.2713 c=0
Rl39 (\10\:VDD \9\:VDD) resistor r=95.1508 c=0
Rl33 (\8\:VDD \7\:VDD) resistor r=189.898 c=0
Rl15 (\6\:VDD \5\:VDD) resistor r=87.6944 c=0
Rl8 (\4\:VDD \3\:VDD) resistor r=87.6944 c=0
Rl2 (\2\:VDD \1\:VDD) resistor r=47.3097 c=0
Rl3 (n1 \2\:n1) resistor r=180.049 c=0
Rl5 (\2\:n1 \4\:n1) resistor r=34.3295 c=0
Rl4 (\2\:n1 \3\:n1) resistor r=2.0166 c=0
Rl6 (n0 \2\:n0) resistor r=189.898 c=0
Rl7 (\2\:n0 \3\:n0) resistor r=222.643 c=0
Rl13 (n2 \2\:n2) resistor r=140.385 c=0
Rl14 (\2\:n2 \3\:n2) resistor r=24.2328 c=0
Rl30 (n3 \2\:n3) resistor r=153.846 c=0
Rl31 (\2\:n3 \3\:n3) resistor r=24.2328 c=0
Rl24 (n6 \9\:n6) resistor r=10.3526 c=0
Rl37 (n4 \2\:n4) resistor r=216.534 c=0
Rl38 (\2\:n4 \3\:n4) resistor r=24.2328 c=0
Rl34 (n5 \2\:n5) resistor r=90.0661 c=0
Rl35 (\2\:n5 \3\:n5) resistor r=90.3625 c=0
Rl36 (\2\:n5 \4\:n5) resistor r=34.5407 c=0
Rz10 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz14 (\38\:VSS \37\:VSS) resistor r=75 c=0
Rz15 (\41\:VSS \40\:VSS) resistor r=75 c=0
Rz16 (\16\:VDD \15\:VDD) resistor r=7.5 c=0
Rz17 (\17\:VDD \15\:VDD) resistor r=18.75 c=0
Rz19 (\24\:VDD \15\:VDD) resistor r=6.25 c=0
Rz1 (\7\:n1 \8\:n1) resistor r=75 c=0
Rz2 (\4\:n0 \5\:n0) resistor r=75 c=0
Rz3 (\6\:n2 \7\:n2) resistor r=75 c=0
Rz6 (\6\:n3 \7\:n3) resistor r=75 c=0
Rz7 (\19\:n6 \18\:n6) resistor r=75 c=0
Rz8 (\5\:n4 \6\:n4) resistor r=75 c=0
Rz9 (\5\:n5 \6\:n5) resistor r=75 c=0
Ry10 (\13\:VSS \12\:VSS) resistor r=20.6667 c=0
Ry11 (\16\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry12 (\17\:VSS \12\:VSS) resistor r=62 c=0
Ry13 (\22\:VSS \12\:VSS) resistor r=10.3333 c=0
Ry14 (\25\:VSS \12\:VSS) resistor r=15.5 c=0
Ry15 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry19 (\35\:VDD \34\:VDD) resistor r=62 c=0
Ry20 (\37\:VDD \36\:VDD) resistor r=62 c=0
Ry1 (\9\:n1 \10\:n1) resistor r=62 c=0
Ry2 (\6\:n0 \7\:n0) resistor r=62 c=0
Ry3 (\8\:n2 \9\:n2) resistor r=62 c=0
Ry6 (\8\:n3 \9\:n3) resistor r=62 c=0
Ry7 (\17\:n6 \16\:n6) resistor r=20.6667 c=0
Ry8 (\7\:n4 \8\:n4) resistor r=62 c=0
Ry9 (\7\:n5 \8\:n5) resistor r=62 c=0
Rx9 (\11\:VSS \9\:VSS) resistor r=45 c=0
Rx10 (\29\:VSS \7\:VSS) resistor r=45 c=0
Rx11 (\36\:VSS \6\:VSS) resistor r=45 c=0
Rx12 (\39\:VSS \4\:VSS) resistor r=45 c=0
Rx13 (\42\:VSS \2\:VSS) resistor r=45 c=0
Rx3 (\1\:A \5\:A) resistor r=45 c=0
Rx14 (\11\:VDD \8\:VDD) resistor r=45 c=0
Rx15 (\26\:VDD \10\:VDD) resistor r=45 c=0
Rx16 (\33\:VDD \6\:VDD) resistor r=45 c=0
Rx17 (\38\:VDD \4\:VDD) resistor r=45 c=0
Rx18 (\39\:VDD \2\:VDD) resistor r=45 c=0
Rx1 (\3\:n1 \5\:n1) resistor r=45 c=0
Rx2 (n0 \8\:n0) resistor r=45 c=0
Rx4 (\3\:n2 \4\:n2) resistor r=45 c=0
Rx5 (\3\:n3 \4\:n3) resistor r=45 c=0
Rx6 (\15\:n6 \9\:n6) resistor r=45 c=0
Rx7 (\3\:n4 \4\:n4) resistor r=45 c=0
Rx8 (\4\:n5 \9\:n5) resistor r=45 c=0
mn2 (\7\:n1 \1\:VDD n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=6.163e-14 ps=4.1e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=5.65e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn1 (n7 \3\:n0 \40\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=4.6e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn3 (n9 n1 \40\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=2.55e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn4 (\6\:n2 \3\:VDD n9 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.175e-14 ps=4.1e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.5e-07 sd=160n sca=8.55924 \
        scb=0.0065649 scc=0.000116351 m=(1)
mn0 (\4\:n0 \3\:A \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.335e-14 ad=2.465e-14 ps=1.62e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=6.2e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn5 (n11 \2\:n2 \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.335e-14 ad=1.957e-14 ps=1.62e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=4.15e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn6 (\6\:n3 \5\:VDD n11 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=3.407e-14 ps=5.6e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=2.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn12_1__rcx (Y n6 \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.069e-14 ad=4.16e-14 ps=1.3975e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22115e-07 sb=1.17933e-06 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(4)
mn7 (n13 \2\:n3 \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.297e-14 ad=3.48e-14 ps=1.23e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=4.25e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn8 (\5\:n4 \7\:VDD n13 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.03e-14 ps=7.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.46e-06 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn11 (\18\:n6 n5 \27\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.63e-14 ad=8.19e-14 ps=1e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.15e-07 sb=4.56923e-07 sd=160n sca=10.5507 \
        scb=0.0097116 scc=0.000384728 m=(1)
mn9 (n15 \2\:n4 \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.63e-14 ad=1.957e-14 ps=1e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6e-07 sb=4.55e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mn10 (\5\:n5 \9\:VDD n15 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=3.988e-14 ps=5.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.8e-07 sb=2.75e-07 sd=160n sca=8.15925 \
        scb=0.00587019 scc=8.94977e-05 m=(1)
mp1 (n8 \2\:n0 \36\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.902e-14 ps=7.5e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.2e-07 sb=7e-07 sd=160n sca=20.5436 scb=0.0200303 \
        scc=0.00154452 m=(1)
mp3 (n10 \4\:n1 \36\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.665e-14 ps=7.5e-07 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=4.95e-07 sd=160n sca=19.1751 \
        scb=0.0185424 scc=0.00153893 m=(1)
mp4 (\8\:n2 \3\:VSS n10 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.665e-14 ad=3.01e-14 ps=1.05e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=1.4e-07 sd=160n sca=18.4975 \
        scb=0.0182651 scc=0.0015388 m=(1)
mp0 (\6\:n0 \4\:A \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.32326e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp5 (n12 n2 \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.59e-14 ps=7.5e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=4.27326e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp6 (\8\:n3 \5\:VSS n12 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=2.63e-14 ps=9.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.5e-07 sb=1.22326e-07 sd=160n sca=15.6338 \
        scb=0.015455 scc=0.000959319 m=(1)
mp12_1__rcx (Y n6 \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.507e-14 ad=6.24e-14 ps=1.1825e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.12308e-07 sb=1.00994e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
mp7 (n14 n3 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.167e-14 ad=1.29e-14 ps=1.47e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.10686e-06 sb=2.45e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp8 (\7\:n4 \8\:VSS n14 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.21186e-06 sb=1.4e-07 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp11 (\16\:n6 \3\:n5 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0415e-13 ad=5.46e-14 ps=1.56e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.26923e-07 sd=160n sca=24.4353 \
        scb=0.0186618 scc=0.00260099 m=(1)
mp9 (n16 n4 \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0415e-13 ad=1.29e-14 ps=1.56e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=2.45e-07 sd=160n sca=17.1405 \
        scb=0.0165101 scc=0.000961221 m=(1)
mp10 (\7\:n5 \10\:VSS n16 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=1.4e-07 sd=160n sca=18.2098 \
        scb=0.0180238 scc=0.000972287 m=(1)
ends DLY3X4
// End of subcircuit definition.

// Generated for: spectre (May  9 14:42:47 2012 )
// Library name: gsclib045
// Cell name: DLY4X1
// View name: extracted

simulator lang=spectre

subckt DLY4X1 A VDD VSS Y
mp16 (\1\:Y net333 \37\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=35.1619 scb=0.02637 \
        scc=0.00345369 m=(1)
C1 (Y VSS) capacitor c=8.03425e-17
C2 (VDD VSS) capacitor c=3.44702e-16
C3 (A VSS) capacitor c=8.32463e-17
C4 (net333 VSS) capacitor c=3.06847e-17
C5 (net345 VSS) capacitor c=3.12528e-17
C6 (net353 VSS) capacitor c=5.82727e-17
C7 (net349 VSS) capacitor c=1.40987e-18
C8 (net361 VSS) capacitor c=8.85882e-17
C9 (net357 VSS) capacitor c=5.62055e-18
C10 (net369 VSS) capacitor c=5.84096e-17
C11 (net365 VSS) capacitor c=1.66931e-18
C12 (net377 VSS) capacitor c=4.73513e-17
C13 (net385 VSS) capacitor c=2.25109e-17
C14 (net393 VSS) capacitor c=1.01073e-16
C15 (net389 VSS) capacitor c=2.06898e-18
C16 (net397 VSS) capacitor c=2.16234e-17
C17 (net276 VSS) capacitor c=1.29981e-18
C18 (net284 VSS) capacitor c=1.6656e-18
C19 (net300 VSS) capacitor c=1.91562e-18
C20 (net292 VSS) capacitor c=2.21505e-18
C21 (net308 VSS) capacitor c=2.65208e-18
C22 (\1\:A VSS) capacitor c=4.53688e-17
C23 (\4\:net397 VSS) capacitor c=1.01237e-16
C24 (\4\:net385 VSS) capacitor c=3.92862e-17
C25 (\2\:net377 VSS) capacitor c=5.9644e-17
C26 (\3\:net345 VSS) capacitor c=3.73918e-17
C27 (\4\:A VSS) capacitor c=4.2162e-17
C28 (\3\:net397 VSS) capacitor c=2.93948e-17
C29 (\9\:VDD VSS) capacitor c=6.09709e-17
C30 (\11\:VDD VSS) capacitor c=3.17835e-17
C31 (\2\:net393 VSS) capacitor c=5.60529e-17
C32 (\3\:net385 VSS) capacitor c=5.31357e-17
C33 (\7\:VDD VSS) capacitor c=3.90385e-17
C34 (\6\:VDD VSS) capacitor c=3.9725e-17
C35 (\3\:net377 VSS) capacitor c=3.76583e-17
C36 (\5\:net369 VSS) capacitor c=2.75055e-17
C37 (\3\:VDD VSS) capacitor c=2.55007e-17
C38 (\5\:VDD VSS) capacitor c=5.05857e-17
C39 (\2\:net361 VSS) capacitor c=5.36066e-17
C40 (\1\:VDD VSS) capacitor c=4.25685e-17
C41 (\2\:net353 VSS) capacitor c=6.50175e-17
C42 (\4\:net333 VSS) capacitor c=1.88018e-17
C43 (\3\:A VSS) capacitor c=2.35955e-17
C44 (\10\:VDD VSS) capacitor c=6.5169e-17
C45 (\3\:net393 VSS) capacitor c=3.21944e-17
C46 (\8\:VDD VSS) capacitor c=2.60828e-17
C47 (\2\:net369 VSS) capacitor c=7.29673e-17
C48 (\4\:net377 VSS) capacitor c=2.81874e-17
C49 (\4\:net361 VSS) capacitor c=3.34674e-17
C50 (\4\:net369 VSS) capacitor c=2.53792e-17
C51 (\4\:VDD VSS) capacitor c=2.49088e-17
C52 (\3\:net361 VSS) capacitor c=4.66035e-17
C53 (\2\:VDD VSS) capacitor c=3.54795e-17
C54 (\3\:net353 VSS) capacitor c=3.0407e-17
C55 (\3\:net333 VSS) capacitor c=1.16476e-17
C56 (\5\:net397 VSS) capacitor c=6.63176e-17
C57 (\12\:VDD VSS) capacitor c=3.45694e-17
C58 (\7\:net393 VSS) capacitor c=8.73593e-17
C59 (\9\:net385 VSS) capacitor c=1.92056e-17
C60 (\25\:VDD VSS) capacitor c=4.0297e-18
C61 (\5\:net377 VSS) capacitor c=3.61306e-17
C62 (\8\:net361 VSS) capacitor c=1.70223e-16
C63 (\29\:VDD VSS) capacitor c=2.13437e-17
C64 (\6\:net369 VSS) capacitor c=6.2792e-17
C65 (\6\:net353 VSS) capacitor c=1.51511e-16
C66 (\32\:VDD VSS) capacitor c=3.27679e-17
C67 (\7\:net345 VSS) capacitor c=1.17147e-16
C68 (\34\:VDD VSS) capacitor c=6.77763e-17
C69 (\5\:net333 VSS) capacitor c=8.44445e-17
C70 (\1\:Y VSS) capacitor c=8.13661e-17
C71 (\37\:VDD VSS) capacitor c=5.53663e-17
C72 (\14\:VDD VSS) capacitor c=9.93569e-17
C73 (\9\:net397 VSS) capacitor c=2.14118e-17
C74 (\5\:net393 VSS) capacitor c=1.32513e-16
C75 (\5\:net385 VSS) capacitor c=5.34967e-17
C76 (\9\:net377 VSS) capacitor c=9.63734e-17
C77 (\9\:net369 VSS) capacitor c=1.07594e-16
C78 (\6\:net361 VSS) capacitor c=5.58657e-17
C79 (\4\:net353 VSS) capacitor c=1.17703e-16
C80 (\5\:net345 VSS) capacitor c=7.48571e-17
C81 (\7\:net333 VSS) capacitor c=1.15208e-16
C82 (\3\:Y VSS) capacitor c=1.60814e-18
C83 (\2\:net333 VSS) capacitor c=7.79768e-18
C84 (\2\:net345 VSS) capacitor c=4.32138e-17
C85 (\3\:net369 VSS) capacitor c=3.83961e-17
C86 (\2\:net385 VSS) capacitor c=2.92386e-17
C87 (\2\:net397 VSS) capacitor c=6.35909e-17
C88 (\2\:A VSS) capacitor c=4.26888e-17
C89 (\9\:net333 VSS) capacitor c=1.00979e-16
C90 (\9\:net345 VSS) capacitor c=5.55934e-17
C91 (\8\:net353 VSS) capacitor c=9.01107e-17
C92 (\5\:net361 VSS) capacitor c=4.28211e-17
C93 (\8\:net369 VSS) capacitor c=7.00215e-17
C94 (\10\:net361 VSS) capacitor c=1.87424e-16
C95 (\11\:net369 VSS) capacitor c=1.05018e-16
C96 (\7\:net377 VSS) capacitor c=1.11772e-16
C97 (\8\:net377 VSS) capacitor c=1.62953e-16
C98 (\11\:net377 VSS) capacitor c=8.51618e-17
C99 (\7\:net385 VSS) capacitor c=6.18478e-17
C100 (\8\:net385 VSS) capacitor c=4.15634e-17
C101 (\4\:net393 VSS) capacitor c=3.83595e-17
C102 (\5\:A VSS) capacitor c=3.76483e-17
C103 (\7\:net397 VSS) capacitor c=5.83737e-17
C104 (\8\:net397 VSS) capacitor c=4.11454e-17
C105 (\16\:VDD VSS) capacitor c=1.18217e-17
C106 (\17\:VDD VSS) capacitor c=2.84468e-17
C107 (\19\:VDD VSS) capacitor c=2.11386e-17
C108 (\20\:VDD VSS) capacitor c=4.15133e-17
C109 (\22\:VDD VSS) capacitor c=1.22615e-17
C110 (\24\:VDD VSS) capacitor c=8.26203e-18
C111 (\27\:VDD VSS) capacitor c=1.02584e-16
C112 (\28\:VDD VSS) capacitor c=5.5888e-17
C113 (\31\:VDD VSS) capacitor c=1.23116e-16
C114 (\36\:VDD VSS) capacitor c=1.53696e-16
Rk1 (\2\:Y Y) resistor r=0.2605 c=0
Rk2 (Y \4\:Y) resistor r=0.04165 c=0
Rk26 (\13\:VDD \15\:VDD) resistor r=0.3547 c=0
Rk27 (\15\:VDD \16\:VDD) resistor r=0.3433 c=0
Rk28 (\16\:VDD \17\:VDD) resistor r=0.135 c=0
Rk29 (\17\:VDD \18\:VDD) resistor r=0.3733 c=0
Rk30 (\18\:VDD \19\:VDD) resistor r=0.1919 c=0
Rk31 (\19\:VDD \20\:VDD) resistor r=0.3396 c=0
Rk32 (\20\:VDD \21\:VDD) resistor r=0.1678 c=0
Rk33 (\21\:VDD \22\:VDD) resistor r=0.1302 c=0
Rk34 (\22\:VDD \23\:VDD) resistor r=0.4731 c=0
Rk36 (\24\:VDD VDD) resistor r=0.07978 c=0
Rk35 (\23\:VDD \24\:VDD) resistor r=0.3215 c=0
Rk37 (\16\:VDD \26\:VDD) resistor r=0.07369 c=0
Rk38 (\17\:VDD \27\:VDD) resistor r=0.6651 c=0
Rk39 (\27\:VDD \28\:VDD) resistor r=0.35 c=0
Rk40 (\19\:VDD \30\:VDD) resistor r=0.04329 c=0
Rk41 (\20\:VDD \31\:VDD) resistor r=0.6893 c=0
Rk42 (\22\:VDD \33\:VDD) resistor r=0.1923 c=0
Rk43 (\23\:VDD \35\:VDD) resistor r=0.033 c=0
Rk44 (\35\:VDD \36\:VDD) resistor r=0.9087 c=0
Rk45 (\24\:VDD \38\:VDD) resistor r=0.4047 c=0
Rk22 (A \5\:A) resistor r=0.06297 c=0
Rk46 (\15\:VSS \17\:VSS) resistor r=0.2835 c=0
Rk47 (\17\:VSS \18\:VSS) resistor r=0.1358 c=0
Rk48 (\18\:VSS \19\:VSS) resistor r=0.2154 c=0
Rk49 (\19\:VSS \20\:VSS) resistor r=0.1878 c=0
Rk50 (\20\:VSS \21\:VSS) resistor r=0.1126 c=0
Rk51 (\21\:VSS \22\:VSS) resistor r=0.08755 c=0
Rk52 (\22\:VSS \23\:VSS) resistor r=0.263 c=0
Rk53 (\23\:VSS \24\:VSS) resistor r=0.256 c=0
Rk54 (\24\:VSS \25\:VSS) resistor r=0.09507 c=0
Rk55 (\25\:VSS \26\:VSS) resistor r=0.1026 c=0
Rk56 (\26\:VSS \27\:VSS) resistor r=0.1979 c=0
Rk57 (\27\:VSS \28\:VSS) resistor r=0.07752 c=0
Rk58 (\28\:VSS \29\:VSS) resistor r=0.1174 c=0
Rk59 (\29\:VSS \30\:VSS) resistor r=0.145 c=0
Rk60 (\30\:VSS \31\:VSS) resistor r=0.2177 c=0
Rk61 (\31\:VSS \32\:VSS) resistor r=0.09256 c=0
Rk63 (\33\:VSS VSS) resistor r=0.02212 c=0
Rk62 (\32\:VSS \33\:VSS) resistor r=0.3784 c=0
Rk64 (\18\:VSS \34\:VSS) resistor r=0.6246 c=0
Rk65 (\20\:VSS \36\:VSS) resistor r=0.07369 c=0
Rk66 (\22\:VSS \37\:VSS) resistor r=0.6059 c=0
Rk67 (\23\:VSS \38\:VSS) resistor r=0.6054 c=0
Rk68 (\24\:VSS \40\:VSS) resistor r=0.07369 c=0
Rk69 (\26\:VSS \41\:VSS) resistor r=0.7625 c=0
Rk70 (\28\:VSS \42\:VSS) resistor r=0.7207 c=0
Rk71 (\29\:VSS \44\:VSS) resistor r=0.0765 c=0
Rk72 (\30\:VSS \45\:VSS) resistor r=0.5916 c=0
Rk73 (\31\:VSS \47\:VSS) resistor r=0.3632 c=0
Rk74 (\33\:VSS \49\:VSS) resistor r=0.2929 c=0
Rk3 (\6\:net333 \8\:net333) resistor r=0.4891 c=0
Rk4 (\8\:net333 \9\:net333) resistor r=0.7554 c=0
Rk5 (\6\:net345 \8\:net345) resistor r=0.5219 c=0
Rk6 (\8\:net345 \9\:net345) resistor r=0.4005 c=0
Rk7 (\5\:net353 \7\:net353) resistor r=0.6367 c=0
Rk8 (\7\:net353 \8\:net353) resistor r=0.7078 c=0
Rk9 (\5\:net361 \7\:net361) resistor r=0.201 c=0
Rk11 (\9\:net361 \10\:net361) resistor r=1.2577 c=0
Rk10 (\7\:net369 \8\:net369) resistor r=0.2279 c=0
Rk12 (\10\:net369 \11\:net369) resistor r=0.6342 c=0
Rk13 (\6\:net377 \7\:net377) resistor r=0.1774 c=0
Rk14 (\7\:net377 \8\:net377) resistor r=0.6423 c=0
Rk15 (\7\:net377 \10\:net377) resistor r=0.4634 c=0
Rk16 (\8\:net377 \11\:net377) resistor r=0.5841 c=0
Rk17 (\6\:net385 \7\:net385) resistor r=0.3448 c=0
Rk18 (\7\:net385 \8\:net385) resistor r=0.2667 c=0
Rk19 (\7\:net385 \10\:net385) resistor r=0.08441 c=0
Rk20 (\4\:net393 \6\:net393) resistor r=0.3134 c=0
Rk21 (\6\:net393 \8\:net393) resistor r=0.6552 c=0
Rk23 (\6\:net397 \7\:net397) resistor r=0.5416 c=0
Rk24 (\7\:net397 \8\:net397) resistor r=0.1621 c=0
Rk25 (\7\:net397 \10\:net397) resistor r=0.1266 c=0
Rl26 (\6\:VDD \7\:VDD) resistor r=301.489 c=0
Rl33 (\9\:VDD \10\:VDD) resistor r=246.131 c=0
Rl34 (\10\:VDD \11\:VDD) resistor r=31.9741 c=0
Rl27 (\7\:VDD \8\:VDD) resistor r=24.2328 c=0
Rl12 (\3\:VDD \4\:VDD) resistor r=55.2823 c=0
Rl13 (\4\:VDD \5\:VDD) resistor r=132.205 c=0
Rl9 (\1\:VDD \2\:VDD) resistor r=26.1559 c=0
Rl40 (\1\:A \2\:A) resistor r=166.187 c=0
Rl42 (\2\:A \4\:A) resistor r=110.418 c=0
Rl41 (\2\:A \3\:A) resistor r=1.2301 c=0
Rl35 (\11\:VSS \12\:VSS) resistor r=106.925 c=0
Rl36 (\12\:VSS \13\:VSS) resistor r=217.847 c=0
Rl25 (\9\:VSS \10\:VSS) resistor r=78.3592 c=0
Rl24 (\7\:VSS \8\:VSS) resistor r=110.771 c=0
Rl17 (\5\:VSS \6\:VSS) resistor r=124.513 c=0
Rl11 (\3\:VSS \4\:VSS) resistor r=24.2328 c=0
Rl10 (\1\:VSS \2\:VSS) resistor r=80.7464 c=0
Rl1 (net333 \2\:net333) resistor r=49.7141 c=0
Rl3 (\2\:net333 \4\:net333) resistor r=34.3295 c=0
Rl2 (\2\:net333 \3\:net333) resistor r=5.9102 c=0
Rl4 (net345 \2\:net345) resistor r=90.0759 c=0
Rl5 (\2\:net345 \3\:net345) resistor r=58.4173 c=0
Rl6 (\2\:net345 \4\:net345) resistor r=11.0837 c=0
Rl7 (net353 \2\:net353) resistor r=140.385 c=0
Rl8 (net353 \3\:net353) resistor r=24.2328 c=0
Rl14 (net361 \2\:net361) resistor r=209.615 c=0
Rl15 (\2\:net361 \3\:net361) resistor r=172.59 c=0
Rl16 (\3\:net361 \4\:net361) resistor r=182.153 c=0
Rl20 (net369 \2\:net369) resistor r=50.6918 c=0
Rl23 (\3\:net369 \5\:net369) resistor r=86.22 c=0
Rl21 (\2\:net369 \3\:net369) resistor r=142.627 c=0
Rl22 (\3\:net369 \4\:net369) resistor r=44.1561 c=0
Rl18 (net377 \2\:net377) resistor r=57.6695 c=0
Rl19 (\3\:net377 \4\:net377) resistor r=91.5405 c=0
Rl28 (net385 \2\:net385) resistor r=0.5213 c=0
Rl30 (\2\:net385 \4\:net385) resistor r=34.3295 c=0
Rl29 (\2\:net385 \3\:net385) resistor r=109.329 c=0
Rl31 (net393 \2\:net393) resistor r=151.923 c=0
Rl32 (\2\:net393 \3\:net393) resistor r=26.1559 c=0
Rl37 (net397 \2\:net397) resistor r=1.2334 c=0
Rl39 (\2\:net397 \4\:net397) resistor r=239.264 c=0
Rl38 (\2\:net397 \3\:net397) resistor r=37.3411 c=0
Rz1 (\3\:Y \4\:Y) resistor r=75 c=0
Rz11 (\14\:VDD \15\:VDD) resistor r=12.5 c=0
Rz12 (\14\:VDD \18\:VDD) resistor r=6.8182 c=0
Rz13 (\14\:VDD \21\:VDD) resistor r=25 c=0
Rz14 (\14\:VDD \23\:VDD) resistor r=8.3333 c=0
Rz15 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz16 (\35\:VSS \36\:VSS) resistor r=75 c=0
Rz17 (\39\:VSS \40\:VSS) resistor r=75 c=0
Rz18 (\43\:VSS \44\:VSS) resistor r=75 c=0
Rz19 (\46\:VSS \47\:VSS) resistor r=75 c=0
Rz20 (\48\:VSS \49\:VSS) resistor r=75 c=0
Rz2 (\7\:net333 \8\:net333) resistor r=75 c=0
Rz3 (\5\:net345 \6\:net345) resistor r=75 c=0
Rz4 (\4\:net353 \5\:net353) resistor r=75 c=0
Rz5 (\6\:net361 \7\:net361) resistor r=75 c=0
Rz6 (\9\:net369 \10\:net369) resistor r=75 c=0
Rz7 (\9\:net377 \10\:net377) resistor r=75 c=0
Rz8 (\5\:net385 \6\:net385) resistor r=75 c=0
Rz9 (\5\:net393 \6\:net393) resistor r=75 c=0
Rz10 (\9\:net397 \10\:net397) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry11 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry12 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry13 (\29\:VDD \30\:VDD) resistor r=62 c=0
Ry14 (\32\:VDD \33\:VDD) resistor r=62 c=0
Ry15 (\34\:VDD \35\:VDD) resistor r=62 c=0
Ry16 (\37\:VDD \38\:VDD) resistor r=20.6667 c=0
Ry17 (\16\:VSS \17\:VSS) resistor r=20.6667 c=0
Ry18 (\16\:VSS \19\:VSS) resistor r=15.5 c=0
Ry19 (\16\:VSS \21\:VSS) resistor r=31 c=0
Ry20 (\16\:VSS \23\:VSS) resistor r=12.4 c=0
Ry21 (\16\:VSS \25\:VSS) resistor r=31 c=0
Ry22 (\16\:VSS \27\:VSS) resistor r=15.5 c=0
Ry23 (\16\:VSS \32\:VSS) resistor r=6.8889 c=0
Ry2 (\5\:net333 \6\:net333) resistor r=62 c=0
Ry3 (\7\:net345 \8\:net345) resistor r=62 c=0
Ry4 (\6\:net353 \7\:net353) resistor r=62 c=0
Ry6 (\8\:net361 \9\:net361) resistor r=62 c=0
Ry5 (\6\:net369 \7\:net369) resistor r=62 c=0
Ry7 (\5\:net377 \6\:net377) resistor r=62 c=0
Ry8 (\9\:net385 \10\:net385) resistor r=62 c=0
Ry9 (\7\:net393 \8\:net393) resistor r=62 c=0
Ry10 (\5\:net397 \6\:net397) resistor r=62 c=0
Rx14 (\8\:VDD \27\:VDD) resistor r=45 c=0
Rx15 (\10\:VDD \28\:VDD) resistor r=45 c=0
Rx16 (\4\:VDD \31\:VDD) resistor r=45 c=0
Rx17 (\2\:VDD \36\:VDD) resistor r=45 c=0
Rx12 (\3\:A \5\:A) resistor r=45 c=0
Rx18 (\12\:VSS \34\:VSS) resistor r=45 c=0
Rx19 (\10\:VSS \37\:VSS) resistor r=45 c=0
Rx20 (\8\:VSS \38\:VSS) resistor r=45 c=0
Rx21 (\6\:VSS \41\:VSS) resistor r=45 c=0
Rx22 (\4\:VSS \42\:VSS) resistor r=45 c=0
Rx23 (\1\:VSS \45\:VSS) resistor r=45 c=0
Rx1 (\3\:net333 \9\:net333) resistor r=45 c=0
Rx2 (\4\:net345 \9\:net345) resistor r=45 c=0
Rx3 (\3\:net353 \8\:net353) resistor r=45 c=0
Rx4 (\3\:net361 \5\:net361) resistor r=45 c=0
Rx6 (\4\:net361 \10\:net361) resistor r=45 c=0
Rx5 (\4\:net369 \8\:net369) resistor r=45 c=0
Rx7 (\2\:net369 \11\:net369) resistor r=45 c=0
Rx8 (net377 \8\:net377) resistor r=45 c=0
Rx9 (\4\:net377 \11\:net377) resistor r=45 c=0
Rx10 (net385 \8\:net385) resistor r=45 c=0
Rx11 (\3\:net393 \4\:net393) resistor r=45 c=0
Rx13 (net397 \8\:net397) resistor r=45 c=0
mn16 (\3\:Y \4\:net333 \48\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.63e-14 ad=3.64e-14 ps=1.03e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn15 (\7\:net333 net345 \46\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.35e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn13 (net341 \2\:net353 \46\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=1.958e-14 ps=6.1e-07 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=5.3e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn14 (\5\:net345 \1\:VDD net341 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=1.958e-14 ad=5.075e-14 ps=5.6e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=3.5e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn11 (net349 \2\:net361 \43\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.215e-14 ad=1.668e-14 ps=1.4e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3e-07 sd=160n sca=16.2011 scb=0.0172667 \
        scc=0.0012292 m=(1)
mn12 (\4\:net353 \5\:VDD net349 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=1.668e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.6e-07 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn10 (\6\:net361 \3\:VDD net357 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.438e-14 ad=2.03e-14 ps=1.04e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.175e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn9 (net357 \5\:net369 \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.39e-14 ad=5.438e-14 ps=1.7e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=7.55e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn7 (net365 \3\:net377 \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.39e-14 ad=3.988e-14 ps=1.7e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.55e-07 sb=4.6e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn8 (\9\:net369 \6\:VDD net365 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=1.4e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn6 (\9\:net377 \7\:VDD net373 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.075e-14 ps=6.1e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=7.3e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn5 (net373 \3\:net385 \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.18e-14 ad=2.32e-14 ps=1.54e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.55e-07 sb=5.25e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn4 (\5\:net385 \11\:VDD net381 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=1.958e-14 ad=2.175e-14 ps=5.6e-07 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=1.5e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn3 (net381 \2\:net393 \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.18e-14 ad=1.958e-14 ps=1.54e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.5e-07 sb=3.3e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn2 (\5\:net393 \9\:VDD net389 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.103e-14 ad=2.03e-14 ps=5.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.35e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn1 (net389 \3\:net397 \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.103e-14 ps=6.1e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=3.45e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mn0 (\9\:net397 \4\:A \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.35e-07 sb=1.4e-07 sd=160n sca=8.0352 \
        scb=0.00565402 scc=8.19771e-05 m=(1)
mp15 (\5\:net333 \3\:net345 \34\:VDD VDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=1.008e-13 ad=5.268e-14 ps=1.73e-06 pd=9.2e-07 \
        nrd=1.16667 nrs=1.16667 sa=2.45e-07 sb=5.85e-07 sd=160n \
        sca=17.5376 scb=0.0173132 scc=0.00131683 m=(1)
mp13 (net276 net353 \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.008e-13 ad=2.473e-14 ps=1.73e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=3e-07 sd=160n sca=17.4145 scb=0.0172865 \
        scc=0.00131682 m=(1)
mp14 (\7\:net345 \2\:VSS net276 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=2.473e-14 ad=3.01e-14 ps=6.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=1.4e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp11 (net284 net361 \32\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.555e-14 ad=1.29e-14 ps=9.2e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2.45e-07 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp12 (\6\:net353 \3\:VSS net284 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.4e-07 sd=160n sca=10.5619 \
        scb=0.00813366 scc=0.000119634 m=(1)
mp8 (\6\:net369 \5\:VSS net300 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.8e-07 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp7 (net300 \2\:net377 \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.127e-14 ad=1.29e-14 ps=1.5e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.75e-07 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp9 (net292 net369 \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.127e-14 ad=1.29e-14 ps=1.5e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=2.45e-07 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp10 (\8\:net361 \7\:VSS net292 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=1.4e-07 sd=160n sca=10.4315 \
        scb=0.0078915 scc=0.00010471 m=(1)
mp6 (\5\:net377 \9\:VSS net308 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=3.01e-14 ps=7.9e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.65e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp5 (net308 \4\:net385 \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.115e-14 ad=3.87e-14 ps=1.69e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=4.4e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp3 (net316 net393 \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.115e-14 ad=1.29e-14 ps=1.69e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=2.45e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp4 (\9\:net385 \13\:VSS net316 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=1.4e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp2 (\7\:net393 \11\:VSS net324 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=11.9849 \
        scb=0.00884842 scc=8.12635e-05 m=(1)
mp1 (net324 \4\:net397 \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=13.2748 \
        scb=0.010838 scc=0.000102032 m=(1)
mp0 (\5\:net397 \1\:A \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=20.984 scb=0.0231223 \
        scc=0.000938814 m=(1)
ends DLY4X1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:43:25 2012 )
// Library name: gsclib045
// Cell name: DLY4X4
// View name: extracted

simulator lang=spectre

subckt DLY4X4 A VDD VSS Y
mp15 (\18\:net333 \3\:net345 \30\:VDD VDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=9.18e-14 ad=5.46e-14 ps=1.32e-06 pd=1.06e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.37481e-06 sd=160n \
        sca=40.9076 scb=0.0353918 scc=0.00415366 m=(1)
C1 (Y VSS) capacitor c=1.80915e-16
C2 (VDD VSS) capacitor c=2.80173e-16
C3 (A VSS) capacitor c=5.29717e-17
C4 (net345 VSS) capacitor c=3.55981e-17
C5 (net333 VSS) capacitor c=2.67547e-16
C6 (net341 VSS) capacitor c=1.63061e-18
C7 (net353 VSS) capacitor c=3.39164e-17
C8 (net349 VSS) capacitor c=7.21012e-19
C9 (net361 VSS) capacitor c=1.04169e-16
C10 (net357 VSS) capacitor c=1.7865e-18
C11 (net369 VSS) capacitor c=6.15605e-17
C12 (net365 VSS) capacitor c=1.51928e-18
C13 (net377 VSS) capacitor c=5.46597e-17
C14 (net385 VSS) capacitor c=2.94322e-17
C15 (net393 VSS) capacitor c=7.56639e-17
C16 (net389 VSS) capacitor c=1.51142e-18
C17 (net397 VSS) capacitor c=2.63324e-17
C18 (net276 VSS) capacitor c=1.81242e-18
C19 (net284 VSS) capacitor c=1.38779e-18
C20 (net300 VSS) capacitor c=2.11386e-18
C21 (net292 VSS) capacitor c=2.32516e-18
C22 (net308 VSS) capacitor c=2.74416e-18
C23 (\1\:A VSS) capacitor c=2.36762e-17
C24 (\3\:net397 VSS) capacitor c=7.07432e-17
C25 (\2\:net377 VSS) capacitor c=6.47159e-17
C26 (\2\:net353 VSS) capacitor c=5.39656e-17
C27 (\3\:net345 VSS) capacitor c=4.1695e-17
C28 (\3\:A VSS) capacitor c=3.8388e-17
C29 (\12\:VDD VSS) capacitor c=5.11095e-17
C30 (\15\:VDD VSS) capacitor c=3.16118e-17
C31 (\2\:net393 VSS) capacitor c=5.03744e-17
C32 (\3\:net385 VSS) capacitor c=5.59836e-17
C33 (\10\:VDD VSS) capacitor c=4.8648e-17
C34 (\9\:VDD VSS) capacitor c=4.39868e-17
C35 (\3\:net377 VSS) capacitor c=3.5928e-17
C36 (\5\:net369 VSS) capacitor c=2.55307e-17
C37 (\3\:VDD VSS) capacitor c=2.8665e-17
C38 (\8\:VDD VSS) capacitor c=5.45018e-17
C39 (\2\:net361 VSS) capacitor c=1.22394e-16
C40 (\1\:VDD VSS) capacitor c=5.04347e-17
C41 (\3\:net353 VSS) capacitor c=5.66517e-17
C42 (\2\:A VSS) capacitor c=3.98725e-17
C43 (\2\:net397 VSS) capacitor c=4.59803e-17
C44 (\14\:VDD VSS) capacitor c=6.46626e-17
C45 (\3\:net393 VSS) capacitor c=3.47437e-17
C46 (\2\:net385 VSS) capacitor c=4.29997e-17
C47 (\11\:VDD VSS) capacitor c=3.21943e-17
C48 (\2\:net369 VSS) capacitor c=6.61413e-17
C49 (\4\:net377 VSS) capacitor c=3.18471e-17
C50 (\4\:net369 VSS) capacitor c=2.82875e-17
C51 (\4\:net361 VSS) capacitor c=3.54678e-17
C52 (\7\:VDD VSS) capacitor c=1.6872e-17
C53 (\3\:net361 VSS) capacitor c=4.25238e-17
C54 (\6\:VDD VSS) capacitor c=4.6405e-17
C55 (\2\:VDD VSS) capacitor c=3.7556e-17
C56 (\2\:net345 VSS) capacitor c=4.62353e-17
C57 (\4\:net397 VSS) capacitor c=3.96277e-17
C58 (\34\:VDD VSS) capacitor c=1.79851e-17
C59 (\7\:net393 VSS) capacitor c=7.11784e-17
C60 (\8\:net385 VSS) capacitor c=1.90458e-17
C61 (\36\:VDD VSS) capacitor c=2.47061e-17
C62 (\5\:net377 VSS) capacitor c=2.71983e-17
C63 (\8\:net361 VSS) capacitor c=1.84532e-16
C64 (\40\:VDD VSS) capacitor c=2.00165e-17
C65 (\6\:net369 VSS) capacitor c=4.63573e-17
C66 (\6\:net353 VSS) capacitor c=1.47014e-16
C67 (\43\:VDD VSS) capacitor c=2.22722e-17
C68 (\6\:net345 VSS) capacitor c=1.76303e-16
C69 (\18\:net333 VSS) capacitor c=5.06215e-17
C70 (\18\:VDD VSS) capacitor c=8.03693e-17
C71 (\8\:net397 VSS) capacitor c=1.96124e-17
C72 (\5\:net393 VSS) capacitor c=1.05853e-16
C73 (\4\:net385 VSS) capacitor c=5.44389e-17
C74 (\9\:net377 VSS) capacitor c=9.68971e-17
C75 (\9\:net369 VSS) capacitor c=1.02949e-16
C76 (\5\:net361 VSS) capacitor c=5.36891e-17
C77 (\4\:net353 VSS) capacitor c=1.20356e-16
C78 (\4\:net345 VSS) capacitor c=6.99999e-17
C79 (\16\:net333 VSS) capacitor c=5.24659e-17
C80 (\4\:VDD VSS) capacitor c=2.97053e-17
C81 (\5\:VDD VSS) capacitor c=2.20623e-17
C82 (\3\:net369 VSS) capacitor c=4.24236e-17
C83 (\15\:net333 VSS) capacitor c=6.5307e-17
C84 (\8\:net345 VSS) capacitor c=1.55282e-16
C85 (\16\:VDD VSS) capacitor c=4.18168e-17
C86 (\17\:VDD VSS) capacitor c=6.34366e-17
C87 (\8\:net353 VSS) capacitor c=5.88511e-17
C88 (\7\:net361 VSS) capacitor c=5.74229e-17
C89 (\8\:net369 VSS) capacitor c=7.15418e-17
C90 (\10\:net361 VSS) capacitor c=1.96938e-16
C91 (\11\:net369 VSS) capacitor c=1.10954e-16
C92 (\7\:net377 VSS) capacitor c=9.71788e-17
C93 (\8\:net377 VSS) capacitor c=1.80066e-16
C94 (\11\:net377 VSS) capacitor c=1.17655e-16
C95 (\6\:net385 VSS) capacitor c=6.63671e-17
C96 (\7\:net385 VSS) capacitor c=6.10721e-17
C97 (\4\:net393 VSS) capacitor c=5.49953e-17
C98 (\4\:A VSS) capacitor c=4.57412e-17
C99 (\6\:net397 VSS) capacitor c=3.79847e-17
C100 (\7\:net397 VSS) capacitor c=4.20832e-17
C101 (\20\:VDD VSS) capacitor c=1.42004e-19
C102 (\22\:VDD VSS) capacitor c=2.95042e-18
C103 (\23\:VDD VSS) capacitor c=1.2572e-17
C104 (\25\:VDD VSS) capacitor c=2.42355e-17
C105 (\27\:VDD VSS) capacitor c=1.36823e-17
C106 (\28\:VDD VSS) capacitor c=2.41388e-17
C107 (\30\:VDD VSS) capacitor c=1.18419e-16
C108 (\38\:VDD VSS) capacitor c=1.16761e-16
C109 (\39\:VDD VSS) capacitor c=6.67067e-17
C110 (\42\:VDD VSS) capacitor c=5.05633e-17
Rk11 (\16\:VDD \17\:VDD) resistor r=0.2376 c=0
Rk31 (\19\:VDD \20\:VDD) resistor r=0.06747 c=0
Rk32 (\20\:VDD \21\:VDD) resistor r=0.283 c=0
Rk33 (\21\:VDD \22\:VDD) resistor r=0.268 c=0
Rk34 (\22\:VDD \23\:VDD) resistor r=0.1124 c=0
Rk35 (\23\:VDD \24\:VDD) resistor r=0.1702 c=0
Rk36 (\24\:VDD \25\:VDD) resistor r=0.3457 c=0
Rk37 (\25\:VDD \26\:VDD) resistor r=0.3557 c=0
Rk38 (\26\:VDD \27\:VDD) resistor r=0.0399 c=0
Rk39 (\27\:VDD \28\:VDD) resistor r=0.4081 c=0
Rk40 (\28\:VDD \29\:VDD) resistor r=0.2529 c=0
Rk45 (\30\:VDD VDD) resistor r=0.1198 c=0
Rk41 (\29\:VDD \30\:VDD) resistor r=0.03238 c=0
Rk46 (\20\:VDD \35\:VDD) resistor r=0.07346 c=0
Rk47 (\22\:VDD \37\:VDD) resistor r=0.4415 c=0
Rk48 (\23\:VDD \38\:VDD) resistor r=0.7453 c=0
Rk49 (\38\:VDD \39\:VDD) resistor r=0.3716 c=0
Rk50 (\25\:VDD \41\:VDD) resistor r=0.1021 c=0
Rk51 (\27\:VDD \42\:VDD) resistor r=0.3891 c=0
Rk52 (\28\:VDD \44\:VDD) resistor r=0.1652 c=0
Rk27 (\4\:A A) resistor r=0.1301 c=0
Rk56 (\15\:VSS \17\:VSS) resistor r=0.3215 c=0
Rk57 (\17\:VSS \18\:VSS) resistor r=0.1558 c=0
Rk58 (\18\:VSS \19\:VSS) resistor r=0.1953 c=0
Rk59 (\19\:VSS \20\:VSS) resistor r=0.2028 c=0
Rk60 (\20\:VSS \21\:VSS) resistor r=0.09754 c=0
Rk61 (\21\:VSS \22\:VSS) resistor r=0.1151 c=0
Rk62 (\22\:VSS \23\:VSS) resistor r=0.2602 c=0
Rk63 (\23\:VSS \24\:VSS) resistor r=0.1951 c=0
Rk64 (\24\:VSS \25\:VSS) resistor r=0.08 c=0
Rk65 (\25\:VSS \26\:VSS) resistor r=0.2003 c=0
Rk66 (\26\:VSS \27\:VSS) resistor r=0.2803 c=0
Rk67 (\27\:VSS \28\:VSS) resistor r=0.07981 c=0
Rk68 (\28\:VSS \29\:VSS) resistor r=0.3179 c=0
Rk73 (\30\:VSS VSS) resistor r=0.1925 c=0
Rk69 (\29\:VSS \30\:VSS) resistor r=0.1199 c=0
Rk74 (\18\:VSS \34\:VSS) resistor r=0.5497 c=0
Rk75 (\20\:VSS \36\:VSS) resistor r=0.07346 c=0
Rk76 (\22\:VSS \37\:VSS) resistor r=0.5399 c=0
Rk77 (\23\:VSS \38\:VSS) resistor r=0.5358 c=0
Rk78 (\24\:VSS \40\:VSS) resistor r=0.2852 c=0
Rk79 (\26\:VSS \41\:VSS) resistor r=0.606 c=0
Rk80 (\27\:VSS \42\:VSS) resistor r=0.7999 c=0
Rk81 (\28\:VSS \44\:VSS) resistor r=0.2972 c=0
Rk82 (\29\:VSS \45\:VSS) resistor r=0.5033 c=0
Rk9 (\5\:net345 \7\:net345) resistor r=0.3646 c=0
Rk10 (\7\:net345 \8\:net345) resistor r=1.2909 c=0
Rk1 (\15\:net333 \17\:net333) resistor r=0.2722 c=0
Rk2 (\17\:net333 \19\:net333) resistor r=0.4353 c=0
Rk12 (\5\:net353 \7\:net353) resistor r=0.7559 c=0
Rk13 (\7\:net353 \8\:net353) resistor r=0.5269 c=0
Rk14 (\6\:net361 \7\:net361) resistor r=0.2137 c=0
Rk16 (\9\:net361 \10\:net361) resistor r=1.3148 c=0
Rk15 (\7\:net369 \8\:net369) resistor r=0.1917 c=0
Rk17 (\10\:net369 \11\:net369) resistor r=0.6325 c=0
Rk18 (\6\:net377 \7\:net377) resistor r=0.1104 c=0
Rk19 (\7\:net377 \8\:net377) resistor r=0.642 c=0
Rk20 (\7\:net377 \10\:net377) resistor r=0.4381 c=0
Rk21 (\8\:net377 \11\:net377) resistor r=0.5967 c=0
Rk22 (\5\:net385 \6\:net385) resistor r=0.3443 c=0
Rk23 (\6\:net385 \7\:net385) resistor r=0.3303 c=0
Rk24 (\6\:net385 \9\:net385) resistor r=0.06751 c=0
Rk25 (\4\:net393 \6\:net393) resistor r=0.4226 c=0
Rk26 (\6\:net393 \8\:net393) resistor r=0.4284 c=0
Rk28 (\5\:net397 \6\:net397) resistor r=0.3134 c=0
Rk29 (\6\:net397 \7\:net397) resistor r=0.2071 c=0
Rk30 (\6\:net397 \9\:net397) resistor r=0.1 c=0
Rl38 (\9\:VDD \10\:VDD) resistor r=295.719 c=0
Rl39 (\11\:VDD \10\:VDD) resistor r=29.5379 c=0
Rl19 (\2\:VDD \1\:VDD) resistor r=128.359 c=0
Rl21 (\4\:VDD \3\:VDD) resistor r=126.901 c=0
Rl24 (\4\:VDD \7\:VDD) resistor r=127.296 c=0
Rl25 (\5\:VDD \8\:VDD) resistor r=72.7584 c=0
Rl23 (\5\:VDD \6\:VDD) resistor r=53.7715 c=0
Rl22 (\5\:VDD \4\:VDD) resistor r=113.852 c=0
Rl44 (\13\:VDD \12\:VDD) resistor r=180.432 c=0
Rl46 (\13\:VDD \15\:VDD) resistor r=26.0821 c=0
Rl45 (\13\:VDD \14\:VDD) resistor r=14.7598 c=0
Rl51 (\1\:A \2\:A) resistor r=33.9954 c=0
Rl52 (\2\:A \3\:A) resistor r=97.6085 c=0
Rl47 (\12\:VSS \11\:VSS) resistor r=41.5405 c=0
Rl48 (\12\:VSS \13\:VSS) resistor r=221.693 c=0
Rl37 (\10\:VSS \9\:VSS) resistor r=62.9746 c=0
Rl36 (\8\:VSS \7\:VSS) resistor r=110.771 c=0
Rl29 (\6\:VSS \5\:VSS) resistor r=147.59 c=0
Rl20 (\4\:VSS \3\:VSS) resistor r=66.5405 c=0
Rl18 (\2\:VSS \1\:VSS) resistor r=59.8789 c=0
Rl1 (net345 \2\:net345) resistor r=51.4546 c=0
Rl2 (\2\:net345 \3\:net345) resistor r=65.3618 c=0
Rl16 (net353 \2\:net353) resistor r=30.3481 c=0
Rl17 (\2\:net353 \3\:net353) resistor r=155.769 c=0
Rl26 (net361 \2\:net361) resistor r=324.566 c=0
Rl27 (\2\:net361 \3\:net361) resistor r=168.744 c=0
Rl28 (\3\:net361 \4\:net361) resistor r=172.537 c=0
Rl31 (net369 \2\:net369) resistor r=50.6918 c=0
Rl34 (\3\:net369 \5\:net369) resistor r=98.7402 c=0
Rl32 (\2\:net369 \3\:net369) resistor r=155.239 c=0
Rl33 (\3\:net369 \4\:net369) resistor r=10.5426 c=0
Rl30 (net377 \2\:net377) resistor r=42.1309 c=0
Rl35 (\3\:net377 \4\:net377) resistor r=56.9251 c=0
Rl40 (net385 \2\:net385) resistor r=24.2328 c=0
Rl41 (\2\:net385 \3\:net385) resistor r=89.6174 c=0
Rl42 (net393 \2\:net393) resistor r=142.308 c=0
Rl43 (\2\:net393 \3\:net393) resistor r=26.1559 c=0
Rl49 (net397 \2\:net397) resistor r=29.5379 c=0
Rl50 (\2\:net397 \3\:net397) resistor r=99.1367 c=0
Rz12 (\19\:VDD \18\:VDD) resistor r=37.5 c=0
Rz13 (\21\:VDD \18\:VDD) resistor r=15 c=0
Rz14 (\24\:VDD \18\:VDD) resistor r=12.5 c=0
Rz15 (\26\:VDD \18\:VDD) resistor r=9.375 c=0
Rz16 (\29\:VDD \18\:VDD) resistor r=12.5 c=0
Rz17 (\30\:VDD \18\:VDD) resistor r=18.75 c=0
Rz18 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz19 (\36\:VSS \35\:VSS) resistor r=75 c=0
Rz20 (\40\:VSS \39\:VSS) resistor r=75 c=0
Rz21 (\44\:VSS \43\:VSS) resistor r=75 c=0
Rz4 (\4\:net345 \5\:net345) resistor r=75 c=0
Rz1 (\17\:net333 \16\:net333) resistor r=75 c=0
Rz5 (\4\:net353 \5\:net353) resistor r=75 c=0
Rz6 (\5\:net361 \6\:net361) resistor r=75 c=0
Rz7 (\9\:net369 \10\:net369) resistor r=75 c=0
Rz8 (\9\:net377 \10\:net377) resistor r=75 c=0
Rz9 (\4\:net385 \5\:net385) resistor r=75 c=0
Rz10 (\5\:net393 \6\:net393) resistor r=75 c=0
Rz11 (\8\:net397 \9\:net397) resistor r=75 c=0
Ry12 (\35\:VDD \34\:VDD) resistor r=62 c=0
Ry13 (\37\:VDD \36\:VDD) resistor r=62 c=0
Ry14 (\41\:VDD \40\:VDD) resistor r=62 c=0
Ry15 (\44\:VDD \43\:VDD) resistor r=62 c=0
Ry19 (\17\:VSS \16\:VSS) resistor r=20.6667 c=0
Ry20 (\19\:VSS \16\:VSS) resistor r=15.5 c=0
Ry21 (\21\:VSS \16\:VSS) resistor r=31 c=0
Ry22 (\25\:VSS \16\:VSS) resistor r=5.6364 c=0
Ry23 (\30\:VSS \16\:VSS) resistor r=5.6364 c=0
Ry4 (\6\:net345 \7\:net345) resistor r=62 c=0
Ry1 (\19\:net333 \18\:net333) resistor r=20.6667 c=0
Ry5 (\6\:net353 \7\:net353) resistor r=62 c=0
Ry7 (\8\:net361 \9\:net361) resistor r=62 c=0
Ry6 (\6\:net369 \7\:net369) resistor r=62 c=0
Ry8 (\5\:net377 \6\:net377) resistor r=62 c=0
Ry9 (\8\:net385 \9\:net385) resistor r=62 c=0
Ry10 (\7\:net393 \8\:net393) resistor r=62 c=0
Ry11 (\4\:net397 \5\:net397) resistor r=62 c=0
Rx3 (\16\:VDD \6\:VDD) resistor r=45 c=0
Rx4 (\17\:VDD \2\:VDD) resistor r=45 c=0
Rx16 (\38\:VDD \11\:VDD) resistor r=45 c=0
Rx17 (\39\:VDD \14\:VDD) resistor r=45 c=0
Rx18 (\42\:VDD \7\:VDD) resistor r=45 c=0
Rx14 (\2\:A \4\:A) resistor r=45 c=0
Rx19 (\34\:VSS \12\:VSS) resistor r=45 c=0
Rx20 (\37\:VSS \10\:VSS) resistor r=45 c=0
Rx21 (\38\:VSS \8\:VSS) resistor r=45 c=0
Rx22 (\41\:VSS \6\:VSS) resistor r=45 c=0
Rx23 (\42\:VSS \4\:VSS) resistor r=45 c=0
Rx24 (\45\:VSS \2\:VSS) resistor r=45 c=0
Rx2 (\2\:net345 \8\:net345) resistor r=45 c=0
Rx1 (\15\:net333 net333) resistor r=45 c=0
Rx5 (net353 \8\:net353) resistor r=45 c=0
Rx6 (\3\:net361 \7\:net361) resistor r=45 c=0
Rx8 (\4\:net361 \10\:net361) resistor r=45 c=0
Rx7 (\4\:net369 \8\:net369) resistor r=45 c=0
Rx9 (\2\:net369 \11\:net369) resistor r=45 c=0
Rx10 (net377 \8\:net377) resistor r=45 c=0
Rx11 (\4\:net377 \11\:net377) resistor r=45 c=0
Rx12 (\2\:net385 \7\:net385) resistor r=45 c=0
Rx13 (\3\:net393 \4\:net393) resistor r=45 c=0
Rx15 (\2\:net397 \7\:net397) resistor r=45 c=0
mn15 (\16\:net333 net345 \30\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.18212e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn16_1__rcx (Y net333 \30\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.223e-14 ad=4.16e-14 ps=8.725e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.77115e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(4)
mn13 (net341 \3\:net353 \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.413e-14 ad=1.668e-14 ps=9.7e-07 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23e-06 sb=3e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn14 (\4\:net345 \1\:VDD net341 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=1.668e-14 ad=2.03e-14 ps=5.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn11 (net349 \2\:net361 \43\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.85e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn8 (\9\:net369 \9\:VDD net365 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.538e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn12 (\4\:net353 \8\:VDD net349 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=2.61e-14 ps=4.1e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.8e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn10 (\5\:net361 \3\:VDD net357 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.003e-14 ad=2.03e-14 ps=9.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.205e-06 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn9 (net357 \5\:net369 \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.365e-14 ad=5.003e-14 ps=1.18e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=8.15e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn7 (net365 \3\:net377 \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.365e-14 ad=2.538e-14 ps=1.18e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=3.6e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn6 (\9\:net377 \10\:VDD net373 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=1.668e-14 ad=4.785e-14 ps=5.2e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=7.65e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn4 (\4\:net385 \15\:VDD net381 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.103e-14 ad=2.03e-14 ps=5.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.55e-07 sb=1.4e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn5 (net373 \3\:net385 \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.175e-14 ad=1.668e-14 ps=1.39e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=6.05e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn3 (net381 \2\:net393 \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.175e-14 ad=2.103e-14 ps=1.39e-06 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=3.3e-07 sd=160n sca=11.4452 \
        scb=0.0112553 scc=0.00042156 m=(1)
mn2 (\5\:net393 \12\:VDD net389 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.537e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.65e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn1 (net389 net397 \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.537e-14 ps=6.1e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=3.45e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn0 (\8\:net397 \3\:A \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp16_1__rcx (Y net333 \30\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.078e-14 ad=6.727e-14 ps=1.3375e-06 pd=1.125e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.10981e-06 sd=160n sca=32.7095 \
        scb=0.022203 scc=0.00336849 m=(4)
mp13 (net276 \2\:net353 \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.772e-14 ad=3.225e-14 ps=1.39e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.375e-06 sb=3.35e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp14 (\6\:net345 \1\:VSS net276 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.225e-14 ad=3.01e-14 ps=7.3e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57e-06 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp11 (net284 net361 \43\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.555e-14 ad=1.29e-14 ps=9.2e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2.45e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp12 (\6\:net353 \3\:VSS net284 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.4e-07 sd=160n sca=10.1832 \
        scb=0.00742094 scc=7.76436e-05 m=(1)
mp8 (\6\:net369 \5\:VSS net300 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.8e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp7 (net300 \2\:net377 \40\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.0208e-13 ad=1.29e-14 ps=1.68e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.75e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp9 (net292 net369 \40\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0208e-13 ad=1.29e-14 ps=1.68e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=2.45e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp10 (\8\:net361 \7\:VSS net292 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=1.4e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp6 (\5\:net377 \9\:VSS net308 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.332e-14 ad=3.225e-14 ps=7.4e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=7.2e-07 sd=160n sca=37.431 scb=0.0268495 \
        scc=0.00487383 m=(1)
mp5 (net308 net385 \36\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=3.332e-14 ps=8.9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=5.2e-07 sd=160n sca=37.431 scb=0.0268495 \
        scc=0.00487383 m=(1)
mp3 (net316 net393 \36\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=1.29e-14 ps=8.9e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2.45e-07 sd=160n sca=37.431 \
        scb=0.0268495 scc=0.00487383 m=(1)
mp4 (\8\:net385 \13\:VSS net316 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.4e-07 sd=160n sca=37.431 scb=0.0268495 \
        scc=0.00487383 m=(1)
mp2 (\7\:net393 \11\:VSS net324 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.1e-07 sd=160n sca=31.4533 \
        scb=0.0258077 scc=0.00372922 m=(1)
mp1 (net324 \3\:net397 \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.049e-13 ad=1.29e-14 ps=1.83e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=4.05e-07 sd=160n sca=32.5509 \
        scb=0.0273823 scc=0.00374133 m=(1)
mp0 (\4\:net397 \1\:A \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.049e-13 ad=3.01e-14 ps=1.83e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.1e-07 sb=1.4e-07 sd=160n sca=43.5704 \
        scb=0.0437218 scc=0.0051335 m=(1)
ends DLY4X4
// End of subcircuit definition.

// Generated for: spectre (May  9 14:44:02 2012 )
// Library name: gsclib045
// Cell name: EDFFHQX1
// View name: extracted

simulator lang=spectre

subckt EDFFHQX1 CK D E Q VDD VSS
mp20 (\12\:CKb \3\:CK \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=18.8664 \
        scb=0.0202043 scc=0.000597023 m=(1)
C1 (E VSS) capacitor c=3.69451e-17
C2 (D VSS) capacitor c=8.7158e-17
C3 (VDD VSS) capacitor c=3.09211e-16
C4 (CK VSS) capacitor c=1.16523e-16
C5 (Q VSS) capacitor c=2.82708e-17
C6 (CKb VSS) capacitor c=9.61285e-17
C7 (CKbb VSS) capacitor c=3.5695e-17
C8 (n20 VSS) capacitor c=5.25646e-17
C9 (Db VSS) capacitor c=1.12115e-16
C10 (net340 VSS) capacitor c=1.32881e-18
C11 (mout VSS) capacitor c=2.97252e-17
C12 (n30 VSS) capacitor c=6.74916e-17
C13 (net380 VSS) capacitor c=1.32746e-18
C14 (qbint VSS) capacitor c=3.80767e-17
C15 (Eb VSS) capacitor c=4.12487e-17
C16 (net333 VSS) capacitor c=4.74274e-19
C17 (net309 VSS) capacitor c=3.74264e-18
C18 (net317 VSS) capacitor c=6.19106e-18
C19 (net328 VSS) capacitor c=4.71904e-18
C20 (\5\:E VSS) capacitor c=4.6836e-17
C21 (\1\:D VSS) capacitor c=5.57299e-17
C22 (\1\:E VSS) capacitor c=5.34039e-17
C23 (\8\:qbint VSS) capacitor c=4.69927e-17
C24 (\7\:CKbb VSS) capacitor c=5.30236e-17
C25 (\2\:CKb VSS) capacitor c=1.11081e-16
C26 (\4\:mout VSS) capacitor c=4.70965e-17
C27 (\3\:CKb VSS) capacitor c=1.36625e-16
C28 (\6\:CKb VSS) capacitor c=5.8431e-17
C29 (\3\:CK VSS) capacitor c=3.46145e-17
C30 (\7\:E VSS) capacitor c=3.03065e-17
C31 (\3\:D VSS) capacitor c=8.31268e-17
C32 (\3\:E VSS) capacitor c=6.64065e-17
C33 (\3\:Eb VSS) capacitor c=6.2806e-17
C34 (\4\:n30 VSS) capacitor c=2.12121e-17
C35 (\7\:qbint VSS) capacitor c=2.44181e-17
C36 (\5\:qbint VSS) capacitor c=4.5585e-17
C37 (\5\:CKbb VSS) capacitor c=3.10124e-17
C38 (\3\:n20 VSS) capacitor c=3.35801e-17
C39 (\3\:mout VSS) capacitor c=5.176e-17
C40 (\3\:CKbb VSS) capacitor c=3.84182e-17
C41 (\7\:CKb VSS) capacitor c=2.24886e-17
C42 (\9\:CKb VSS) capacitor c=2.26989e-17
C43 (\1\:CK VSS) capacitor c=5.30915e-17
C44 (\6\:E VSS) capacitor c=3.26266e-17
C45 (\2\:D VSS) capacitor c=5.69991e-17
C46 (\2\:Eb VSS) capacitor c=5.84334e-17
C47 (\4\:E VSS) capacitor c=4.82949e-17
C48 (\2\:E VSS) capacitor c=3.31158e-17
C49 (\3\:n30 VSS) capacitor c=1.25575e-17
C50 (\6\:qbint VSS) capacitor c=3.21088e-17
C51 (\8\:CKbb VSS) capacitor c=5.21916e-17
C52 (\6\:CKbb VSS) capacitor c=3.20248e-17
C53 (\2\:n20 VSS) capacitor c=3.23185e-17
C54 (\4\:CKbb VSS) capacitor c=3.72633e-17
C55 (\2\:CKbb VSS) capacitor c=3.99761e-17
C56 (\8\:CKb VSS) capacitor c=1.87958e-17
C57 (\2\:CK VSS) capacitor c=5.44907e-17
C58 (\6\:Eb VSS) capacitor c=1.1243e-16
C59 (\1\:VDD VSS) capacitor c=4.71006e-17
C60 (\3\:Db VSS) capacitor c=3.21013e-16
C61 (\9\:qbint VSS) capacitor c=4.95062e-17
C62 (\11\:VDD VSS) capacitor c=3.45825e-17
C63 (\3\:Q VSS) capacitor c=4.50454e-17
C64 (\13\:VDD VSS) capacitor c=3.65988e-17
C65 (\9\:n30 VSS) capacitor c=8.27857e-17
C66 (\5\:mout VSS) capacitor c=4.32468e-17
C67 (\15\:VDD VSS) capacitor c=4.6749e-17
C68 (\4\:n20 VSS) capacitor c=3.40864e-17
C69 (\5\:Db VSS) capacitor c=3.0323e-16
C70 (\15\:CKbb VSS) capacitor c=7.00021e-17
C71 (\17\:VDD VSS) capacitor c=3.38871e-17
C72 (\12\:CKb VSS) capacitor c=7.28727e-17
C73 (\3\:VDD VSS) capacitor c=5.95145e-17
C74 (\4\:Eb VSS) capacitor c=8.3211e-17
C75 (\13\:qbint VSS) capacitor c=5.70635e-17
C76 (\1\:Q VSS) capacitor c=6.12022e-17
C77 (\7\:n30 VSS) capacitor c=5.79748e-17
C78 (\9\:mout VSS) capacitor c=5.90218e-17
C79 (\7\:n20 VSS) capacitor c=6.83776e-17
C80 (\7\:Db VSS) capacitor c=9.43056e-17
C81 (\13\:CKbb VSS) capacitor c=1.09276e-16
C82 (\14\:CKb VSS) capacitor c=1.99512e-17
C83 (\2\:mout VSS) capacitor c=2.7586e-17
C84 (\4\:CKb VSS) capacitor c=5.2738e-17
C85 (\5\:CKb VSS) capacitor c=4.30148e-17
C86 (\2\:qbint VSS) capacitor c=1.31368e-17
C87 (\3\:qbint VSS) capacitor c=6.70585e-18
C88 (\4\:qbint VSS) capacitor c=4.08638e-17
C89 (\2\:n30 VSS) capacitor c=3.4642e-17
C90 (\10\:CKb VSS) capacitor c=3.51846e-17
C91 (\11\:CKb VSS) capacitor c=7.92181e-17
C92 (\6\:n20 VSS) capacitor c=8.43118e-17
C93 (\9\:n20 VSS) capacitor c=8.9108e-17
C94 (\7\:mout VSS) capacitor c=4.78973e-17
C95 (\8\:mout VSS) capacitor c=6.24119e-17
C96 (\9\:CKbb VSS) capacitor c=6.29574e-17
C97 (\10\:CKbb VSS) capacitor c=1.2825e-16
C98 (\11\:CKbb VSS) capacitor c=1.11267e-16
C99 (\12\:CKbb VSS) capacitor c=7.54837e-17
C100 (\17\:CKbb VSS) capacitor c=5.35434e-17
C101 (\18\:CKbb VSS) capacitor c=6.75396e-17
C102 (\5\:n30 VSS) capacitor c=1.30286e-16
C103 (\6\:n30 VSS) capacitor c=1.3794e-16
C104 (\11\:qbint VSS) capacitor c=5.9391e-17
C105 (\12\:qbint VSS) capacitor c=4.92363e-17
C106 (\8\:E VSS) capacitor c=1.47919e-16
C107 (\9\:E VSS) capacitor c=1.15262e-16
C108 (\10\:E VSS) capacitor c=3.26339e-17
C109 (\11\:E VSS) capacitor c=4.01258e-17
C110 (\4\:D VSS) capacitor c=5.22029e-17
C111 (\8\:Eb VSS) capacitor c=7.80595e-17
C112 (\5\:VDD VSS) capacitor c=1.53587e-17
C113 (\6\:VDD VSS) capacitor c=3.68057e-17
C114 (\7\:VDD VSS) capacitor c=3.17995e-17
C115 (\9\:VDD VSS) capacitor c=2.13948e-17
Rk29 (\8\:E \9\:E) resistor r=0.9065 c=0
Rk30 (\9\:E \10\:E) resistor r=0.08499 c=0
Rk32 (\11\:E E) resistor r=0.053 c=0
Rk31 (\9\:E \11\:E) resistor r=0.2237 c=0
Rk36 (\2\:VSS \4\:VSS) resistor r=0.6062 c=0
Rk37 (\4\:VSS \5\:VSS) resistor r=0.2154 c=0
Rk38 (\5\:VSS \6\:VSS) resistor r=0.3606 c=0
Rk39 (\6\:VSS \7\:VSS) resistor r=0.5211 c=0
Rk40 (\7\:VSS \8\:VSS) resistor r=0.05496 c=0
Rk41 (\8\:VSS \9\:VSS) resistor r=0.599 c=0
Rk43 (\10\:VSS VSS) resistor r=0.04989 c=0
Rk42 (\9\:VSS \10\:VSS) resistor r=0.1026 c=0
Rk44 (\5\:VSS \12\:VSS) resistor r=0.271 c=0
Rk45 (\6\:VSS \14\:VSS) resistor r=0.2827 c=0
Rk46 (\7\:VSS \16\:VSS) resistor r=0.1224 c=0
Rk47 (\9\:VSS \18\:VSS) resistor r=0.2529 c=0
Rk33 (D \4\:D) resistor r=0.03958 c=0
Rk48 (\2\:VDD \4\:VDD) resistor r=0.5324 c=0
Rk49 (\4\:VDD \5\:VDD) resistor r=0.1878 c=0
Rk50 (\5\:VDD \6\:VDD) resistor r=0.3355 c=0
Rk51 (\6\:VDD \7\:VDD) resistor r=0.5737 c=0
Rk52 (\7\:VDD \8\:VDD) resistor r=0.05496 c=0
Rk53 (\8\:VDD \9\:VDD) resistor r=0.619 c=0
Rk55 (\10\:VDD VDD) resistor r=0.04989 c=0
Rk54 (\9\:VDD \10\:VDD) resistor r=0.08253 c=0
Rk56 (\5\:VDD \12\:VDD) resistor r=0.1957 c=0
Rk57 (\6\:VDD \14\:VDD) resistor r=0.1957 c=0
Rk58 (\7\:VDD \16\:VDD) resistor r=0.2919 c=0
Rk59 (\9\:VDD \18\:VDD) resistor r=0.1966 c=0
Rk1 (\4\:CK CK) resistor r=0.002999 c=0
Rk18 (\2\:Q Q) resistor r=0.1572 c=0
Rk19 (Q \4\:Q) resistor r=0.1049 c=0
Rk2 (\10\:CKb \11\:CKb) resistor r=0.2077 c=0
Rk3 (\11\:CKb \13\:CKb) resistor r=0.6388 c=0
Rk4 (\11\:CKb \15\:CKb) resistor r=0.1003 c=0
Rk11 (\9\:CKbb \10\:CKbb) resistor r=0.2447 c=0
Rk12 (\10\:CKbb \11\:CKbb) resistor r=0.8878 c=0
Rk13 (\11\:CKbb \12\:CKbb) resistor r=0.2837 c=0
Rk14 (\12\:CKbb \14\:CKbb) resistor r=0.2845 c=0
Rk15 (\14\:CKbb \16\:CKbb) resistor r=0.6667 c=0
Rk16 (\11\:CKbb \17\:CKbb) resistor r=0.2247 c=0
Rk17 (\12\:CKbb \18\:CKbb) resistor r=0.3613 c=0
Rk5 (\5\:n20 \6\:n20) resistor r=0.1174 c=0
Rk6 (\6\:n20 \8\:n20) resistor r=0.2631 c=0
Rk7 (\6\:n20 \9\:n20) resistor r=0.5876 c=0
Rk26 (\2\:Db \4\:Db) resistor r=0.5934 c=0
Rk27 (\4\:Db \6\:Db) resistor r=2.4551 c=0
Rk28 (\6\:Db \8\:Db) resistor r=0.5402 c=0
Rk8 (\6\:mout \7\:mout) resistor r=0.1196 c=0
Rk9 (\7\:mout \8\:mout) resistor r=0.228 c=0
Rk10 (\7\:mout \10\:mout) resistor r=0.2628 c=0
Rk20 (\5\:n30 \6\:n30) resistor r=0.9078 c=0
Rk21 (\6\:n30 \8\:n30) resistor r=0.2329 c=0
Rk22 (\6\:n30 \10\:n30) resistor r=0.4348 c=0
Rk23 (\10\:qbint \11\:qbint) resistor r=0.2292 c=0
Rk24 (\11\:qbint \12\:qbint) resistor r=0.2451 c=0
Rk25 (\11\:qbint \14\:qbint) resistor r=0.2442 c=0
Rk34 (\5\:Eb \7\:Eb) resistor r=0.6874 c=0
Rk35 (\7\:Eb \8\:Eb) resistor r=0.484 c=0
Rl36 (\5\:E \6\:E) resistor r=95.3288 c=0
Rl37 (\6\:E \7\:E) resistor r=35.7134 c=0
Rl31 (\3\:E \4\:E) resistor r=28.079 c=0
Rl30 (\1\:E \2\:E) resistor r=46.5349 c=0
Rl34 (\1\:D \2\:D) resistor r=24.2328 c=0
Rl35 (\2\:D \3\:D) resistor r=101.156 c=0
Rl2 (\2\:CK \3\:CK) resistor r=58.7903 c=0
Rl1 (\1\:CK \2\:CK) resistor r=195.329 c=0
Rl11 (CKb \2\:CKb) resistor r=203.045 c=0
Rl12 (\2\:CKb \3\:CKb) resistor r=524.566 c=0
Rl18 (\8\:CKb \9\:CKb) resistor r=26.098 c=0
Rl13 (\3\:CKb \4\:CKb) resistor r=245.697 c=0
Rl16 (\4\:CKb \7\:CKb) resistor r=30.4507 c=0
Rl15 (\5\:CKb \6\:CKb) resistor r=206.36 c=0
Rl17 (\5\:CKb \8\:CKb) resistor r=12.0714 c=0
Rl14 (\4\:CKb \5\:CKb) resistor r=172.352 c=0
Rl19 (\7\:CKbb \8\:CKbb) resistor r=47.3097 c=0
Rl10 (\5\:CKbb \6\:CKbb) resistor r=48.7687 c=0
Rl4 (\3\:CKbb \4\:CKbb) resistor r=29.5379 c=0
Rl3 (CKbb \2\:CKbb) resistor r=46.417 c=0
Rl8 (n20 \2\:n20) resistor r=98.7687 c=0
Rl9 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl5 (mout \2\:mout) resistor r=16.2873 c=0
Rl7 (\2\:mout \4\:mout) resistor r=45.868 c=0
Rl6 (\2\:mout \3\:mout) resistor r=99.7141 c=0
Rl27 (n30 \2\:n30) resistor r=171.462 c=0
Rl29 (\2\:n30 \4\:n30) resistor r=23.7402 c=0
Rl28 (\2\:n30 \3\:n30) resistor r=5.1011 c=0
Rl20 (qbint \2\:qbint) resistor r=72.3105 c=0
Rl24 (\2\:qbint \6\:qbint) resistor r=104.219 c=0
Rl25 (\3\:qbint \7\:qbint) resistor r=35.772 c=0
Rl21 (\2\:qbint \3\:qbint) resistor r=17.6978 c=0
Rl26 (\4\:qbint \8\:qbint) resistor r=93.4643 c=0
Rl23 (\4\:qbint \5\:qbint) resistor r=68.03 c=0
Rl22 (\3\:qbint \4\:qbint) resistor r=87.8245 c=0
Rl32 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl33 (\2\:Eb \3\:Eb) resistor r=135.217 c=0
Rz11 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz12 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz13 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz14 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz15 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz16 (\3\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz17 (\3\:VDD \8\:VDD) resistor r=6.25 c=0
Rz18 (\3\:VDD \10\:VDD) resistor r=37.5 c=0
Rz5 (\1\:Q \2\:Q) resistor r=75 c=0
Rz1 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz4 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz2 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\9\:mout \10\:mout) resistor r=75 c=0
Rz6 (\7\:n30 \8\:n30) resistor r=75 c=0
Rz7 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz10 (\4\:Eb \5\:Eb) resistor r=75 c=0
Ry11 (\3\:VSS \4\:VSS) resistor r=5.6364 c=0
Ry12 (\3\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry13 (\3\:VSS \10\:VSS) resistor r=31 c=0
Ry14 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry15 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry16 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry17 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry18 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry5 (\3\:Q \4\:Q) resistor r=62 c=0
Ry1 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry4 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry2 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry8 (\3\:Db \4\:Db) resistor r=20.6667 c=0
Ry9 (\5\:Db \6\:Db) resistor r=31 c=0
Ry3 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\9\:n30 \10\:n30) resistor r=62 c=0
Ry7 (\9\:qbint \10\:qbint) resistor r=62 c=0
Ry10 (\6\:Eb \7\:Eb) resistor r=62 c=0
Rx11 (\2\:E \8\:E) resistor r=45 c=0
Rx12 (\4\:E \10\:E) resistor r=45 c=0
Rx13 (\6\:E \11\:E) resistor r=45 c=0
Rx14 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\8\:CKb \10\:CKb) resistor r=45 c=0
Rx5 (\8\:CKbb \9\:CKbb) resistor r=45 c=0
Rx6 (\6\:CKbb \10\:CKbb) resistor r=45 c=0
Rx7 (\4\:CKbb \17\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx4 (mout \8\:mout) resistor r=45 c=0
Rx9 (\3\:n30 \5\:n30) resistor r=45 c=0
Rx10 (\6\:qbint \12\:qbint) resistor r=45 c=0
Rx15 (\2\:Eb \8\:Eb) resistor r=45 c=0
mn20 (\14\:CKb \1\:CK \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn21 (\13\:CKbb \9\:CKb \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.9e-14 ps=6.1e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn25 (\7\:n20 \7\:CKb \7\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=8.098e-14 ps=6.9e-07 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.4389 scb=0.0137383 \
        scc=0.000784938 m=(1)
mn36 (\7\:n20 \3\:CKbb net340 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.075e-14 ad=8.098e-14 ps=7.1e-07 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=1.755e-06 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn35 (net340 \3\:mout \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.945e-14 ad=3.075e-14 ps=1.38e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=1.56e-06 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn30 (\9\:mout \3\:n20 \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.945e-14 ad=6.252e-14 ps=1.38e-06 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=1.265e-06 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn40 (\9\:mout \5\:CKbb \7\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.638e-14 ad=6.252e-14 ps=9.6e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=9.15e-07 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn51 (\7\:n30 CKb net380 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.638e-14 ps=5.3e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=5.95e-07 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn50 (net380 \5\:qbint \13\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.598e-14 ad=1.23e-14 ps=1.11e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=4.9e-07 sd=160n sca=13.4389 \
        scb=0.0137383 scc=0.000784938 m=(1)
mn55 (\1\:Q \7\:qbint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.598e-14 ad=3.9e-14 ps=1.11e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59808e-06 sb=1.5e-07 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(1)
mn45 (\13\:qbint \4\:n30 \11\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.87e-14 ad=9.16e-14 ps=6.9e-07 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.07951e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn1 (\13\:qbint \3\:Eb Db VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.42e-14 ad=9.16e-14 ps=8.6e-07 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.98173e-07 sb=5.73365e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3 (Db \3\:E net333 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.42e-14 ps=6.4e-07 pd=8.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.13173e-07 sb=3.58365e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn2 (net333 \3\:D \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.18173e-07 sb=2.53365e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn0 (\4\:Eb \7\:E \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.905e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.16e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp21 (\15\:CKbb \6\:CKb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.8049 \
        scb=0.0100559 scc=8.95671e-05 m=(1)
mp25 (\4\:n20 CKbb \5\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.98e-06 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp36 (\4\:n20 \3\:CKb net309 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=4.96e-14 ps=9.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.775e-06 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp35 (net309 \4\:mout \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.75e-14 ad=5.58e-14 ps=1.12e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.55e-06 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp30 (\5\:mout n20 \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.75e-14 ad=1.364e-13 ps=1.12e-06 pd=1.5e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.65e-07 sb=1.255e-06 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp40 (\5\:mout \2\:CKb \9\:n30 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=1.364e-13 ps=9.4e-07 pd=1.5e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.35e-06 sb=7.7e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp51 (\9\:n30 \7\:CKbb net317 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.565e-14 ad=4.96e-14 ps=8.5e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.555e-06 sb=5.65e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp50 (net317 \8\:qbint \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.78e-14 ad=3.565e-14 ps=1.32e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.715e-06 sb=4.05e-07 sd=160n sca=15.5687 \
        scb=0.0146164 scc=0.00101158 m=(1)
mp55 (\3\:Q qbint \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.78e-14 ad=5.46e-14 ps=1.32e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.60872e-06 sb=1.4e-07 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp45 (\9\:qbint n30 \11\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.17e-14 ad=7.01e-14 ps=1.11e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=9.12339e-07 sd=160n sca=12.4967 \
        scb=0.0111079 scc=0.00042389 m=(1)
mp1 (\9\:qbint \1\:E \3\:Db VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.19e-14 ad=7.01e-14 ps=1.2e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.50641e-07 sb=7.04551e-07 sd=160n sca=16.2669 \
        scb=0.0145797 scc=0.00118861 m=(1)
mp3 (\3\:Db Eb net328 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=8.19e-14 ps=1.05e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.05641e-07 sb=4.49551e-07 sd=160n sca=16.5949 \
        scb=0.0146729 scc=0.00118863 m=(1)
mp2 (net328 \1\:D \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.265e-14 ps=1.16e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.85641e-07 sb=2.69551e-07 sd=160n sca=17.3384 \
        scb=0.0151709 scc=0.00118918 m=(1)
mp0 (\6\:Eb \5\:E \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.76395e-07 sb=1.4e-07 sd=160n sca=24.8073 \
        scb=0.0246729 scc=0.00213017 m=(1)
ends EDFFHQX1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:44:40 2012 )
// Library name: gsclib045
// Cell name: EDFFHQX2
// View name: extracted

simulator lang=spectre

subckt EDFFHQX2 CK D E Q VDD VSS
mp20 (\15\:CKb \1\:CK \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=3.7e-07 sd=160n sca=22.5547 \
        scb=0.0255076 scc=0.00117617 m=(1)
C1 (E VSS) capacitor c=7.82829e-17
C2 (D VSS) capacitor c=4.06269e-17
C3 (VDD VSS) capacitor c=3.07599e-16
C4 (CK VSS) capacitor c=6.77499e-17
C5 (Q VSS) capacitor c=3.73355e-17
C6 (CKb VSS) capacitor c=8.71823e-17
C7 (CKbb VSS) capacitor c=3.9113e-17
C8 (n20 VSS) capacitor c=4.84625e-17
C9 (Db VSS) capacitor c=1.20242e-16
C10 (net340 VSS) capacitor c=2.80762e-18
C11 (mout VSS) capacitor c=1.88678e-17
C12 (n30 VSS) capacitor c=5.65346e-17
C13 (qbint VSS) capacitor c=1.51412e-16
C14 (Eb VSS) capacitor c=3.32814e-17
C15 (net333 VSS) capacitor c=5.79558e-18
C16 (net309 VSS) capacitor c=6.00201e-18
C17 (net317 VSS) capacitor c=3.54272e-18
C18 (net328 VSS) capacitor c=6.49179e-18
C19 (\5\:E VSS) capacitor c=4.51675e-17
C20 (\1\:D VSS) capacitor c=4.77143e-17
C21 (\1\:E VSS) capacitor c=3.72852e-17
C22 (\10\:qbint VSS) capacitor c=7.49162e-17
C23 (\7\:CKbb VSS) capacitor c=7.26996e-17
C24 (\2\:CKb VSS) capacitor c=1.06505e-16
C25 (\4\:mout VSS) capacitor c=4.07721e-17
C26 (\3\:CKb VSS) capacitor c=1.27295e-16
C27 (\9\:CKb VSS) capacitor c=4.82985e-17
C28 (\1\:CK VSS) capacitor c=3.77215e-17
C29 (\7\:E VSS) capacitor c=2.32079e-17
C30 (\3\:D VSS) capacitor c=3.4745e-17
C31 (\3\:E VSS) capacitor c=3.76826e-17
C32 (\3\:Eb VSS) capacitor c=5.77139e-17
C33 (\4\:n30 VSS) capacitor c=2.01706e-17
C34 (\6\:qbint VSS) capacitor c=3.53912e-17
C35 (\5\:CKbb VSS) capacitor c=3.48818e-17
C36 (\3\:n20 VSS) capacitor c=2.92406e-17
C37 (\3\:mout VSS) capacitor c=4.17642e-17
C38 (\3\:CKbb VSS) capacitor c=3.29388e-17
C39 (\8\:CKb VSS) capacitor c=2.24704e-17
C40 (\10\:CKb VSS) capacitor c=2.28561e-17
C41 (\3\:CK VSS) capacitor c=4.24345e-17
C42 (\6\:E VSS) capacitor c=3.72231e-17
C43 (\2\:D VSS) capacitor c=3.83084e-17
C44 (\4\:Eb VSS) capacitor c=3.58626e-17
C45 (\4\:E VSS) capacitor c=4.43358e-17
C46 (\2\:E VSS) capacitor c=2.74405e-17
C47 (\3\:n30 VSS) capacitor c=1.66436e-17
C48 (\8\:CKbb VSS) capacitor c=5.40645e-17
C49 (\6\:CKbb VSS) capacitor c=2.72081e-17
C50 (\2\:n20 VSS) capacitor c=3.4804e-17
C51 (\4\:CKbb VSS) capacitor c=3.68669e-17
C52 (\2\:CKbb VSS) capacitor c=3.37656e-17
C53 (\7\:CKb VSS) capacitor c=2.52981e-17
C54 (\2\:CK VSS) capacitor c=5.11135e-17
C55 (\5\:Eb VSS) capacitor c=1.10914e-17
C56 (\11\:VDD VSS) capacitor c=3.14289e-17
C57 (\3\:Db VSS) capacitor c=3.19242e-16
C58 (\15\:qbint VSS) capacitor c=3.88761e-17
C59 (\4\:Q VSS) capacitor c=4.24598e-17
C60 (\8\:n30 VSS) capacitor c=8.28363e-17
C61 (\5\:mout VSS) capacitor c=3.69538e-17
C62 (\17\:VDD VSS) capacitor c=4.97132e-17
C63 (\8\:n20 VSS) capacitor c=3.85877e-17
C64 (\5\:Db VSS) capacitor c=3.12228e-16
C65 (\17\:CKbb VSS) capacitor c=7.54552e-17
C66 (\19\:VDD VSS) capacitor c=3.37779e-17
C67 (\15\:CKb VSS) capacitor c=5.30494e-17
C68 (\1\:VDD VSS) capacitor c=9.1962e-17
C69 (\9\:Eb VSS) capacitor c=7.17928e-17
C70 (\11\:qbint VSS) capacitor c=5.8088e-17
C71 (\2\:Q VSS) capacitor c=5.74027e-17
C72 (\5\:n30 VSS) capacitor c=5.43696e-17
C73 (\9\:mout VSS) capacitor c=7.47879e-17
C74 (\6\:n20 VSS) capacitor c=7.27969e-17
C75 (\7\:Db VSS) capacitor c=9.80743e-17
C76 (\12\:CKbb VSS) capacitor c=1.05305e-16
C77 (\13\:CKb VSS) capacitor c=1.97929e-17
C78 (\2\:mout VSS) capacitor c=2.40076e-17
C79 (\4\:CKb VSS) capacitor c=5.04634e-17
C80 (\5\:CKb VSS) capacitor c=4.32058e-17
C81 (\5\:qbint VSS) capacitor c=3.89035e-17
C82 (\2\:n30 VSS) capacitor c=1.97102e-17
C83 (\2\:Eb VSS) capacitor c=3.94434e-17
C84 (\4\:CK VSS) capacitor c=4.54591e-17
C85 (\11\:CKb VSS) capacitor c=4.25176e-17
C86 (\12\:CKb VSS) capacitor c=4.49398e-17
C87 (\4\:n20 VSS) capacitor c=1.12762e-16
C88 (\5\:n20 VSS) capacitor c=7.6061e-17
C89 (\7\:mout VSS) capacitor c=5.10102e-17
C90 (\8\:mout VSS) capacitor c=6.06342e-17
C91 (\9\:CKbb VSS) capacitor c=1.6296e-16
C92 (\10\:CKbb VSS) capacitor c=1.64176e-16
C93 (\11\:CKbb VSS) capacitor c=8.00028e-17
C94 (\14\:CKbb VSS) capacitor c=5.7957e-17
C95 (\15\:CKbb VSS) capacitor c=4.71834e-17
C96 (\16\:CKbb VSS) capacitor c=7.1731e-17
C97 (\1\:Q VSS) capacitor c=3.91305e-17
C98 (\7\:n30 VSS) capacitor c=1.51021e-16
C99 (\10\:n30 VSS) capacitor c=1.41982e-16
C100 (\13\:qbint VSS) capacitor c=6.72922e-17
C101 (\14\:qbint VSS) capacitor c=5.47446e-17
C102 (\4\:D VSS) capacitor c=6.96862e-17
C103 (\9\:E VSS) capacitor c=1.3126e-16
C104 (\10\:E VSS) capacitor c=1.6096e-16
C105 (\11\:E VSS) capacitor c=4.4215e-17
C106 (\7\:Eb VSS) capacitor c=8.22475e-17
C107 (\8\:Eb VSS) capacitor c=8.37625e-17
C108 (\3\:VDD VSS) capacitor c=1.4014e-18
C109 (\5\:VDD VSS) capacitor c=1.25441e-16
C110 (\8\:VDD VSS) capacitor c=5.03754e-17
C111 (\10\:VDD VSS) capacitor c=1.36774e-17
Rk31 (E \8\:E) resistor r=0.005081 c=0
Rk32 (\8\:E \9\:E) resistor r=0.4616 c=0
Rk33 (\9\:E \10\:E) resistor r=0.9528 c=0
Rk34 (\9\:E \11\:E) resistor r=0.1737 c=0
Rk30 (D \4\:D) resistor r=0.02448 c=0
Rk52 (\2\:VSS \3\:VSS) resistor r=0.1678 c=0
Rk53 (\3\:VSS \4\:VSS) resistor r=0.5338 c=0
Rk54 (\3\:VSS \6\:VSS) resistor r=0.2736 c=0
Rk56 (\4\:VSS \8\:VSS) resistor r=0.5511 c=0
Rk57 (\8\:VSS \9\:VSS) resistor r=0.2279 c=0
Rk59 (\10\:VSS VSS) resistor r=0.09733 c=0
Rk58 (\9\:VSS \10\:VSS) resistor r=0.4536 c=0
Rk62 (\8\:VSS \16\:VSS) resistor r=0.2815 c=0
Rk63 (\10\:VSS \18\:VSS) resistor r=0.2627 c=0
Rk38 (\2\:VDD \3\:VDD) resistor r=0.1678 c=0
Rk39 (\3\:VDD \4\:VDD) resistor r=0.08253 c=0
Rk40 (\4\:VDD \5\:VDD) resistor r=0.5413 c=0
Rk43 (\5\:VDD \8\:VDD) resistor r=0.5687 c=0
Rk44 (\8\:VDD \9\:VDD) resistor r=0.4084 c=0
Rk46 (\10\:VDD VDD) resistor r=0.1124 c=0
Rk45 (\9\:VDD \10\:VDD) resistor r=0.2881 c=0
Rk47 (\3\:VDD \12\:VDD) resistor r=0.2203 c=0
Rk50 (\8\:VDD \18\:VDD) resistor r=0.269 c=0
Rk51 (\10\:VDD \20\:VDD) resistor r=0.2603 c=0
Rk1 (CK \4\:CK) resistor r=0.1473 c=0
Rk18 (Q \1\:Q) resistor r=0.07016 c=0
Rk19 (\1\:Q \3\:Q) resistor r=0.1659 c=0
Rk20 (\1\:Q \5\:Q) resistor r=0.1485 c=0
Rk2 (\11\:CKb \12\:CKb) resistor r=0.1752 c=0
Rk3 (\12\:CKb \14\:CKb) resistor r=0.1178 c=0
Rk4 (\12\:CKb \16\:CKb) resistor r=0.4258 c=0
Rk11 (\9\:CKbb \10\:CKbb) resistor r=1.2493 c=0
Rk12 (\10\:CKbb \11\:CKbb) resistor r=0.2837 c=0
Rk13 (\11\:CKbb \13\:CKbb) resistor r=0.313 c=0
Rk14 (\9\:CKbb \14\:CKbb) resistor r=0.2758 c=0
Rk15 (\10\:CKbb \15\:CKbb) resistor r=0.2391 c=0
Rk16 (\11\:CKbb \16\:CKbb) resistor r=0.3905 c=0
Rk17 (\13\:CKbb \18\:CKbb) resistor r=0.5662 c=0
Rk5 (\4\:n20 \5\:n20) resistor r=0.5759 c=0
Rk6 (\5\:n20 \7\:n20) resistor r=0.2867 c=0
Rk7 (\5\:n20 \9\:n20) resistor r=0.1411 c=0
Rk27 (\2\:Db \4\:Db) resistor r=0.6178 c=0
Rk28 (\4\:Db \6\:Db) resistor r=2.4126 c=0
Rk29 (\6\:Db \8\:Db) resistor r=0.6073 c=0
Rk8 (\6\:mout \7\:mout) resistor r=0.1174 c=0
Rk9 (\7\:mout \8\:mout) resistor r=0.271 c=0
Rk10 (\7\:mout \10\:mout) resistor r=0.2989 c=0
Rk21 (\6\:n30 \7\:n30) resistor r=0.2625 c=0
Rk22 (\7\:n30 \9\:n30) resistor r=0.4468 c=0
Rk23 (\7\:n30 \10\:n30) resistor r=0.9313 c=0
Rk24 (\12\:qbint \13\:qbint) resistor r=0.2788 c=0
Rk25 (\13\:qbint \14\:qbint) resistor r=0.2678 c=0
Rk26 (\13\:qbint \16\:qbint) resistor r=0.1276 c=0
Rk35 (\6\:Eb \7\:Eb) resistor r=0.04776 c=0
Rk36 (\7\:Eb \8\:Eb) resistor r=0.6174 c=0
Rk37 (\7\:Eb \10\:Eb) resistor r=0.6151 c=0
Rl40 (\5\:E \6\:E) resistor r=193 c=0
Rl41 (\6\:E \7\:E) resistor r=39.1533 c=0
Rl34 (\3\:E \4\:E) resistor r=24.2328 c=0
Rl33 (\1\:E \2\:E) resistor r=24.2328 c=0
Rl38 (\1\:D \2\:D) resistor r=74.2328 c=0
Rl39 (\2\:D \3\:D) resistor r=43.4636 c=0
Rl1 (\1\:CK \2\:CK) resistor r=110.713 c=0
Rl2 (\2\:CK \3\:CK) resistor r=95.3288 c=0
Rl11 (CKb \2\:CKb) resistor r=212.66 c=0
Rl12 (\2\:CKb \3\:CKb) resistor r=555.335 c=0
Rl13 (\3\:CKb \4\:CKb) resistor r=259.159 c=0
Rl17 (\4\:CKb \8\:CKb) resistor r=30.4507 c=0
Rl18 (\5\:CKb \9\:CKb) resistor r=172.31 c=0
Rl14 (\4\:CKb \5\:CKb) resistor r=153.047 c=0
Rl19 (\6\:CKb \10\:CKb) resistor r=34.3295 c=0
Rl16 (\6\:CKb \7\:CKb) resistor r=2.0166 c=0
Rl15 (\5\:CKb \6\:CKb) resistor r=22.0246 c=0
Rl20 (\7\:CKbb \8\:CKbb) resistor r=47.3097 c=0
Rl10 (\5\:CKbb \6\:CKbb) resistor r=24.2328 c=0
Rl4 (\3\:CKbb \4\:CKbb) resistor r=29.5379 c=0
Rl3 (CKbb \2\:CKbb) resistor r=46.417 c=0
Rl8 (n20 \2\:n20) resistor r=85.7713 c=0
Rl9 (\2\:n20 \3\:n20) resistor r=53.079 c=0
Rl5 (mout \2\:mout) resistor r=5.1171 c=0
Rl7 (\2\:mout \4\:mout) resistor r=34.3295 c=0
Rl6 (\2\:mout \3\:mout) resistor r=124.714 c=0
Rl30 (n30 \2\:n30) resistor r=103.56 c=0
Rl32 (\2\:n30 \4\:n30) resistor r=34.3295 c=0
Rl31 (\2\:n30 \3\:n30) resistor r=1.2666 c=0
Rl24 (\5\:qbint qbint) resistor r=134.566 c=0
Rl29 (\5\:qbint \10\:qbint) resistor r=114.618 c=0
Rl25 (\5\:qbint \6\:qbint) resistor r=49.2335 c=0
Rl35 (Eb \2\:Eb) resistor r=23.7402 c=0
Rl36 (\2\:Eb \3\:Eb) resistor r=126.865 c=0
Rl37 (\2\:Eb \4\:Eb) resistor r=33.6809 c=0
Rz15 (\6\:VSS \5\:VSS) resistor r=75 c=0
Rz18 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz19 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz11 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz12 (\4\:VDD \1\:VDD) resistor r=37.5 c=0
Rz13 (\5\:VDD \1\:VDD) resistor r=6.25 c=0
Rz14 (\9\:VDD \1\:VDD) resistor r=8.3333 c=0
Rz5 (\3\:Q \2\:Q) resistor r=75 c=0
Rz1 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz4 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz2 (\6\:n20 \7\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\9\:mout \10\:mout) resistor r=75 c=0
Rz6 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz7 (\12\:qbint \11\:qbint) resistor r=75 c=0
Rz10 (\9\:Eb \10\:Eb) resistor r=75 c=0
Ry16 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry17 (\4\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry18 (\9\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry11 (\12\:VDD \11\:VDD) resistor r=62 c=0
Ry14 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry15 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry5 (\5\:Q \4\:Q) resistor r=62 c=0
Ry1 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry4 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry2 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry8 (\3\:Db \4\:Db) resistor r=20.6667 c=0
Ry9 (\5\:Db \6\:Db) resistor r=31 c=0
Ry3 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry7 (\16\:qbint \15\:qbint) resistor r=62 c=0
Ry10 (\5\:Eb \6\:Eb) resistor r=62 c=0
Rx12 (\6\:E \8\:E) resistor r=45 c=0
Rx13 (\2\:E \10\:E) resistor r=45 c=0
Rx14 (\4\:E \11\:E) resistor r=45 c=0
Rx11 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\7\:CKb \11\:CKb) resistor r=45 c=0
Rx5 (\6\:CKbb \9\:CKbb) resistor r=45 c=0
Rx6 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx7 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \16\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx4 (mout \8\:mout) resistor r=45 c=0
Rx9 (\3\:n30 \10\:n30) resistor r=45 c=0
Rx10 (\14\:qbint qbint) resistor r=45 c=0
Rx15 (\4\:Eb \8\:Eb) resistor r=45 c=0
mn20 (\13\:CKb \3\:CK \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=3.6e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn21 (\12\:CKbb \10\:CKb \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.248e-14 ps=6.1e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.55e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn25 (\6\:n20 \8\:CKb \7\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=9.225e-14 ps=6.9e-07 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn36 (\6\:n20 \3\:CKbb net340 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.997e-14 ad=9.225e-14 ps=8e-07 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=2e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn35 (net340 \3\:mout \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.227e-14 ad=3.997e-14 ps=9.2e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=2e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn30 (\9\:mout \3\:n20 \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.227e-14 ad=6.867e-14 ps=9.2e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.175e-06 sb=2e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn40 (\9\:mout \5\:CKbb \5\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.305e-14 ad=6.867e-14 ps=8.3e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.555e-06 sb=2e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn51 (\5\:n30 CKb net380 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.845e-14 ad=4.305e-14 ps=5.9e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.81e-06 sb=2e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn50 (net380 \6\:qbint \4\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.803e-14 ad=1.845e-14 ps=1.13e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.945e-06 sb=1.97366e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn55_1__rcx (\2\:Q qbint \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.236e-14 ad=4.42e-14 ps=1.12e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59808e-06 sb=1.80538e-06 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(2)
mn45 (\11\:qbint \4\:n30 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=7.67e-14 ad=9.62e-14 ps=1.11e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.71548e-06 sb=1.25038e-06 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn1 (\11\:qbint \3\:Eb Db VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=9.62e-14 ps=8.4e-07 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.80327e-06 sb=8.35385e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn3 (Db \3\:E net333 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=6.24e-14 \
        ad=4.16e-14 ps=1e-06 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.84663e-06 sb=6.30385e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mn2 (net333 \3\:D \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.297e-14 ad=6.24e-14 ps=1.23e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.90692e-06 sb=3.45385e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(1)
mn0 (\9\:Eb \7\:E \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.297e-14 ad=2.03e-14 ps=1.23e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.4914 scb=0.00978575 \
        scc=0.000300434 m=(1)
mp21 (\17\:CKbb \9\:CKb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.548e-14 ps=7.5e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.65e-07 sd=160n sca=14.1611 \
        scb=0.0124524 scc=0.000189889 m=(1)
mp25 (\8\:n20 CKbb \5\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=14.1869 scb=0.0131869 \
        scc=0.000739194 m=(1)
mp36 (\8\:n20 \3\:CKb net309 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.68e-14 ad=4.96e-14 ps=1.18e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=14.1869 scb=0.0131869 \
        scc=0.000739194 m=(1)
mp30 (\5\:mout n20 \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=1.2865e-13 ps=1.13e-06 pd=1.45e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=2e-06 sd=160n sca=14.1869 scb=0.0131869 \
        scc=0.000739194 m=(1)
mp35 (net309 \4\:mout \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=8.68e-14 ps=1.13e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=2e-06 sd=160n sca=14.1869 scb=0.0131869 \
        scc=0.000739194 m=(1)
mp40 (\5\:mout \2\:CKb \8\:n30 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=1.2865e-13 ps=9.4e-07 pd=1.45e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=2e-06 sd=160n sca=14.1869 scb=0.0131869 \
        scc=0.000739194 m=(1)
mp51 (\8\:n30 \7\:CKbb net317 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.635e-06 sb=2e-06 sd=160n sca=14.1869 \
        scb=0.0131869 scc=0.000739194 m=(1)
mp50 (net317 \10\:qbint \5\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.2085e-13 ad=1.86e-14 ps=1.57e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=1.94919e-06 sd=160n sca=14.1869 \
        scb=0.0131869 scc=0.000739194 m=(1)
mp55 (\4\:Q qbint \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.2275e-13 ad=6.24e-14 ps=1.55e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.62462e-06 sb=1.79256e-06 sd=160n sca=13.3279 \
        scb=0.011929 scc=0.000599966 m=(2)
mp45 (\15\:qbint n30 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.2465e-13 ad=9.945e-14 ps=1.53e-06 pd=1.29e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.73641e-06 sb=1.24756e-06 sd=160n sca=13.3279 \
        scb=0.011929 scc=0.000599966 m=(1)
mp1 (\15\:qbint \1\:E \3\:Db VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.02e-14 ad=9.945e-14 ps=1.14e-06 pd=1.29e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.79795e-06 sb=9.47564e-07 sd=160n sca=13.3279 \
        scb=0.011929 scc=0.000599966 m=(1)
mp3 (\3\:Db Eb net328 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.3065e-13 ad=7.02e-14 ps=1.45e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.8441e-06 sb=7.22564e-07 sd=160n sca=13.3279 \
        scb=0.011929 scc=0.000599966 m=(1)
mp2 (net328 \1\:D \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.382e-14 ad=1.3065e-13 ps=1.49e-06 pd=1.45e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.92205e-06 sb=3.42564e-07 sd=160n sca=13.9445 \
        scb=0.0121677 scc=0.000600062 m=(1)
mp0 (\5\:Eb \5\:E \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.382e-14 ad=3.01e-14 ps=1.49e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.5754 scb=0.0148797 \
        scc=0.00022139 m=(1)
ends EDFFHQX2
// End of subcircuit definition.

// Generated for: spectre (May  9 14:45:18 2012 )
// Library name: gsclib045
// Cell name: EDFFHQX4
// View name: extracted

simulator lang=spectre

subckt EDFFHQX4 CK D E Q VDD VSS
mp20 (\12\:CKb \3\:CK \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.53e-14 ad=3.655e-14 ps=1.17e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.05e-07 sd=160n sca=19.0805 \
        scb=0.0206115 scc=0.000620106 m=(1)
C1 (VDD VSS) capacitor c=4.15782e-16
C2 (CK VSS) capacitor c=1.0641e-16
C3 (Q VSS) capacitor c=2.86507e-17
C4 (CKb VSS) capacitor c=9.85623e-17
C5 (CKbb VSS) capacitor c=3.82556e-17
C6 (n20 VSS) capacitor c=5.75468e-17
C7 (Db VSS) capacitor c=1.10943e-16
C8 (net340 VSS) capacitor c=4.79276e-19
C9 (mout VSS) capacitor c=2.83716e-17
C10 (n30 VSS) capacitor c=4.55997e-16
C11 (qbint VSS) capacitor c=2.87905e-16
C12 (Eb VSS) capacitor c=4.07708e-17
C13 (net333 VSS) capacitor c=8.93728e-19
C14 (net309 VSS) capacitor c=6.85886e-18
C15 (net317 VSS) capacitor c=3.19819e-18
C16 (net328 VSS) capacitor c=4.86067e-18
C17 (\5\:E VSS) capacitor c=3.99157e-17
C18 (\1\:D VSS) capacitor c=5.10411e-17
C19 (\1\:E VSS) capacitor c=3.9406e-17
C20 (\17\:qbint VSS) capacitor c=7.70168e-17
C21 (\7\:CKbb VSS) capacitor c=6.92991e-17
C22 (\2\:CKb VSS) capacitor c=1.12374e-16
C23 (\4\:mout VSS) capacitor c=4.61114e-17
C24 (\3\:CKb VSS) capacitor c=1.21485e-16
C25 (\8\:CKb VSS) capacitor c=5.10572e-17
C26 (\3\:CK VSS) capacitor c=3.56498e-17
C27 (\7\:E VSS) capacitor c=2.26224e-17
C28 (\3\:D VSS) capacitor c=8.08614e-17
C29 (\3\:E VSS) capacitor c=6.07729e-17
C30 (\3\:Eb VSS) capacitor c=5.82623e-17
C31 (\9\:qbint VSS) capacitor c=4.35623e-17
C32 (\5\:CKbb VSS) capacitor c=3.31812e-17
C33 (\3\:n20 VSS) capacitor c=3.21062e-17
C34 (\3\:mout VSS) capacitor c=7.64617e-17
C35 (\3\:CKbb VSS) capacitor c=5.36974e-17
C36 (\6\:CKb VSS) capacitor c=2.2262e-17
C37 (\7\:CKb VSS) capacitor c=2.12192e-17
C38 (\1\:CK VSS) capacitor c=4.6543e-17
C39 (\6\:E VSS) capacitor c=2.5467e-17
C40 (\2\:D VSS) capacitor c=5.14429e-17
C41 (\2\:Eb VSS) capacitor c=6.28414e-17
C42 (\4\:E VSS) capacitor c=4.84008e-17
C43 (\2\:E VSS) capacitor c=2.46454e-17
C44 (\8\:CKbb VSS) capacitor c=5.30777e-17
C45 (\6\:CKbb VSS) capacitor c=2.92723e-17
C46 (\2\:n20 VSS) capacitor c=3.39331e-17
C47 (\4\:CKbb VSS) capacitor c=3.40673e-17
C48 (\2\:CKbb VSS) capacitor c=4.87089e-17
C49 (\5\:CKb VSS) capacitor c=5.10829e-17
C50 (\2\:CK VSS) capacitor c=4.48026e-17
C51 (\6\:Eb VSS) capacitor c=9.14373e-17
C52 (\1\:VDD VSS) capacitor c=3.71412e-17
C53 (\3\:Db VSS) capacitor c=4.09186e-16
C54 (\26\:qbint VSS) capacitor c=4.59389e-17
C55 (\28\:qbint VSS) capacitor c=2.33494e-17
C56 (\1\:Q VSS) capacitor c=1.3106e-16
C57 (\14\:n30 VSS) capacitor c=7.97388e-17
C58 (\5\:mout VSS) capacitor c=4.72496e-17
C59 (\24\:VDD VSS) capacitor c=5.42978e-17
C60 (\4\:n20 VSS) capacitor c=3.63227e-17
C61 (\5\:Db VSS) capacitor c=4.2169e-16
C62 (\18\:CKbb VSS) capacitor c=5.9212e-17
C63 (\26\:VDD VSS) capacitor c=8.91948e-18
C64 (\12\:CKb VSS) capacitor c=6.00004e-17
C65 (\3\:VDD VSS) capacitor c=1.80108e-16
C66 (\4\:Eb VSS) capacitor c=7.08261e-17
C67 (\18\:qbint VSS) capacitor c=3.60906e-17
C68 (\24\:qbint VSS) capacitor c=2.60169e-17
C69 (\11\:n30 VSS) capacitor c=6.02899e-17
C70 (\9\:mout VSS) capacitor c=6.18587e-17
C71 (\7\:n20 VSS) capacitor c=7.36517e-17
C72 (\7\:Db VSS) capacitor c=9.40469e-17
C73 (\14\:CKbb VSS) capacitor c=2.62874e-17
C74 (\9\:CKb VSS) capacitor c=1.78045e-17
C75 (\2\:mout VSS) capacitor c=2.86801e-17
C76 (\4\:CKb VSS) capacitor c=5.5617e-17
C77 (\8\:qbint VSS) capacitor c=4.40336e-17
C78 (\11\:CKb VSS) capacitor c=7.4121e-17
C79 (\14\:CKb VSS) capacitor c=3.84084e-17
C80 (\6\:n20 VSS) capacitor c=1.08393e-16
C81 (\9\:n20 VSS) capacitor c=9.8102e-17
C82 (\7\:mout VSS) capacitor c=5.1843e-17
C83 (\8\:mout VSS) capacitor c=6.23225e-17
C84 (\9\:CKbb VSS) capacitor c=6.72352e-17
C85 (\10\:CKbb VSS) capacitor c=1.35414e-16
C86 (\11\:CKbb VSS) capacitor c=1.05225e-16
C87 (\12\:CKbb VSS) capacitor c=7.33435e-17
C88 (\13\:CKbb VSS) capacitor c=1.07333e-16
C89 (\16\:CKbb VSS) capacitor c=6.11145e-17
C90 (\17\:CKbb VSS) capacitor c=6.99323e-17
C91 (\5\:Q VSS) capacitor c=2.38982e-16
C92 (\10\:n30 VSS) capacitor c=2.19419e-16
C93 (\20\:qbint VSS) capacitor c=3.68244e-17
C94 (\21\:qbint VSS) capacitor c=5.94903e-17
C95 (\22\:qbint VSS) capacitor c=5.95394e-17
C96 (\23\:qbint VSS) capacitor c=7.11768e-17
C97 (\4\:D VSS) capacitor c=1.21466e-16
C98 (\8\:E VSS) capacitor c=9.06855e-17
C99 (\9\:E VSS) capacitor c=1.27119e-16
C100 (\10\:E VSS) capacitor c=1.17237e-16
C101 (\11\:E VSS) capacitor c=3.28575e-17
C102 (\8\:Eb VSS) capacitor c=9.34343e-17
C103 (\5\:VDD VSS) capacitor c=1.49754e-16
C104 (\12\:VDD VSS) capacitor c=2.48721e-17
Rk40 (E \8\:E) resistor r=0.02329 c=0
Rk41 (\8\:E \9\:E) resistor r=0.4346 c=0
Rk42 (\9\:E \10\:E) resistor r=0.8663 c=0
Rk43 (\9\:E \11\:E) resistor r=0.1053 c=0
Rk39 (\4\:D D) resistor r=0.003678 c=0
Rk46 (\2\:VDD \4\:VDD) resistor r=0.388 c=0
Rk47 (\4\:VDD \5\:VDD) resistor r=0.4586 c=0
Rk53 (\5\:VDD \11\:VDD) resistor r=0.1653 c=0
Rk54 (\11\:VDD \12\:VDD) resistor r=0.411 c=0
Rk55 (\12\:VDD \13\:VDD) resistor r=0.3408 c=0
Rk56 (\13\:VDD \14\:VDD) resistor r=0.3533 c=0
Rk58 (\15\:VDD VDD) resistor r=0.04989 c=0
Rk57 (\14\:VDD \15\:VDD) resistor r=0.09758 c=0
Rk63 (\12\:VDD \25\:VDD) resistor r=0.2671 c=0
Rk64 (\14\:VDD \27\:VDD) resistor r=0.07369 c=0
Rk1 (\4\:CK CK) resistor r=0.002999 c=0
Rk20 (\1\:Q Q) resistor r=0.0613 c=0
Rk21 (Q \5\:Q) resistor r=0.1831 c=0
Rk65 (\2\:VSS \4\:VSS) resistor r=0.2777 c=0
Rk66 (\4\:VSS \5\:VSS) resistor r=0.3859 c=0
Rk73 (\5\:VSS \14\:VSS) resistor r=0.506 c=0
Rk74 (\14\:VSS \15\:VSS) resistor r=0.05997 c=0
Rk75 (\15\:VSS \16\:VSS) resistor r=0.5915 c=0
Rk77 (\17\:VSS VSS) resistor r=0.04989 c=0
Rk76 (\16\:VSS \17\:VSS) resistor r=0.1101 c=0
Rk80 (\14\:VSS \23\:VSS) resistor r=0.1357 c=0
Rk81 (\16\:VSS \25\:VSS) resistor r=0.319 c=0
Rk2 (\10\:CKb \11\:CKb) resistor r=0.097 c=0
Rk3 (\11\:CKb \13\:CKb) resistor r=0.5979 c=0
Rk4 (\11\:CKb \14\:CKb) resistor r=0.2103 c=0
Rk11 (\9\:CKbb \10\:CKbb) resistor r=0.3005 c=0
Rk12 (\10\:CKbb \11\:CKbb) resistor r=0.8339 c=0
Rk13 (\11\:CKbb \12\:CKbb) resistor r=0.2837 c=0
Rk14 (\12\:CKbb \13\:CKbb) resistor r=0.2959 c=0
Rk15 (\13\:CKbb \15\:CKbb) resistor r=0.02467 c=0
Rk16 (\11\:CKbb \16\:CKbb) resistor r=0.2281 c=0
Rk17 (\12\:CKbb \17\:CKbb) resistor r=0.3608 c=0
Rk18 (\13\:CKbb \19\:CKbb) resistor r=0.6204 c=0
Rk5 (\5\:n20 \6\:n20) resistor r=0.1174 c=0
Rk6 (\6\:n20 \8\:n20) resistor r=0.3034 c=0
Rk7 (\6\:n20 \9\:n20) resistor r=0.6257 c=0
Rk36 (\2\:Db \4\:Db) resistor r=0.5355 c=0
Rk37 (\4\:Db \6\:Db) resistor r=3.306 c=0
Rk38 (\6\:Db \8\:Db) resistor r=0.5391 c=0
Rk8 (\6\:mout \7\:mout) resistor r=0.127 c=0
Rk9 (\7\:mout \8\:mout) resistor r=0.228 c=0
Rk10 (\7\:mout \10\:mout) resistor r=0.2916 c=0
Rk25 (n30 \10\:n30) resistor r=1.6488 c=0
Rk26 (\10\:n30 \12\:n30) resistor r=0.2699 c=0
Rk28 (\10\:n30 \15\:n30) resistor r=0.4527 c=0
Rk29 (\19\:qbint \20\:qbint) resistor r=0.1927 c=0
Rk30 (\20\:qbint \21\:qbint) resistor r=0.3329 c=0
Rk31 (\21\:qbint \22\:qbint) resistor r=0.2351 c=0
Rk32 (\22\:qbint \23\:qbint) resistor r=0.3953 c=0
Rk33 (\20\:qbint \25\:qbint) resistor r=0.08277 c=0
Rk34 (\21\:qbint \27\:qbint) resistor r=0.309 c=0
Rk35 (\22\:qbint \29\:qbint) resistor r=0.05443 c=0
Rk44 (\5\:Eb \7\:Eb) resistor r=0.5406 c=0
Rk45 (\7\:Eb \8\:Eb) resistor r=0.5895 c=0
Rl46 (\5\:E \6\:E) resistor r=110.307 c=0
Rl47 (\6\:E \7\:E) resistor r=29.5379 c=0
Rl41 (\3\:E \4\:E) resistor r=35.7713 c=0
Rl40 (\1\:E \2\:E) resistor r=30.2349 c=0
Rl44 (\1\:D \2\:D) resistor r=26.1559 c=0
Rl45 (\2\:D \3\:D) resistor r=110.771 c=0
Rl2 (\2\:CK \3\:CK) resistor r=74.1758 c=0
Rl1 (\1\:CK \2\:CK) resistor r=167.308 c=0
Rl11 (CKb \2\:CKb) resistor r=185.67 c=0
Rl12 (\2\:CKb \3\:CKb) resistor r=528.412 c=0
Rl17 (\5\:CKb \8\:CKb) resistor r=201.384 c=0
Rl16 (\5\:CKb \7\:CKb) resistor r=31.8672 c=0
Rl13 (\3\:CKb \4\:CKb) resistor r=222.62 c=0
Rl15 (\4\:CKb \6\:CKb) resistor r=30.4507 c=0
Rl14 (\4\:CKb \5\:CKb) resistor r=167.982 c=0
Rl18 (\7\:CKbb \8\:CKbb) resistor r=35.3072 c=0
Rl10 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl4 (\3\:CKbb \4\:CKbb) resistor r=29.5379 c=0
Rl3 (CKbb \2\:CKbb) resistor r=53.3118 c=0
Rl8 (n20 \2\:n20) resistor r=98.7687 c=0
Rl9 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl5 (mout \2\:mout) resistor r=6.7128 c=0
Rl7 (\2\:mout \4\:mout) resistor r=45.868 c=0
Rl6 (\2\:mout \3\:mout) resistor r=128.126 c=0
Rl25 (\8\:qbint qbint) resistor r=124.455 c=0
Rl34 (\8\:qbint \17\:qbint) resistor r=109.439 c=0
Rl26 (\8\:qbint \9\:qbint) resistor r=46.5644 c=0
Rl42 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl43 (\2\:Eb \3\:Eb) resistor r=162.581 c=0
Rz13 (\4\:VDD \3\:VDD) resistor r=8.3333 c=0
Rz16 (\5\:VDD \3\:VDD) resistor r=15 c=0
Rz17 (\11\:VDD \3\:VDD) resistor r=9.375 c=0
Rz18 (\13\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz19 (\15\:VDD \3\:VDD) resistor r=37.5 c=0
Rz20 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz25 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz26 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz1 (\9\:CKb \10\:CKb) resistor r=75 c=0
Rz4 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz2 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\9\:mout \10\:mout) resistor r=75 c=0
Rz7 (\12\:n30 \11\:n30) resistor r=75 c=0
Rz8 (\19\:qbint \18\:qbint) resistor r=75 c=0
Rz9 (\25\:qbint \24\:qbint) resistor r=75 c=0
Rz12 (\4\:Eb \5\:Eb) resistor r=75 c=0
Ry13 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry18 (\25\:VDD \24\:VDD) resistor r=62 c=0
Ry19 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry20 (\4\:VSS \3\:VSS) resistor r=7.75 c=0
Ry21 (\5\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry23 (\15\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry24 (\17\:VSS \3\:VSS) resistor r=31 c=0
Ry1 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry4 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry2 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry10 (\3\:Db \4\:Db) resistor r=20.6667 c=0
Ry11 (\5\:Db \6\:Db) resistor r=31 c=0
Ry3 (\5\:mout \6\:mout) resistor r=62 c=0
Ry7 (\15\:n30 \14\:n30) resistor r=62 c=0
Ry8 (\27\:qbint \26\:qbint) resistor r=62 c=0
Ry9 (\29\:qbint \28\:qbint) resistor r=62 c=0
Ry12 (\6\:Eb \7\:Eb) resistor r=62 c=0
Rx13 (\6\:E \8\:E) resistor r=45 c=0
Rx14 (\2\:E \10\:E) resistor r=45 c=0
Rx15 (\4\:E \11\:E) resistor r=45 c=0
Rx12 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\5\:CKb \14\:CKb) resistor r=45 c=0
Rx5 (\8\:CKbb \9\:CKbb) resistor r=45 c=0
Rx6 (\6\:CKbb \10\:CKbb) resistor r=45 c=0
Rx7 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \17\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx4 (mout \8\:mout) resistor r=45 c=0
Rx11 (\23\:qbint qbint) resistor r=45 c=0
Rx16 (\2\:Eb \8\:Eb) resistor r=45 c=0
mn20 (\9\:CKb \1\:CK \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn21 (\14\:CKbb \7\:CKb \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn25 (\7\:n20 \6\:CKb \7\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=8.713e-14 ps=6.9e-07 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=17.1738 scb=0.0176382 \
        scc=0.00148475 m=(1)
mn36 (\7\:n20 \3\:CKbb net340 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=8.713e-14 ps=5.3e-07 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=2e-06 sd=160n sca=17.1738 scb=0.0176382 \
        scc=0.00148475 m=(1)
mn35 (net340 \3\:mout \22\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=9.415e-14 ad=1.23e-14 ps=1.54e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=2e-06 sd=160n sca=17.1738 scb=0.0176382 \
        scc=0.00148475 m=(1)
mn30 (\9\:mout \3\:n20 \22\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=9.415e-14 ad=5.638e-14 ps=1.54e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=2e-06 sd=160n sca=17.1738 scb=0.0176382 \
        scc=0.00148475 m=(1)
mn40 (\9\:mout \5\:CKbb \11\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.023e-14 ad=5.638e-14 ps=9e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=1.96756e-06 sd=160n sca=17.1738 \
        scb=0.0176382 scc=0.00148475 m=(1)
mn51 (\11\:n30 CKb net380 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.023e-14 ps=5.3e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.68e-06 sb=1.91805e-06 sd=160n sca=17.1738 \
        scb=0.0176382 scc=0.00148475 m=(1)
mn50 (net380 \9\:qbint \5\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.803e-14 ad=1.23e-14 ps=1.13e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.785e-06 sb=1.87524e-06 sd=160n sca=17.1738 \
        scb=0.0176382 scc=0.00148475 m=(1)
mn55_1__rcx (\5\:Q qbint \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=6.261e-14 ad=7.93e-14 ps=1.045e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.59808e-06 sb=1.5026e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn45 (\24\:qbint n30 \5\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.646e-14 ad=3.28e-14 ps=1.26e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.90012e-06 sb=3.05e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(2)
mn1 (\18\:qbint \3\:Eb Db VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.85e-14 ad=5.18e-14 ps=9.7e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.99231e-07 sb=7.82692e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn2 (net333 \3\:D \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.685e-14 ad=1.56e-14 ps=1.22e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.74231e-07 sb=4.07692e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
mn3 (Db \3\:E net333 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=5.85e-14 ps=6.4e-07 pd=9.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.69231e-07 sb=5.12692e-07 sd=160n sca=8.81533 scb=0.00706435 \
        scc=0.000179997 m=(1)
mn0 (\4\:Eb \7\:E \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.685e-14 ad=3.263e-14 ps=1.22e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04793e-06 sb=2.25e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp21 (\18\:CKbb \8\:CKb \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.53e-14 ad=3.01e-14 ps=1.17e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.35e-07 sb=1.4e-07 sd=160n sca=12.3202 \
        scb=0.00940859 scc=0.000103219 m=(1)
mp25 (\4\:n20 CKbb \5\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp36 (\4\:n20 \3\:CKb net309 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.3e-14 ad=4.96e-14 ps=1.22e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp35 (net309 \4\:mout \24\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=9.3e-14 ps=1e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.9e-07 sb=2e-06 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp30 (\5\:mout n20 \24\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=1.209e-13 ps=1e-06 pd=1.4e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=2e-06 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp40 (\5\:mout \2\:CKb \14\:n30 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=1.209e-13 ps=9.4e-07 pd=1.4e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.36e-06 sb=2e-06 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(1)
mp51 (\14\:n30 \7\:CKbb net317 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.86e-14 ad=4.96e-14 ps=7.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.565e-06 sb=1.87e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp50 (net317 \17\:qbint \5\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.471e-13 ad=1.86e-14 ps=1.77e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.67e-06 sb=1.765e-06 sd=160n sca=13.1273 \
        scb=0.0119313 scc=0.000538101 m=(1)
mp55_1__rcx (\1\:Q qbint \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=1.1359e-13 ad=6.24e-14 ps=1.57e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.62462e-06 sb=1.23051e-06 sd=160n sca=12.53 \
        scb=0.0110214 scc=0.000443901 m=(4)
mp45_1__rcx (\28\:qbint n30 \5\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.838e-14 ad=4.96e-14 ps=1.585e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.75e-07 sd=160n sca=13.1273 scb=0.0119313 \
        scc=0.000538101 m=(2)
mp1 (\26\:qbint \1\:E \3\:Db VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.19e-14 ad=5.46e-14 ps=1.2e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.92756e-07 sd=160n sca=18.3796 \
        scb=0.0159892 scc=0.00159615 m=(1)
mp3 (\3\:Db Eb net328 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=8.19e-14 ps=1.05e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=5.37756e-07 sd=160n sca=18.4282 \
        scb=0.0159986 scc=0.00159615 m=(1)
mp2 (net328 \1\:D \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=9.975e-14 ad=5.265e-14 ps=1.48e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=3.57756e-07 sd=160n sca=18.9201 \
        scb=0.0161836 scc=0.00159622 m=(1)
mp0 (\6\:Eb \5\:E \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.975e-14 ad=3.01e-14 ps=1.48e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.7e-07 sb=1.4e-07 sd=160n sca=29.4705 \
        scb=0.0286682 scc=0.00289959 m=(1)
ends EDFFHQX4
// End of subcircuit definition.

// Generated for: spectre (May  9 14:45:56 2012 )
// Library name: gsclib045
// Cell name: EDFFHQX8
// View name: extracted

simulator lang=spectre

subckt EDFFHQX8 CK D E Q VDD VSS
mp20 (\11\:CKb \3\:CK \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=19.0805 \
        scb=0.0206115 scc=0.000620106 m=(1)
C1 (E VSS) capacitor c=5.12729e-17
C2 (D VSS) capacitor c=1.10008e-16
C3 (VDD VSS) capacitor c=3.42088e-16
C4 (CK VSS) capacitor c=8.43875e-17
C5 (Q VSS) capacitor c=1.40927e-17
C6 (CKb VSS) capacitor c=1.0045e-16
C7 (CKbb VSS) capacitor c=3.46296e-17
C8 (n20 VSS) capacitor c=5.0201e-17
C9 (Db VSS) capacitor c=1.1138e-16
C10 (net340 VSS) capacitor c=1.12663e-18
C11 (mout VSS) capacitor c=2.50056e-17
C12 (n30 VSS) capacitor c=2.09671e-16
C13 (qbint VSS) capacitor c=3.52412e-16
C14 (Eb VSS) capacitor c=4.19757e-17
C15 (net333 VSS) capacitor c=2.2582e-18
C16 (net309 VSS) capacitor c=3.62978e-18
C17 (net317 VSS) capacitor c=5.90399e-18
C18 (net328 VSS) capacitor c=4.72477e-18
C19 (\5\:E VSS) capacitor c=4.49161e-17
C20 (\3\:D VSS) capacitor c=5.45307e-17
C21 (\1\:E VSS) capacitor c=4.29072e-17
C22 (\29\:qbint VSS) capacitor c=4.4225e-17
C23 (\7\:CKbb VSS) capacitor c=5.73253e-17
C24 (\2\:CKb VSS) capacitor c=1.16291e-16
C25 (\4\:mout VSS) capacitor c=4.45602e-17
C26 (\3\:CKb VSS) capacitor c=1.341e-16
C27 (\8\:CKb VSS) capacitor c=5.59644e-17
C28 (\3\:CK VSS) capacitor c=4.73367e-17
C29 (\7\:E VSS) capacitor c=3.17001e-17
C30 (\1\:D VSS) capacitor c=8.48059e-17
C31 (\3\:E VSS) capacitor c=6.49233e-17
C32 (\3\:Eb VSS) capacitor c=5.88599e-17
C33 (\15\:qbint VSS) capacitor c=6.15166e-17
C34 (\5\:CKbb VSS) capacitor c=3.0973e-17
C35 (\3\:n20 VSS) capacitor c=3.15921e-17
C36 (\3\:mout VSS) capacitor c=6.11827e-17
C37 (\3\:CKbb VSS) capacitor c=4.52275e-17
C38 (\6\:CKb VSS) capacitor c=2.33686e-17
C39 (\7\:CKb VSS) capacitor c=2.1133e-17
C40 (\1\:CK VSS) capacitor c=3.79487e-17
C41 (\6\:E VSS) capacitor c=3.49754e-17
C42 (\2\:D VSS) capacitor c=5.50358e-17
C43 (\4\:E VSS) capacitor c=4.56286e-17
C44 (\2\:Eb VSS) capacitor c=5.16807e-17
C45 (\2\:E VSS) capacitor c=3.15877e-17
C46 (\7\:n30 VSS) capacitor c=1.48916e-17
C47 (\8\:CKbb VSS) capacitor c=5.34073e-17
C48 (\6\:CKbb VSS) capacitor c=3.6641e-17
C49 (\2\:n20 VSS) capacitor c=3.02041e-17
C50 (\4\:CKbb VSS) capacitor c=3.7357e-17
C51 (\2\:CKbb VSS) capacitor c=4.54562e-17
C52 (\5\:CKb VSS) capacitor c=5.70658e-17
C53 (\2\:CK VSS) capacitor c=5.24623e-17
C54 (\6\:Eb VSS) capacitor c=1.19173e-16
C55 (\18\:VDD VSS) capacitor c=2.71245e-17
C56 (\3\:Db VSS) capacitor c=5.15316e-16
C57 (\30\:qbint VSS) capacitor c=1.13743e-16
C58 (\9\:Q VSS) capacitor c=2.62641e-16
C59 (\15\:n30 VSS) capacitor c=8.57492e-17
C60 (\5\:mout VSS) capacitor c=3.78671e-17
C61 (\32\:VDD VSS) capacitor c=5.47924e-17
C62 (\4\:n20 VSS) capacitor c=3.41106e-17
C63 (\5\:Db VSS) capacitor c=4.68741e-16
C64 (\15\:CKbb VSS) capacitor c=7.77954e-17
C65 (\34\:VDD VSS) capacitor c=3.66086e-17
C66 (\11\:CKb VSS) capacitor c=6.87175e-17
C67 (\1\:VDD VSS) capacitor c=1.02915e-16
C68 (\4\:Eb VSS) capacitor c=8.90219e-17
C69 (\35\:qbint VSS) capacitor c=9.18985e-17
C70 (\1\:Q VSS) capacitor c=2.69723e-16
C71 (\17\:n30 VSS) capacitor c=5.79598e-17
C72 (\9\:mout VSS) capacitor c=6.49032e-17
C73 (\7\:n20 VSS) capacitor c=7.75896e-17
C74 (\7\:Db VSS) capacitor c=9.09398e-17
C75 (\13\:CKbb VSS) capacitor c=1.11194e-16
C76 (\13\:CKb VSS) capacitor c=1.86708e-17
C77 (\2\:mout VSS) capacitor c=2.77675e-17
C78 (\4\:CKb VSS) capacitor c=5.58563e-17
C79 (\14\:qbint VSS) capacitor c=2.92985e-17
C80 (\4\:CK VSS) capacitor c=2.79043e-17
C81 (\9\:CKb VSS) capacitor c=3.96661e-17
C82 (\10\:CKb VSS) capacitor c=6.86082e-17
C83 (\6\:n20 VSS) capacitor c=9.51546e-17
C84 (\9\:n20 VSS) capacitor c=9.64547e-17
C85 (\7\:mout VSS) capacitor c=3.99671e-17
C86 (\8\:mout VSS) capacitor c=6.44091e-17
C87 (\9\:CKbb VSS) capacitor c=5.24214e-17
C88 (\10\:CKbb VSS) capacitor c=1.2787e-16
C89 (\11\:CKbb VSS) capacitor c=1.1648e-16
C90 (\12\:CKbb VSS) capacitor c=7.18817e-17
C91 (\17\:CKbb VSS) capacitor c=5.91126e-17
C92 (\18\:CKbb VSS) capacitor c=8.6112e-17
C93 (\13\:n30 VSS) capacitor c=2.26984e-16
C94 (\14\:n30 VSS) capacitor c=2.45188e-16
C95 (\34\:qbint VSS) capacitor c=8.28002e-17
C96 (\37\:qbint VSS) capacitor c=1.05304e-16
C97 (\8\:E VSS) capacitor c=2.98325e-17
C98 (\9\:E VSS) capacitor c=1.0727e-16
C99 (\10\:E VSS) capacitor c=1.20406e-16
C100 (\11\:E VSS) capacitor c=5.09034e-17
C101 (\4\:D VSS) capacitor c=4.37436e-17
C102 (\8\:Eb VSS) capacitor c=8.13455e-17
C103 (\3\:VDD VSS) capacitor c=1.03856e-17
C104 (\5\:VDD VSS) capacitor c=9.32356e-17
C105 (\8\:VDD VSS) capacitor c=1.74559e-16
C106 (\14\:VDD VSS) capacitor c=3.14648e-17
C107 (\16\:VDD VSS) capacitor c=2.55897e-17
Rk39 (\8\:E \9\:E) resistor r=0.07408 c=0
Rk40 (\9\:E \10\:E) resistor r=0.8672 c=0
Rk42 (\11\:E E) resistor r=0.1102 c=0
Rk41 (\9\:E \11\:E) resistor r=0.1796 c=0
Rk43 (D \4\:D) resistor r=0.09326 c=0
Rk69 (\2\:VDD \3\:VDD) resistor r=0.1502 c=0
Rk70 (\3\:VDD \4\:VDD) resistor r=0.3508 c=0
Rk71 (\4\:VDD \5\:VDD) resistor r=0.1076 c=0
Rk73 (\5\:VDD \7\:VDD) resistor r=0.3082 c=0
Rk74 (\7\:VDD \8\:VDD) resistor r=0.07501 c=0
Rk80 (\8\:VDD \14\:VDD) resistor r=0.5762 c=0
Rk81 (\14\:VDD \15\:VDD) resistor r=0.0349 c=0
Rk82 (\15\:VDD \16\:VDD) resistor r=0.619 c=0
Rk84 (\17\:VDD VDD) resistor r=0.04989 c=0
Rk83 (\16\:VDD \17\:VDD) resistor r=0.08253 c=0
Rk85 (\3\:VDD \19\:VDD) resistor r=0.2569 c=0
Rk92 (\14\:VDD \33\:VDD) resistor r=0.3119 c=0
Rk93 (\16\:VDD \35\:VDD) resistor r=0.1781 c=0
Rk3 (\4\:CK CK) resistor r=0.02099 c=0
Rk24 (Q \9\:Q) resistor r=0.079 c=0
Rk23 (\1\:Q Q) resistor r=0.1749 c=0
Rk46 (\2\:VSS \3\:VSS) resistor r=0.1352 c=0
Rk47 (\3\:VSS \4\:VSS) resistor r=0.2655 c=0
Rk48 (\4\:VSS \5\:VSS) resistor r=0.2355 c=0
Rk50 (\5\:VSS \7\:VSS) resistor r=0.307 c=0
Rk55 (\7\:VSS \12\:VSS) resistor r=0.506 c=0
Rk56 (\12\:VSS \13\:VSS) resistor r=0.06499 c=0
Rk57 (\13\:VSS \14\:VSS) resistor r=0.614 c=0
Rk59 (\15\:VSS VSS) resistor r=0.04989 c=0
Rk58 (\14\:VSS \15\:VSS) resistor r=0.08755 c=0
Rk60 (\3\:VSS \17\:VSS) resistor r=0.3062 c=0
Rk67 (\12\:VSS \31\:VSS) resistor r=0.1224 c=0
Rk68 (\14\:VSS \33\:VSS) resistor r=0.282 c=0
Rk4 (\9\:CKb \10\:CKb) resistor r=0.2077 c=0
Rk5 (\10\:CKb \12\:CKb) resistor r=0.6501 c=0
Rk6 (\10\:CKb \14\:CKb) resistor r=0.1003 c=0
Rk13 (\9\:CKbb \10\:CKbb) resistor r=0.2151 c=0
Rk14 (\10\:CKbb \11\:CKbb) resistor r=0.9794 c=0
Rk15 (\10\:CKbb \12\:CKbb) resistor r=0.3432 c=0
Rk16 (\12\:CKbb \14\:CKbb) resistor r=0.3187 c=0
Rk17 (\14\:CKbb \16\:CKbb) resistor r=0.6636 c=0
Rk18 (\11\:CKbb \17\:CKbb) resistor r=0.1963 c=0
Rk19 (\12\:CKbb \18\:CKbb) resistor r=0.3724 c=0
Rk7 (\5\:n20 \6\:n20) resistor r=0.1174 c=0
Rk8 (\6\:n20 \8\:n20) resistor r=0.2775 c=0
Rk9 (\6\:n20 \9\:n20) resistor r=0.5876 c=0
Rk36 (\2\:Db \4\:Db) resistor r=0.5488 c=0
Rk37 (\4\:Db \6\:Db) resistor r=3.8624 c=0
Rk38 (\6\:Db \8\:Db) resistor r=0.577 c=0
Rk10 (\6\:mout \7\:mout) resistor r=0.1196 c=0
Rk11 (\7\:mout \8\:mout) resistor r=0.2225 c=0
Rk12 (\7\:mout \10\:mout) resistor r=0.2651 c=0
Rk28 (\13\:n30 \14\:n30) resistor r=1.8864 c=0
Rk29 (\14\:n30 \16\:n30) resistor r=0.4033 c=0
Rk30 (\14\:n30 \18\:n30) resistor r=0.2699 c=0
Rk32 (\30\:qbint \34\:qbint) resistor r=0.1424 c=0
Rk33 (\34\:qbint \35\:qbint) resistor r=0.234 c=0
Rk34 (\34\:qbint \37\:qbint) resistor r=0.7268 c=0
Rk44 (\5\:Eb \7\:Eb) resistor r=0.7303 c=0
Rk45 (\7\:Eb \8\:Eb) resistor r=0.466 c=0
Rl64 (\5\:E \6\:E) resistor r=94.9225 c=0
Rl65 (\6\:E \7\:E) resistor r=39.1533 c=0
Rl61 (\3\:E \4\:E) resistor r=24.2328 c=0
Rl58 (\1\:E \2\:E) resistor r=37.2302 c=0
Rl63 (\2\:D \3\:D) resistor r=33.8972 c=0
Rl62 (\1\:D \2\:D) resistor r=86.3335 c=0
Rl2 (\2\:CK \3\:CK) resistor r=154.944 c=0
Rl1 (\1\:CK \2\:CK) resistor r=99.1749 c=0
Rl11 (CKb \2\:CKb) resistor r=195.353 c=0
Rl12 (\2\:CKb \3\:CKb) resistor r=532.258 c=0
Rl17 (\5\:CKb \8\:CKb) resistor r=228.021 c=0
Rl16 (\5\:CKb \7\:CKb) resistor r=27.116 c=0
Rl13 (\3\:CKb \4\:CKb) resistor r=245.697 c=0
Rl15 (\4\:CKb \6\:CKb) resistor r=30.4507 c=0
Rl14 (\4\:CKb \5\:CKb) resistor r=168.304 c=0
Rl18 (\7\:CKbb \8\:CKbb) resistor r=49.2328 c=0
Rl10 (\5\:CKbb \6\:CKbb) resistor r=50.6918 c=0
Rl4 (\3\:CKbb \4\:CKbb) resistor r=29.5379 c=0
Rl3 (CKbb \2\:CKbb) resistor r=53.3118 c=0
Rl8 (n20 \2\:n20) resistor r=100 c=0
Rl9 (\2\:n20 \3\:n20) resistor r=29.9451 c=0
Rl5 (mout \2\:mout) resistor r=16.2873 c=0
Rl7 (\2\:mout \4\:mout) resistor r=45.868 c=0
Rl6 (\2\:mout \3\:mout) resistor r=99.7141 c=0
Rl52 (n30 \7\:n30) resistor r=9.3321 c=0
Rl31 (\14\:qbint qbint) resistor r=82.3745 c=0
Rl46 (\14\:qbint \29\:qbint) resistor r=62.6951 c=0
Rl32 (\14\:qbint \15\:qbint) resistor r=100.722 c=0
Rl59 (Eb \2\:Eb) resistor r=24.2328 c=0
Rl60 (\2\:Eb \3\:Eb) resistor r=122.197 c=0
Rz24 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz25 (\4\:VDD \1\:VDD) resistor r=10.7143 c=0
Rz26 (\7\:VDD \1\:VDD) resistor r=12.5 c=0
Rz27 (\8\:VDD \1\:VDD) resistor r=18.75 c=0
Rz29 (\15\:VDD \1\:VDD) resistor r=6.25 c=0
Rz30 (\17\:VDD \1\:VDD) resistor r=37.5 c=0
Rz15 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz22 (\31\:VSS \30\:VSS) resistor r=75 c=0
Rz23 (\33\:VSS \32\:VSS) resistor r=75 c=0
Rz1 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz4 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz2 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz12 (Db \2\:Db) resistor r=75 c=0
Rz13 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\9\:mout \10\:mout) resistor r=75 c=0
Rz9 (\18\:n30 \17\:n30) resistor r=75 c=0
Rz14 (\4\:Eb \5\:Eb) resistor r=75 c=0
Ry20 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry27 (\33\:VDD \32\:VDD) resistor r=62 c=0
Ry28 (\35\:VDD \34\:VDD) resistor r=62 c=0
Ry15 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry16 (\4\:VSS \1\:VSS) resistor r=12.4 c=0
Ry17 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry18 (\13\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry19 (\15\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\11\:CKb \12\:CKb) resistor r=62 c=0
Ry4 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry2 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry12 (\3\:Db \4\:Db) resistor r=20.6667 c=0
Ry13 (\5\:Db \6\:Db) resistor r=31 c=0
Ry3 (\5\:mout \6\:mout) resistor r=62 c=0
Ry9 (\16\:n30 \15\:n30) resistor r=62 c=0
Ry14 (\6\:Eb \7\:Eb) resistor r=62 c=0
Rx11 (\4\:E \8\:E) resistor r=45 c=0
Rx12 (\2\:E \10\:E) resistor r=45 c=0
Rx13 (\6\:E \11\:E) resistor r=45 c=0
Rx14 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx2 (\5\:CKb \9\:CKb) resistor r=45 c=0
Rx5 (\4\:CKbb \9\:CKbb) resistor r=45 c=0
Rx6 (\6\:CKbb \11\:CKbb) resistor r=45 c=0
Rx7 (\8\:CKbb \17\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx4 (mout \8\:mout) resistor r=45 c=0
Rx9 (\13\:n30 \7\:n30) resistor r=45 c=0
Rx10 (\37\:qbint qbint) resistor r=45 c=0
Rx15 (\2\:Eb \8\:Eb) resistor r=45 c=0
mn20 (\13\:CKb \1\:CK \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn21 (\13\:CKbb \7\:CKb \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn25 (\7\:n20 \6\:CKb \7\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=9.225e-14 ps=6.9e-07 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.535 scb=0.0112489 \
        scc=0.00047927 m=(1)
mn36 (\7\:n20 \3\:CKbb net340 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.947e-14 ad=9.225e-14 ps=6e-07 pd=1.31e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=2e-06 sd=160n sca=11.535 scb=0.0112489 \
        scc=0.00047927 m=(1)
mn35 (net340 \3\:mout \30\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.585e-14 ad=1.948e-14 ps=1.32e-06 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.75e-07 sb=2e-06 sd=160n sca=11.535 scb=0.0112489 \
        scc=0.00047927 m=(1)
mn30 (\9\:mout \3\:n20 \30\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.585e-14 ad=7.79e-14 ps=1.32e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=2e-06 sd=160n sca=11.535 scb=0.0112489 \
        scc=0.00047927 m=(1)
mn40 (\9\:mout \5\:CKbb \17\:n30 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.1e-14 ad=7.79e-14 ps=8.1e-07 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.495e-06 sb=2e-06 sd=160n sca=11.535 scb=0.0112489 \
        scc=0.00047927 m=(1)
mn51 (\17\:n30 CKb net380 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=4.1e-14 ps=5.3e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=1.975e-06 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn50 (net380 \15\:qbint \7\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=6.538e-14 ad=1.23e-14 ps=1.14e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=1.87e-06 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn55_1__rcx (\1\:Q qbint \7\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 \
        nf=1 as=9.428e-14 ad=4.636e-14 ps=1.53429e-06 pd=9.0429e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.42034e-06 sb=1.55e-06 sd=160n \
        sca=16.4223 scb=0.0158966 scc=0.0014413 m=(7)
mn45_1__rcx (\35\:qbint n30 \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=6.24e-14 ps=8.2667e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.43721e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(3)
mn1 (\35\:qbint \3\:Eb Db VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=1.04e-13 ps=9e-07 pd=1.32e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.95e-07 sb=5.82212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn3 (Db \3\:E net333 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=1.56e-14 \
        ad=4.94e-14 ps=6.4e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.23e-06 sb=3.47212e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mn2 (net333 \1\:D \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=1.56e-14 ps=8.6e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.335e-06 sb=2.42212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn0 (\4\:Eb \7\:E \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=2.03e-14 ps=8.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp21 (\15\:CKbb \8\:CKb \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=13.019 \
        scb=0.0104631 scc=0.000112651 m=(1)
mp25 (\4\:n20 CKbb \5\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.5208 scb=0.0170531 \
        scc=0.00159934 m=(1)
mp36 (\4\:n20 \3\:CKb net309 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=4.96e-14 ps=9.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=18.5208 scb=0.0170531 \
        scc=0.00159934 m=(1)
mp35 (net309 \4\:mout \32\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.455e-14 ad=5.58e-14 ps=1.23e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=2e-06 sd=160n sca=18.5208 scb=0.0170531 \
        scc=0.00159934 m=(1)
mp30 (\5\:mout n20 \32\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.455e-14 ad=1.2555e-13 ps=1.23e-06 pd=1.43e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.2e-07 sb=2e-06 sd=160n sca=18.5208 scb=0.0170531 \
        scc=0.00159934 m=(1)
mp40 (\5\:mout \2\:CKb \15\:n30 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=1.2555e-13 ps=9.4e-07 pd=1.43e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=1.955e-06 sd=160n sca=18.5208 \
        scb=0.0170531 scc=0.00159934 m=(1)
mp51 (\15\:n30 \7\:CKbb net317 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.1e-14 ad=4.96e-14 ps=8.2e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=1.75e-06 sd=160n sca=18.5208 \
        scb=0.0170531 scc=0.00159934 m=(1)
mp50 (net317 \29\:qbint \8\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.62e-14 ad=3.1e-14 ps=1.27e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72e-06 sb=1.605e-06 sd=160n sca=18.5208 \
        scb=0.0170531 scc=0.00159934 m=(1)
mp55_1__rcx (\9\:Q qbint \8\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 \
        nf=1 as=7.191e-14 ad=6.993e-14 ps=1.21857e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.40079e-06 sb=1.37e-06 sd=160n \
        sca=20.7359 scb=0.0165012 scc=0.00199728 m=(7)
mp45_1__rcx (\30\:qbint n30 \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=8.53e-14 ad=6.24e-14 ps=1.28667e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.38955e-06 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(3)
mp1 (\30\:qbint \1\:E \3\:Db VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.19e-14 ad=6.24e-14 ps=1.2e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=7.14551e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp3 (\3\:Db Eb net328 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.655e-14 ad=8.19e-14 ps=1.07e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-06 sb=4.59551e-07 sd=160n sca=17.3844 \
        scb=0.0153023 scc=0.00137893 m=(1)
mp2 (net328 \3\:D \18\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.655e-14 ps=1.16e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.29e-06 sb=2.69551e-07 sd=160n sca=18.003 \
        scb=0.0156068 scc=0.00137911 m=(1)
mp0 (\6\:Eb \5\:E \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.525e-06 sb=1.4e-07 sd=160n sca=25.493 \
        scb=0.0240811 scc=0.00243861 m=(1)
ends EDFFHQX8
// End of subcircuit definition.

// Generated for: spectre (May  9 14:46:34 2012 )
// Library name: gsclib045
// Cell name: EDFFTRX1
// View name: extracted

simulator lang=spectre

subckt EDFFTRX1 CK D E Q QN RN VDD VSS
mp57 (\1\:QN \4\:qint \28\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.142e-14 ad=5.46e-14 ps=1.52e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.4e-07 sd=160n sca=34.3332 \
        scb=0.0249008 scc=0.00341086 m=(1)
C1 (CK VSS) capacitor c=7.18699e-17
C2 (D VSS) capacitor c=7.56131e-17
C3 (Q VSS) capacitor c=7.64236e-17
C4 (VDD VSS) capacitor c=4.09447e-16
C5 (QN VSS) capacitor c=2.2925e-17
C6 (RN VSS) capacitor c=8.39036e-17
C7 (qint VSS) capacitor c=2.13143e-17
C8 (qbint VSS) capacitor c=2.46767e-17
C9 (CKb VSS) capacitor c=8.8476e-17
C10 (n30 VSS) capacitor c=3.83194e-17
C11 (net496 VSS) capacitor c=4.27757e-20
C12 (mout VSS) capacitor c=5.61506e-17
C13 (CKbb VSS) capacitor c=3.07803e-17
C14 (n20 VSS) capacitor c=4.91526e-17
C15 (net516 VSS) capacitor c=7.19536e-19
C16 (Dp VSS) capacitor c=6.75873e-17
C17 (RNb VSS) capacitor c=4.23287e-17
C18 (Eb VSS) capacitor c=4.95386e-17
C19 (n1 VSS) capacitor c=1.37941e-18
C20 (Db VSS) capacitor c=9.42025e-17
C21 (net427 VSS) capacitor c=7.07753e-19
C22 (n2 VSS) capacitor c=8.77164e-17
C23 (n3 VSS) capacitor c=8.33393e-17
C24 (\1\:D VSS) capacitor c=3.10625e-17
C25 (\4\:E VSS) capacitor c=3.55379e-17
C26 (\2\:Db VSS) capacitor c=5.83171e-17
C27 (\3\:E VSS) capacitor c=4.01005e-17
C28 (\11\:qbint VSS) capacitor c=5.64406e-17
C29 (\3\:RNb VSS) capacitor c=6.04992e-17
C30 (\1\:RN VSS) capacitor c=3.82478e-17
C31 (\11\:CKb VSS) capacitor c=4.79613e-17
C32 (\5\:CKb VSS) capacitor c=6.05093e-17
C33 (\3\:mout VSS) capacitor c=8.05873e-17
C34 (\3\:n20 VSS) capacitor c=3.22944e-17
C35 (\3\:CKb VSS) capacitor c=3.75743e-17
C36 (\5\:CKbb VSS) capacitor c=9.95396e-17
C37 (\7\:qbint VSS) capacitor c=5.98776e-17
C38 (\1\:CK VSS) capacitor c=2.0613e-17
C39 (\6\:qbint VSS) capacitor c=3.24807e-17
C40 (\4\:qint VSS) capacitor c=4.63164e-17
C41 (\3\:D VSS) capacitor c=2.45102e-17
C42 (\7\:E VSS) capacitor c=2.61304e-17
C43 (\1\:E VSS) capacitor c=6.65683e-17
C44 (\3\:Eb VSS) capacitor c=5.16712e-17
C45 (\10\:qbint VSS) capacitor c=1.04867e-16
C46 (\3\:RN VSS) capacitor c=3.55907e-17
C47 (\9\:CKb VSS) capacitor c=3.02905e-17
C48 (\2\:Dp VSS) capacitor c=5.51283e-17
C49 (\7\:CKb VSS) capacitor c=4.81238e-17
C50 (\3\:CKbb VSS) capacitor c=1.13794e-16
C51 (\4\:CKbb VSS) capacitor c=1.18795e-16
C52 (\9\:qbint VSS) capacitor c=8.1034e-17
C53 (\3\:n30 VSS) capacitor c=3.39086e-17
C54 (\3\:CK VSS) capacitor c=3.00236e-17
C55 (\5\:qbint VSS) capacitor c=4.20901e-17
C56 (\4\:qbint VSS) capacitor c=2.85179e-17
C57 (\3\:qint VSS) capacitor c=3.74609e-17
C58 (\2\:D VSS) capacitor c=2.3223e-17
C59 (\6\:E VSS) capacitor c=3.56042e-17
C60 (\3\:Db VSS) capacitor c=2.17658e-17
C61 (\2\:E VSS) capacitor c=7.08349e-17
C62 (\2\:Eb VSS) capacitor c=5.01759e-17
C63 (\12\:qbint VSS) capacitor c=3.05769e-17
C64 (\2\:RNb VSS) capacitor c=6.01465e-17
C65 (\2\:RN VSS) capacitor c=3.91083e-17
C66 (\10\:CKb VSS) capacitor c=3.68556e-17
C67 (\3\:Dp VSS) capacitor c=2.65556e-17
C68 (\8\:CKb VSS) capacitor c=5.43065e-17
C69 (\2\:CKbb VSS) capacitor c=7.4264e-17
C70 (\6\:CKb VSS) capacitor c=5.36727e-17
C71 (\2\:mout VSS) capacitor c=6.32244e-17
C72 (\4\:CKb VSS) capacitor c=4.34445e-17
C73 (\2\:CKb VSS) capacitor c=3.57543e-17
C74 (\8\:qbint VSS) capacitor c=2.73853e-17
C75 (\2\:n30 VSS) capacitor c=2.24111e-17
C76 (\2\:CK VSS) capacitor c=3.02184e-17
C77 (\2\:qbint VSS) capacitor c=3.79876e-17
C78 (\4\:Db VSS) capacitor c=1.20625e-16
C79 (\16\:VDD VSS) capacitor c=2.14601e-17
C80 (\4\:Eb VSS) capacitor c=4.08253e-17
C81 (\13\:Dp VSS) capacitor c=8.30325e-17
C82 (\3\:n3 VSS) capacitor c=8.49969e-17
C83 (\11\:Dp VSS) capacitor c=2.87657e-17
C84 (\3\:n2 VSS) capacitor c=7.22792e-17
C85 (\18\:VDD VSS) capacitor c=1.47141e-17
C86 (\6\:RNb VSS) capacitor c=4.63881e-17
C87 (\6\:CKbb VSS) capacitor c=3.31522e-17
C88 (\20\:VDD VSS) capacitor c=1.74609e-17
C89 (\5\:n20 VSS) capacitor c=1.84747e-17
C90 (\22\:VDD VSS) capacitor c=1.27899e-17
C91 (\8\:mout VSS) capacitor c=3.92165e-17
C92 (\8\:n30 VSS) capacitor c=4.22109e-17
C93 (\24\:VDD VSS) capacitor c=7.87492e-17
C94 (\16\:qbint VSS) capacitor c=9.22925e-17
C95 (\19\:CKb VSS) capacitor c=6.63619e-17
C96 (\26\:VDD VSS) capacitor c=3.13406e-17
C97 (\1\:Q VSS) capacitor c=5.32271e-17
C98 (\5\:qint VSS) capacitor c=2.55074e-17
C99 (\28\:VDD VSS) capacitor c=1.75277e-17
C100 (\1\:QN VSS) capacitor c=3.57909e-17
C101 (\1\:VDD VSS) capacitor c=2.07555e-16
C102 (\7\:Db VSS) capacitor c=3.3113e-17
C103 (\8\:Eb VSS) capacitor c=1.13685e-16
C104 (\4\:Dp VSS) capacitor c=1.05517e-16
C105 (\8\:Dp VSS) capacitor c=2.53661e-17
C106 (\8\:RNb VSS) capacitor c=4.77094e-17
C107 (\10\:CKbb VSS) capacitor c=4.15747e-17
C108 (\9\:n20 VSS) capacitor c=8.53948e-17
C109 (\6\:mout VSS) capacitor c=4.63237e-17
C110 (\6\:n30 VSS) capacitor c=5.75529e-17
C111 (\20\:qbint VSS) capacitor c=6.67526e-17
C112 (\17\:CKb VSS) capacitor c=1.44576e-16
C113 (\4\:Q VSS) capacitor c=2.13546e-17
C114 (\9\:qint VSS) capacitor c=2.74299e-17
C115 (\3\:QN VSS) capacitor c=2.71567e-17
C116 (\2\:qint VSS) capacitor c=7.93507e-18
C117 (\3\:qbint VSS) capacitor c=3.38803e-17
C118 (\2\:n20 VSS) capacitor c=3.88189e-17
C119 (\7\:qint VSS) capacitor c=2.81471e-17
C120 (\8\:qint VSS) capacitor c=1.9611e-17
C121 (\4\:CK VSS) capacitor c=5.56571e-17
C122 (\5\:E VSS) capacitor c=2.25884e-17
C123 (\4\:n30 VSS) capacitor c=6.64649e-17
C124 (\5\:n30 VSS) capacitor c=6.36749e-17
C125 (\4\:mout VSS) capacitor c=6.06392e-17
C126 (\5\:mout VSS) capacitor c=5.91719e-17
C127 (\7\:n20 VSS) capacitor c=6.03507e-17
C128 (\8\:n20 VSS) capacitor c=7.04265e-17
C129 (\12\:CKb VSS) capacitor c=4.54277e-17
C130 (\13\:CKb VSS) capacitor c=1.09738e-16
C131 (\14\:CKb VSS) capacitor c=1.54822e-16
C132 (\15\:CKb VSS) capacitor c=1.02353e-16
C133 (\16\:CKb VSS) capacitor c=1.88818e-16
C134 (\21\:CKb VSS) capacitor c=5.25311e-17
C135 (\22\:CKb VSS) capacitor c=6.99432e-17
C136 (\8\:CKbb VSS) capacitor c=6.20943e-17
C137 (\9\:CKbb VSS) capacitor c=7.18152e-17
C138 (\4\:RN VSS) capacitor c=2.98996e-17
C139 (\4\:RNb VSS) capacitor c=5.97882e-17
C140 (\5\:RNb VSS) capacitor c=5.63313e-17
C141 (\13\:qbint VSS) capacitor c=1.99344e-16
C142 (\15\:qbint VSS) capacitor c=8.42785e-17
C143 (\18\:qbint VSS) capacitor c=1.63851e-16
C144 (\19\:qbint VSS) capacitor c=2.53956e-16
C145 (\6\:Dp VSS) capacitor c=2.86111e-16
C146 (\7\:Dp VSS) capacitor c=1.56285e-16
C147 (\10\:Dp VSS) capacitor c=1.26314e-16
C148 (\8\:E VSS) capacitor c=7.41816e-17
C149 (\9\:E VSS) capacitor c=7.59822e-17
C150 (\7\:Eb VSS) capacitor c=1.60707e-16
C151 (\4\:D VSS) capacitor c=3.79904e-17
C152 (\6\:Db VSS) capacitor c=9.95995e-17
C153 (\3\:VDD VSS) capacitor c=1.74607e-17
C154 (\5\:VDD VSS) capacitor c=2.25962e-17
C155 (\7\:VDD VSS) capacitor c=8.55689e-18
C156 (\9\:VDD VSS) capacitor c=8.74826e-18
C157 (\13\:VDD VSS) capacitor c=9.86012e-18
C158 (\15\:VDD VSS) capacitor c=4.96723e-18
Rk9 (CK \4\:CK) resistor r=0.1694 c=0
Rk53 (\4\:D D) resistor r=0.1309 c=0
Rk7 (\3\:Q Q) resistor r=0.02419 c=0
Rk6 (\2\:Q \3\:Q) resistor r=0.4387 c=0
Rk8 (\3\:Q \5\:Q) resistor r=0.179 c=0
Rk48 (\8\:E E) resistor r=0.245 c=0
Rk49 (E \9\:E) resistor r=0.002376 c=0
Rk77 (\2\:VSS \3\:VSS) resistor r=0.1076 c=0
Rk78 (\3\:VSS \4\:VSS) resistor r=0.4435 c=0
Rk79 (\4\:VSS \5\:VSS) resistor r=0.08503 c=0
Rk80 (\5\:VSS \6\:VSS) resistor r=0.1274 c=0
Rk81 (\6\:VSS \7\:VSS) resistor r=0.2277 c=0
Rk82 (\7\:VSS \8\:VSS) resistor r=0.3608 c=0
Rk83 (\8\:VSS \9\:VSS) resistor r=0.1242 c=0
Rk84 (\9\:VSS \10\:VSS) resistor r=0.4749 c=0
Rk85 (\10\:VSS \11\:VSS) resistor r=0.3507 c=0
Rk86 (\11\:VSS \12\:VSS) resistor r=0.1602 c=0
Rk87 (\12\:VSS \13\:VSS) resistor r=0.4483 c=0
Rk88 (\13\:VSS \14\:VSS) resistor r=0.1427 c=0
Rk89 (\14\:VSS \15\:VSS) resistor r=0.1853 c=0
Rk91 (\16\:VSS VSS) resistor r=0.1 c=0
Rk90 (\15\:VSS \16\:VSS) resistor r=0.1151 c=0
Rk92 (\3\:VSS \18\:VSS) resistor r=0.3656 c=0
Rk93 (\5\:VSS \20\:VSS) resistor r=0.202 c=0
Rk94 (\6\:VSS \22\:VSS) resistor r=0.202 c=0
Rk95 (\7\:VSS \24\:VSS) resistor r=0.2125 c=0
Rk96 (\9\:VSS \26\:VSS) resistor r=0.04328 c=0
Rk97 (\10\:VSS \28\:VSS) resistor r=0.2544 c=0
Rk98 (\12\:VSS \30\:VSS) resistor r=0.3404 c=0
Rk99 (\13\:VSS \32\:VSS) resistor r=0.3548 c=0
Rk100 (\15\:VSS \34\:VSS) resistor r=0.07358 c=0
Rk56 (\2\:VDD \3\:VDD) resistor r=0.09255 c=0
Rk57 (\3\:VDD \4\:VDD) resistor r=0.5086 c=0
Rk58 (\4\:VDD \5\:VDD) resistor r=0.4685 c=0
Rk59 (\5\:VDD \6\:VDD) resistor r=0.2329 c=0
Rk60 (\6\:VDD \7\:VDD) resistor r=0.2304 c=0
Rk61 (\7\:VDD \8\:VDD) resistor r=0.2204 c=0
Rk62 (\8\:VDD \9\:VDD) resistor r=0.2279 c=0
Rk63 (\9\:VDD \10\:VDD) resistor r=0.273 c=0
Rk64 (\10\:VDD \11\:VDD) resistor r=0.253 c=0
Rk65 (\11\:VDD \12\:VDD) resistor r=0.1978 c=0
Rk66 (\12\:VDD \13\:VDD) resistor r=0.2078 c=0
Rk67 (\13\:VDD \14\:VDD) resistor r=0.2931 c=0
Rk69 (\15\:VDD VDD) resistor r=0.2151 c=0
Rk68 (\14\:VDD \15\:VDD) resistor r=0.0349 c=0
Rk70 (\3\:VDD \17\:VDD) resistor r=0.1667 c=0
Rk71 (\5\:VDD \19\:VDD) resistor r=0.07358 c=0
Rk72 (\7\:VDD \21\:VDD) resistor r=0.1022 c=0
Rk73 (\9\:VDD \23\:VDD) resistor r=0.07358 c=0
Rk74 (\11\:VDD \25\:VDD) resistor r=0.3694 c=0
Rk75 (\13\:VDD \27\:VDD) resistor r=0.1288 c=0
Rk76 (\15\:VDD \29\:VDD) resistor r=0.2233 c=0
Rk2 (\4\:QN QN) resistor r=0.09283 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3053 c=0
Rk30 (\4\:RN RN) resistor r=0.07165 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.1296 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1192 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.0936 c=0
Rk34 (\13\:qbint \14\:qbint) resistor r=1.9974 c=0
Rk35 (\14\:qbint \15\:qbint) resistor r=0.5272 c=0
Rk36 (\15\:qbint \17\:qbint) resistor r=0.05765 c=0
Rk37 (\17\:qbint \18\:qbint) resistor r=1.0114 c=0
Rk38 (\14\:qbint \19\:qbint) resistor r=0.04612 c=0
Rk39 (\15\:qbint \21\:qbint) resistor r=0.3747 c=0
Rk19 (\12\:CKb \13\:CKb) resistor r=0.2736 c=0
Rk20 (\13\:CKb \14\:CKb) resistor r=0.6521 c=0
Rk21 (\14\:CKb \15\:CKb) resistor r=0.6405 c=0
Rk22 (\15\:CKb \16\:CKb) resistor r=0.1789 c=0
Rk23 (\16\:CKb \18\:CKb) resistor r=1.201 c=0
Rk24 (\18\:CKb \20\:CKb) resistor r=0.3632 c=0
Rk25 (\14\:CKb \21\:CKb) resistor r=0.21 c=0
Rk26 (\15\:CKb \22\:CKb) resistor r=0.3497 c=0
Rk10 (\4\:n30 \5\:n30) resistor r=0.314 c=0
Rk11 (\5\:n30 \7\:n30) resistor r=0.2323 c=0
Rk12 (\5\:n30 \9\:n30) resistor r=0.1882 c=0
Rk13 (\4\:mout \5\:mout) resistor r=0.2539 c=0
Rk14 (\5\:mout \7\:mout) resistor r=0.1504 c=0
Rk15 (\5\:mout \9\:mout) resistor r=0.2658 c=0
Rk27 (\7\:CKbb \8\:CKbb) resistor r=0.1404 c=0
Rk28 (\8\:CKbb \9\:CKbb) resistor r=0.4133 c=0
Rk29 (\8\:CKbb \11\:CKbb) resistor r=0.2357 c=0
Rk16 (\6\:n20 \7\:n20) resistor r=0.05734 c=0
Rk17 (\7\:n20 \8\:n20) resistor r=0.415 c=0
Rk18 (\7\:n20 \10\:n20) resistor r=0.381 c=0
Rk42 (\5\:Dp \6\:Dp) resistor r=0.7338 c=0
Rk43 (\6\:Dp \7\:Dp) resistor r=1.3263 c=0
Rk44 (\6\:Dp \9\:Dp) resistor r=0.09158 c=0
Rk45 (\6\:Dp \10\:Dp) resistor r=0.7072 c=0
Rk46 (\10\:Dp \12\:Dp) resistor r=0.0496 c=0
Rk47 (\10\:Dp \14\:Dp) resistor r=0.3172 c=0
Rk31 (\4\:RNb \5\:RNb) resistor r=0.2715 c=0
Rk32 (\5\:RNb \7\:RNb) resistor r=0.2862 c=0
Rk33 (\5\:RNb \9\:RNb) resistor r=0.2124 c=0
Rk50 (\5\:Eb \6\:Eb) resistor r=0.2114 c=0
Rk51 (\6\:Eb \7\:Eb) resistor r=0.8562 c=0
Rk52 (\6\:Eb \9\:Eb) resistor r=0.0529 c=0
Rk54 (\5\:Db \6\:Db) resistor r=0.9098 c=0
Rk55 (\5\:Db \8\:Db) resistor r=0.2562 c=0
Rk40 (\2\:n2 \4\:n2) resistor r=0.3108 c=0
Rk41 (\2\:n3 \4\:n3) resistor r=0.4714 c=0
Rl9 (\1\:CK \2\:CK) resistor r=42.3077 c=0
Rl10 (\2\:CK \3\:CK) resistor r=39.5604 c=0
Rl47 (\1\:D \2\:D) resistor r=26.1559 c=0
Rl48 (\2\:D \3\:D) resistor r=37.6944 c=0
Rl41 (\2\:E \3\:E) resistor r=63.4387 c=0
Rl40 (\1\:E \2\:E) resistor r=134.41 c=0
Rl44 (\4\:E \5\:E) resistor r=39.6181 c=0
Rl46 (\5\:E \7\:E) resistor r=49.2335 c=0
Rl45 (\5\:E \6\:E) resistor r=125.373 c=0
Rl32 (\1\:RN \2\:RN) resistor r=56.9251 c=0
Rl33 (\2\:RN \3\:RN) resistor r=137.694 c=0
Rl1 (qint \2\:qint) resistor r=5.915 c=0
Rl3 (\2\:qint \4\:qint) resistor r=49.7141 c=0
Rl2 (\2\:qint \3\:qint) resistor r=34.3295 c=0
Rl36 (\10\:qbint \11\:qbint) resistor r=241.873 c=0
Rl14 (\7\:qbint \9\:qbint) resistor r=165.385 c=0
Rl37 (\11\:qbint \12\:qbint) resistor r=24.2328 c=0
Rl13 (\7\:qbint \8\:qbint) resistor r=35.7713 c=0
Rl4 (qbint \2\:qbint) resistor r=24.2328 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=53.079 c=0
Rl8 (\3\:qbint \6\:qbint) resistor r=47.3105 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=41.5412 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=167.299 c=0
Rl31 (\10\:CKb \11\:CKb) resistor r=103.079 c=0
Rl30 (\9\:CKb \10\:CKb) resistor r=57.2464 c=0
Rl27 (\7\:CKb \8\:CKb) resistor r=33.8482 c=0
Rl22 (\5\:CKb \6\:CKb) resistor r=62.6944 c=0
Rl16 (\3\:CKb \4\:CKb) resistor r=62.6944 c=0
Rl15 (CKb \2\:CKb) resistor r=43.4636 c=0
Rl11 (n30 \2\:n30) resistor r=24.2328 c=0
Rl12 (\2\:n30 \3\:n30) resistor r=53.079 c=0
Rl20 (mout \2\:mout) resistor r=60.6695 c=0
Rl21 (\2\:mout \3\:mout) resistor r=103.079 c=0
Rl26 (\4\:CKbb \5\:CKbb) resistor r=201.054 c=0
Rl25 (\3\:CKbb \4\:CKbb) resistor r=459.181 c=0
Rl23 (CKbb \2\:CKbb) resistor r=41.5405 c=0
Rl24 (\2\:CKbb \3\:CKbb) resistor r=172.197 c=0
Rl17 (n20 \2\:n20) resistor r=118.949 c=0
Rl18 (\2\:n20 \3\:n20) resistor r=49.7185 c=0
Rl19 (\2\:n20 \4\:n20) resistor r=3.3229 c=0
Rl28 (Dp \2\:Dp) resistor r=165.385 c=0
Rl29 (\2\:Dp \3\:Dp) resistor r=24.2328 c=0
Rl34 (RNb \2\:RNb) resistor r=94.9523 c=0
Rl35 (\2\:RNb \3\:RNb) resistor r=118.464 c=0
Rl38 (Eb \2\:Eb) resistor r=115.18 c=0
Rl39 (\2\:Eb \3\:Eb) resistor r=74.168 c=0
Rl42 (Db \2\:Db) resistor r=226.489 c=0
Rl43 (\2\:Db \3\:Db) resistor r=24.2328 c=0
Rz3 (\4\:Q \5\:Q) resistor r=75 c=0
Rz22 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz23 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz24 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz25 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz26 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz27 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz28 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz29 (\31\:VSS \32\:VSS) resistor r=75 c=0
Rz30 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz15 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz16 (\1\:VDD \4\:VDD) resistor r=7.5 c=0
Rz17 (\1\:VDD \6\:VDD) resistor r=18.75 c=0
Rz18 (\1\:VDD \8\:VDD) resistor r=15 c=0
Rz19 (\1\:VDD \10\:VDD) resistor r=15 c=0
Rz20 (\1\:VDD \12\:VDD) resistor r=18.75 c=0
Rz21 (\1\:VDD \14\:VDD) resistor r=12.5 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz10 (\20\:qbint \21\:qbint) resistor r=75 c=0
Rz7 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz4 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz5 (\6\:mout \7\:mout) resistor r=75 c=0
Rz8 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz6 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz11 (\4\:Dp \5\:Dp) resistor r=75 c=0
Rz12 (\8\:Dp \9\:Dp) resistor r=75 c=0
Rz9 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz13 (\8\:Eb \9\:Eb) resistor r=75 c=0
Rz14 (\7\:Db \8\:Db) resistor r=75 c=0
Ry3 (\1\:Q \2\:Q) resistor r=62 c=0
Ry26 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry27 (\1\:VSS \4\:VSS) resistor r=6.8889 c=0
Ry28 (\1\:VSS \8\:VSS) resistor r=8.8571 c=0
Ry29 (\1\:VSS \11\:VSS) resistor r=5.1667 c=0
Ry30 (\1\:VSS \14\:VSS) resistor r=20.6667 c=0
Ry31 (\1\:VSS \16\:VSS) resistor r=20.6667 c=0
Ry19 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry20 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry21 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry22 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry23 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry24 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry25 (\28\:VDD \29\:VDD) resistor r=62 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry10 (\16\:qbint \17\:qbint) resistor r=31 c=0
Ry7 (\19\:CKb \20\:CKb) resistor r=62 c=0
Ry4 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry5 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\6\:CKbb \7\:CKbb) resistor r=62 c=0
Ry6 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry15 (\11\:Dp \12\:Dp) resistor r=62 c=0
Ry16 (\13\:Dp \14\:Dp) resistor r=62 c=0
Ry9 (\6\:RNb \7\:RNb) resistor r=62 c=0
Ry17 (\4\:Eb \5\:Eb) resistor r=62 c=0
Ry18 (\4\:Db \5\:Db) resistor r=62 c=0
Ry11 (n2 \2\:n2) resistor r=62 c=0
Ry12 (\3\:n2 \4\:n2) resistor r=62 c=0
Ry13 (n3 \2\:n3) resistor r=62 c=0
Ry14 (\3\:n3 \4\:n3) resistor r=62 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx21 (\2\:D \4\:D) resistor r=45 c=0
Rx18 (\2\:E \8\:E) resistor r=45 c=0
Rx19 (\6\:E \9\:E) resistor r=45 c=0
Rx12 (\2\:RN \4\:RN) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx14 (\12\:qbint \13\:qbint) resistor r=45 c=0
Rx15 (\2\:qbint \18\:qbint) resistor r=45 c=0
Rx16 (\8\:qbint \19\:qbint) resistor r=45 c=0
Rx6 (\10\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\8\:CKb \13\:CKb) resistor r=45 c=0
Rx8 (\2\:CKb \16\:CKb) resistor r=45 c=0
Rx9 (\6\:CKb \21\:CKb) resistor r=45 c=0
Rx10 (\4\:CKb \22\:CKb) resistor r=45 c=0
Rx3 (\2\:n30 \4\:n30) resistor r=45 c=0
Rx4 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\2\:CKbb \9\:CKbb) resistor r=45 c=0
Rx5 (\4\:n20 \8\:n20) resistor r=45 c=0
Rx17 (\3\:Dp \7\:Dp) resistor r=45 c=0
Rx13 (\2\:RNb \4\:RNb) resistor r=45 c=0
Rx20 (\2\:Eb \7\:Eb) resistor r=45 c=0
Rx22 (\3\:Db \6\:Db) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \33\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.273e-14 ad=3.64e-14 ps=1.67e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\9\:qint \4\:qbint \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\4\:Q \5\:qbint \31\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.542e-14 ad=3.64e-14 ps=8.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.39423e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn20 (\17\:CKb \3\:CK \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.542e-14 ad=2.03e-14 ps=8.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn45 (\20\:qbint \3\:n30 \29\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.08e-14 ad=5.638e-14 ps=8.9e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=1.4439e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn50 (net496 \9\:qbint \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.08e-14 ad=8.7e-15 ps=8.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.6e-07 sb=2e-06 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn51 (\6\:n30 CKb net496 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=1.995e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn40 (\6\:n30 \4\:CKbb \6\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.148e-14 ad=2.32e-14 ps=1e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.79e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn26 (\9\:n20 \7\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=3.553e-14 ps=5.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.995e-06 sb=6.65e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn30 (\6\:mout n20 \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.453e-14 ad=5.148e-14 ps=1.08e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.27e-06 sb=1.39e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn35 (net516 mout \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.453e-14 ad=8.7e-15 ps=1.08e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-06 sb=1.06e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn36 (\9\:n20 \3\:CKbb net516 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.553e-14 ps=4.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.705e-06 sb=9.55e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn25 (n21 \2\:Dp \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.85e-14 ad=1.957e-14 ps=1.64e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.85e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn21 (\10\:CKbb \9\:CKb \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.85e-14 ad=2.03e-14 ps=1.64e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn2 (\8\:RNb \3\:RN \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.568e-14 ad=2.32e-14 ps=9.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=8.1e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn3 (\8\:Dp RNb \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.568e-14 ad=2.32e-14 ps=9.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=4.5e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn7 (\4\:Dp Db n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.45e-07 sb=1.4e-07 sd=160n sca=7.47547 scb=0.00467957 \
        scc=5.27432e-05 m=(1)
mn5 (\8\:Dp \10\:qbint n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2.45e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn4 (n0 \3\:Eb \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn6 (n1 \1\:E \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=7.47547 \
        scb=0.00467957 scc=5.27432e-05 m=(1)
mn0 (\8\:Eb \7\:E \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (\7\:Db \3\:D \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=2.32e-14 ps=7.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.6e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp56 (\5\:qint \6\:qbint \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.142e-14 ad=2.63e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.22326e-07 sd=160n sca=46.9517 \
        scb=0.029008 scc=0.00588492 m=(1)
mp55 (\1\:Q qbint \26\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0705e-13 ad=5.15e-14 ps=1.72e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.32051e-07 sb=3.32628e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp20 (\19\:CKb \1\:CK \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0705e-13 ad=4.3e-14 ps=1.72e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.82442e-07 sb=2e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
