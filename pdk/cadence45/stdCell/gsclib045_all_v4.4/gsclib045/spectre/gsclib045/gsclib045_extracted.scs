Rk10 (\11\:CKNbb \14\:CKNbb) resistor r=0.3382 c=0
Rk11 (\14\:CKNbb \15\:CKNbb) resistor r=0.2715 c=0
Rk39 (\16\:CKNbb \17\:CKNbb) resistor r=0.3681 c=0
Rk40 (\7\:n35g \8\:n35g) resistor r=0.2407 c=0
Rk41 (\7\:n35g \10\:n35g) resistor r=0.6914 c=0
Rk52 (\12\:n35g \13\:n35g) resistor r=0.2429 c=0
Rk53 (\13\:n35g \14\:n35g) resistor r=0.5654 c=0
Rk54 (\13\:n35g \16\:n35g) resistor r=0.4319 c=0
Rk49 (\12\:qbint \13\:qbint) resistor r=0.4944 c=0
Rk50 (\13\:qbint \15\:qbint) resistor r=0.567 c=0
Rk51 (\13\:qbint \17\:qbint) resistor r=0.1463 c=0
Rk61 (\18\:qbint \19\:qbint) resistor r=0.2118 c=0
Rk55 (\5\:RTb \7\:RTb) resistor r=0.2224 c=0
Rk56 (\7\:RTb \8\:RTb) resistor r=0.4165 c=0
Rk57 (\8\:RTb \9\:RTb) resistor r=0.6885 c=0
Rk58 (\8\:RTb \11\:RTb) resistor r=0.3065 c=0
Rk37 (\5\:n35 \6\:n35) resistor r=0.4289 c=0
Rk38 (\6\:n35 \8\:n35) resistor r=0.3027 c=0
Rk42 (\10\:n35 \11\:n35) resistor r=0.4009 c=0
Rk43 (\11\:n35 \13\:n35) resistor r=0.3298 c=0
Rk65 (\15\:n35 \16\:n35) resistor r=0.3037 c=0
Rk66 (\16\:n35 \18\:n35) resistor r=0.2874 c=0
Rk70 (\2\:n41 \4\:n41) resistor r=0.7136 c=0
Rk71 (\2\:n42 \4\:n42) resistor r=0.5301 c=0
Rk67 (\2\:n40 \4\:n40) resistor r=0.6255 c=0
Rk23 (\2\:net426 \4\:net426) resistor r=0.5521 c=0
Rl20 (\2\:RN \4\:RN) resistor r=63.1757 c=0
Rl18 (\1\:RN \2\:RN) resistor r=153.56 c=0
Rl19 (\2\:RN \3\:RN) resistor r=0.5166 c=0
Rl45 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl31 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl34 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl33 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl32 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl64 (\7\:SN \8\:SN) resistor r=237.735 c=0
Rl65 (\8\:SN \9\:SN) resistor r=491.014 c=0
Rl12 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl48 (\4\:SN \6\:SN) resistor r=95.229 c=0
Rl46 (\3\:SN \4\:SN) resistor r=1129.61 c=0
Rl47 (\4\:SN \5\:SN) resistor r=14.5488 c=0
Rl2 (\2\:D \3\:D) resistor r=41.5405 c=0
Rl1 (\1\:D \2\:D) resistor r=137.096 c=0
Rl15 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl13 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl14 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl51 (\13\:CKNb \14\:CKNb) resistor r=166.412 c=0
Rl9 (\3\:CKNb \4\:CKNb) resistor r=349.426 c=0
Rl7 (CKNb \2\:CKNb) resistor r=147.923 c=0
Rl10 (\2\:CKNb \5\:CKNb) resistor r=59.4618 c=0
Rl8 (\2\:CKNb \3\:CKNb) resistor r=237.282 c=0
Rl11 (\2\:CKNb \6\:CKNb) resistor r=4.3228 c=0
Rl40 (\7\:CKNb \8\:CKNb) resistor r=66.1349 c=0
Rl43 (\8\:CKNb \11\:CKNb) resistor r=762.322 c=0
Rl44 (\9\:CKNb \12\:CKNb) resistor r=66.8717 c=0
Rl42 (\9\:CKNb \10\:CKNb) resistor r=132.647 c=0
Rl41 (\8\:CKNb \9\:CKNb) resistor r=465.929 c=0
Rl5 (mout \2\:mout) resistor r=24.2328 c=0
Rl6 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl21 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl16 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl17 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl3 (n20 \2\:n20) resistor r=205.495 c=0
Rl53 (\3\:RNb \4\:RNb) resistor r=234.8 c=0
Rl22 (RNb \2\:RNb) resistor r=62.7075 c=0
Rl54 (\4\:RNb \5\:RNb) resistor r=1125.6 c=0
Rl57 (\5\:RNb \8\:RNb) resistor r=775.703 c=0
Rl56 (\6\:RNb \7\:RNb) resistor r=142.538 c=0
Rl58 (\6\:RNb \9\:RNb) resistor r=2.7666 c=0
Rl55 (\5\:RNb \6\:RNb) resistor r=283.029 c=0
Rl4 (CKNbb \2\:CKNbb) resistor r=183.837 c=0
Rl25 (\5\:CKNbb \6\:CKNbb) resistor r=163.736 c=0
Rl52 (\7\:CKNbb \8\:CKNbb) resistor r=870.726 c=0
Rl24 (\3\:CKNbb \5\:CKNbb) resistor r=528.767 c=0
Rl23 (\3\:CKNbb \4\:CKNbb) resistor r=188.95 c=0
Rl28 (\3\:n35g \4\:n35g) resistor r=250.512 c=0
Rl26 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl27 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl29 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl59 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl63 (\10\:qbint \11\:qbint) resistor r=237.758 c=0
Rl39 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl36 (qbint \2\:qbint) resistor r=112.732 c=0
Rl38 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl37 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl60 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl62 (\8\:qbint \10\:qbint) resistor r=180.657 c=0
Rl61 (\8\:qbint \9\:qbint) resistor r=494.685 c=0
Rl30 (RTb \2\:RTb) resistor r=112.412 c=0
Rl35 (\3\:RTb \4\:RTb) resistor r=242.811 c=0
Rl49 (n35 \2\:n35) resistor r=508.667 c=0
Rl50 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz20 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz23 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz24 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz25 (\12\:VSS \13\:VSS) resistor r=37.5 c=0
Rz28 (\14\:VSS \15\:VSS) resistor r=37.5 c=0
Rz29 (\26\:VSS \27\:VSS) resistor r=75 c=0
Rz30 (\28\:VSS \29\:VSS) resistor r=75 c=0
Rz31 (\30\:VSS \31\:VSS) resistor r=75 c=0
Rz32 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz33 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz4 (\17\:CKNb \18\:CKNb) resistor r=75 c=0
Rz8 (\11\:mout \12\:mout) resistor r=75 c=0
Rz9 (\13\:mout \14\:mout) resistor r=75 c=0
Rz1 (\12\:n20 \13\:n20) resistor r=75 c=0
Rz2 (\14\:n20 \15\:n20) resistor r=75 c=0
Rz7 (\10\:RNb \11\:RNb) resistor r=75 c=0
Rz3 (\9\:CKNbb \10\:CKNbb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz17 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz21 (n42 \2\:n42) resistor r=75 c=0
Rz22 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz18 (n40 \2\:n40) resistor r=75 c=0
Rz19 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz5 (net426 \2\:net426) resistor r=75 c=0
Rz6 (\3\:net426 \4\:net426) resistor r=75 c=0
Ry26 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry27 (\14\:VDD \15\:VDD) resistor r=20.6667 c=0
Ry28 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry29 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry30 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry31 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry32 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry33 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry19 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry12 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry22 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry23 (\1\:VSS \4\:VSS) resistor r=6.2 c=0
Ry24 (\1\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry25 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry34 (\16\:VSS \17\:VSS) resistor r=12.4 c=0
Ry35 (\16\:VSS \18\:VSS) resistor r=5.1667 c=0
Ry36 (\16\:VSS \22\:VSS) resistor r=5.1667 c=0
Ry37 (\16\:VSS \25\:VSS) resistor r=62 c=0
Ry4 (\21\:CKNb \22\:CKNb) resistor r=62 c=0
Ry6 (\5\:mout \6\:mout) resistor r=62 c=0
Ry7 (\16\:mout \17\:mout) resistor r=62 c=0
Ry8 (\19\:mout \20\:mout) resistor r=62 c=0
Ry1 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry2 (\16\:n20 \17\:n20) resistor r=62 c=0
Ry5 (\13\:RNb \14\:RNb) resistor r=62 c=0
Ry3 (\13\:CKNbb \14\:CKNbb) resistor r=62 c=0
Ry10 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry16 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry15 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry17 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry9 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry11 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry18 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry20 (n41 \2\:n41) resistor r=62 c=0
Ry21 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx13 (\3\:RN \5\:RN) resistor r=45 c=0
Rx36 (\7\:RT \9\:RT) resistor r=45 c=0
Rx37 (\3\:RT \10\:RT) resistor r=45 c=0
Rx38 (\1\:RT \11\:RT) resistor r=45 c=0
Rx9 (\5\:SN \10\:SN) resistor r=45 c=0
Rx10 (\2\:SN \11\:SN) resistor r=45 c=0
Rx30 (\3\:SN \12\:SN) resistor r=45 c=0
Rx31 (\9\:SN \13\:SN) resistor r=45 c=0
Rx3 (\2\:D \4\:D) resistor r=45 c=0
Rx11 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx1 (\4\:CKNb \15\:CKNb) resistor r=45 c=0
Rx2 (\10\:CKNb \16\:CKNb) resistor r=45 c=0
Rx12 (\6\:CKNb \20\:CKNb) resistor r=45 c=0
Rx32 (\14\:CKNb \23\:CKNb) resistor r=45 c=0
Rx33 (\11\:CKNb \24\:CKNb) resistor r=45 c=0
Rx19 (\4\:mout \10\:mout) resistor r=45 c=0
Rx20 (\2\:mout \18\:mout) resistor r=45 c=0
Rx4 (\2\:n20 \10\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \11\:n20) resistor r=45 c=0
Rx6 (n20 \18\:n20) resistor r=45 c=0
Rx14 (\7\:n20 \19\:n20) resistor r=45 c=0
Rx15 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx16 (\8\:RNb \12\:RNb) resistor r=45 c=0
Rx17 (\9\:RNb \15\:RNb) resistor r=45 c=0
Rx18 (\2\:RNb \16\:RNb) resistor r=45 c=0
Rx7 (CKNbb \12\:CKNbb) resistor r=45 c=0
Rx8 (\3\:CKNbb \15\:CKNbb) resistor r=45 c=0
Rx22 (\6\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx23 (\8\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx24 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx27 (n35g \14\:n35g) resistor r=45 c=0
Rx26 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx34 (\9\:qbint \18\:qbint) resistor r=45 c=0
Rx35 (qbint \19\:qbint) resistor r=45 c=0
Rx28 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx29 (RTb \9\:RTb) resistor r=45 c=0
Rx21 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx25 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx39 (n35 \16\:n35) resistor r=45 c=0
mn25 (n21 \1\:D \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\14\:n20 \2\:CKNbb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\12\:n20 \12\:CKNb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (n30 \3\:mout \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\9\:CKNbb CKNb \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn20 (\17\:CKNb \1\:CKN \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (\3\:net426 \6\:SN \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=4.858e-14 ps=6.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 \3\:net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn22 (\10\:RNb \1\:RN \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn31 (\11\:mout RNb net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn40 (\7\:n35 \7\:CKNb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM1 (\16\:qbint \5\:n35g \28\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0121 \5\:qbint \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \2\:RT \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \7\:CKNbb \3\:n40 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn51 (n40 \3\:RNb \3\:n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n40 \11\:qbint n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn50 (n42 \8\:SN \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp26 (\16\:n20 \3\:CKNb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3011 \
        scb=0.0111155 scc=0.000221731 m=(1)
mp36 (\8\:n20 \4\:CKNbb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp35 (n31 mout \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp21 (\13\:CKNbb \5\:CKNb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\16\:mout \1\:SN \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp20 (\21\:CKNb \4\:CKN \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\19\:mout \3\:n20 net402 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp31 (net402 \7\:RNb \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.44121 \
        scb=0.00199344 scc=3.60278e-06 m=(1)
mp22 (\13\:RNb \4\:RN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.1952 \
        scb=0.00791337 scc=0.000154249 m=(1)
mp40 (\4\:n35 \5\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
PM1 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \13\:CKNb \3\:n41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp51 (n43 \4\:RNb \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (n41 \10\:qbint n43 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\3\:Q \7\:qbint \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
mp50 (n41 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.4549 \
        scb=0.0114313 scc=0.00019992 m=(1)
ends RDFFNSRQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:44:25 2012 )
// Library name: gsclib045
// Cell name: RDFFNSRX1
// View name: extracted

simulator lang=spectre

subckt RDFFNSRX1 CKN D ExtVDD Q QN RN RT SN VDD VSS
mp22 (\11\:RNb \1\:RN \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=17.4481 \
        scb=0.0196885 scc=0.000695801 m=(1)
C1 (Q VSS) capacitor c=6.28746e-17
C2 (VDD VSS) capacitor c=7.46779e-16
C3 (CKN VSS) capacitor c=3.95786e-17
C4 (QN VSS) capacitor c=2.45377e-17
C5 (ExtVDD VSS) capacitor c=3.40062e-16
C6 (SN VSS) capacitor c=3.73036e-17
C7 (D VSS) capacitor c=3.64853e-17
C8 (RT VSS) capacitor c=5.37929e-17
C9 (n20 VSS) capacitor c=5.60775e-17
C10 (CKNb VSS) capacitor c=4.54719e-17
C11 (mout VSS) capacitor c=4.81917e-17
C12 (RNb VSS) capacitor c=3.83103e-17
C13 (CKNbb VSS) capacitor c=8.04371e-17
C14 (n35g VSS) capacitor c=1.61541e-17
C15 (qbint VSS) capacitor c=4.42103e-17
C16 (n35 VSS) capacitor c=4.704e-17
C17 (RTb VSS) capacitor c=5.51558e-17
C18 (qint VSS) capacitor c=2.23971e-17
C19 (n41 VSS) capacitor c=8.42008e-17
C20 (net426 VSS) capacitor c=8.68145e-17
C21 (n40 VSS) capacitor c=8.44192e-17
C22 (n42 VSS) capacitor c=7.9367e-17
C23 (\9\:SN VSS) capacitor c=7.05332e-17
C24 (\7\:qbint VSS) capacitor c=3.33117e-17
C25 (\11\:qbint VSS) capacitor c=1.40691e-16
C26 (\9\:RNb VSS) capacitor c=1.30339e-16
C27 (\13\:qbint VSS) capacitor c=4.54827e-17
C28 (\3\:qint VSS) capacitor c=6.11524e-17
C29 (\12\:CKNb VSS) capacitor c=5.92662e-17
C30 (\4\:RTb VSS) capacitor c=1.20105e-16
C31 (\7\:RT VSS) capacitor c=4.93104e-17
C32 (\4\:qbint VSS) capacitor c=6.71074e-17
C33 (\3\:n35g VSS) capacitor c=9.23598e-17
C34 (\4\:RT VSS) capacitor c=9.70366e-17
C35 (\7\:CKNbb VSS) capacitor c=4.02998e-17
C36 (\7\:RNb VSS) capacitor c=5.57751e-17
C37 (\3\:n20 VSS) capacitor c=4.79469e-17
C38 (\4\:CKN VSS) capacitor c=5.81773e-17
C39 (\1\:SN VSS) capacitor c=2.606e-17
C40 (\5\:CKNb VSS) capacitor c=4.39552e-17
C41 (\6\:CKNbb VSS) capacitor c=9.26623e-17
C42 (\3\:CKNb VSS) capacitor c=1.63018e-16
C43 (\4\:D VSS) capacitor c=7.4039e-17
C44 (\1\:RN VSS) capacitor c=4.26919e-17
C45 (\10\:SN VSS) capacitor c=1.32177e-16
C46 (\6\:qbint VSS) capacitor c=3.70594e-17
C47 (\12\:qbint VSS) capacitor c=8.05994e-17
C48 (\8\:RNb VSS) capacitor c=6.59499e-17
C49 (\14\:qbint VSS) capacitor c=4.66967e-17
C50 (\4\:qint VSS) capacitor c=3.79151e-17
C51 (\9\:CKNbb VSS) capacitor c=5.18818e-17
C52 (\5\:RT VSS) capacitor c=1.51407e-16
C53 (\6\:RT VSS) capacitor c=6.53002e-17
C54 (\5\:qbint VSS) capacitor c=3.89239e-17
C55 (\4\:n35g VSS) capacitor c=2.69017e-17
C56 (\6\:CKNb VSS) capacitor c=3.37014e-17
C57 (\6\:n20 VSS) capacitor c=6.14389e-17
C58 (\1\:CKN VSS) capacitor c=2.978e-17
C59 (\3\:SN VSS) capacitor c=4.67477e-17
C60 (\3\:mout VSS) capacitor c=4.57969e-17
C61 (\11\:CKNb VSS) capacitor c=4.92242e-17
C62 (\1\:D VSS) capacitor c=6.31199e-17
C63 (\4\:RN VSS) capacitor c=3.72482e-17
C64 (\10\:RNb VSS) capacitor c=5.65938e-17
C65 (\10\:CKNbb VSS) capacitor c=4.08873e-17
C66 (\3\:n35 VSS) capacitor c=7.87125e-17
C67 (\10\:qbint VSS) capacitor c=8.42169e-17
C68 (\8\:SN VSS) capacitor c=6.09072e-17
C69 (\11\:SN VSS) capacitor c=9.5301e-17
C70 (\13\:CKNb VSS) capacitor c=5.9051e-17
C71 (\1\:RT VSS) capacitor c=1.61738e-17
C72 (\10\:CKNb VSS) capacitor c=1.4062e-16
C73 (\3\:RTb VSS) capacitor c=9.79047e-17
C74 (\7\:SN VSS) capacitor c=5.66406e-17
C75 (\4\:n35 VSS) capacitor c=6.72119e-17
C76 (\3\:qbint VSS) capacitor c=4.77989e-17
C77 (\6\:SN VSS) capacitor c=1.67248e-16
C78 (\1\:ExtVDD VSS) capacitor c=7.97108e-17
C79 (\2\:ExtVDD VSS) capacitor c=8.02734e-17
C80 (\2\:RTb VSS) capacitor c=5.37409e-17
C81 (\5\:n35g VSS) capacitor c=1.0197e-16
C82 (\2\:n35 VSS) capacitor c=5.55821e-17
C83 (\3\:CKNbb VSS) capacitor c=6.3058e-17
C84 (\3\:RNb VSS) capacitor c=4.02966e-17
C85 (\2\:RNb VSS) capacitor c=4.32741e-17
C86 (\4\:RNb VSS) capacitor c=4.85635e-17
C87 (\7\:n20 VSS) capacitor c=5.32732e-17
C88 (\4\:n20 VSS) capacitor c=1.25118e-16
C89 (\3\:CKN VSS) capacitor c=2.44621e-17
C90 (\2\:CKNb VSS) capacitor c=9.72807e-17
C91 (\2\:SN VSS) capacitor c=4.948e-17
C92 (\5\:SN VSS) capacitor c=2.63449e-17
C93 (\8\:CKNbb VSS) capacitor c=2.03365e-17
C94 (\2\:CKNbb VSS) capacitor c=5.3329e-17
C95 (\2\:mout VSS) capacitor c=4.33727e-17
C96 (\4\:mout VSS) capacitor c=3.16656e-17
C97 (\5\:n20 VSS) capacitor c=1.11424e-16
C98 (\4\:CKNb VSS) capacitor c=7.51052e-17
C99 (\9\:CKNb VSS) capacitor c=2.68879e-17
C100 (\3\:D VSS) capacitor c=1.57765e-17
C101 (\6\:RNb VSS) capacitor c=1.36091e-16
C102 (\2\:n20 VSS) capacitor c=6.9687e-17
C103 (\3\:RN VSS) capacitor c=4.95741e-17
C104 (\1\:VDD VSS) capacitor c=3.0029e-17
C105 (\11\:VDD VSS) capacitor c=4.49493e-17
C106 (\3\:Q VSS) capacitor c=7.33516e-17
C107 (\13\:VDD VSS) capacitor c=5.03811e-17
C108 (\9\:qint VSS) capacitor c=5.46386e-17
C109 (\15\:VDD VSS) capacitor c=7.86472e-17
C110 (\3\:n41 VSS) capacitor c=9.77577e-17
C111 (\4\:QN VSS) capacitor c=6.25671e-17
C112 (\17\:n35 VSS) capacitor c=1.12496e-16
C113 (\15\:n35g VSS) capacitor c=5.66699e-17
C114 (\9\:RTb VSS) capacitor c=3.98197e-17
C115 (\11\:ExtVDD VSS) capacitor c=3.21338e-17
C116 (\3\:ExtVDD VSS) capacitor c=1.02066e-16
C117 (\7\:n35g VSS) capacitor c=6.78535e-17
C118 (\17\:qbint VSS) capacitor c=6.54131e-17
C119 (\5\:n35 VSS) capacitor c=5.94583e-17
C120 (\13\:n35 VSS) capacitor c=1.03593e-16
C121 (\5\:mout VSS) capacitor c=1.31817e-16
C122 (\17\:VDD VSS) capacitor c=4.42334e-17
C123 (\18\:CKNb VSS) capacitor c=4.93707e-17
C124 (\15\:mout VSS) capacitor c=1.11308e-16
C125 (\22\:VDD VSS) capacitor c=6.16723e-17
C126 (\20\:VDD VSS) capacitor c=6.65173e-17
C127 (\12\:CKNbb VSS) capacitor c=5.9547e-17
C128 (\18\:n20 VSS) capacitor c=3.40507e-17
C129 (\8\:n20 VSS) capacitor c=6.26405e-17
C130 (\29\:VDD VSS) capacitor c=3.87439e-17
C131 (\11\:RNb VSS) capacitor c=5.05803e-17
C132 (\27\:VDD VSS) capacitor c=3.9673e-17
C133 (\1\:Q VSS) capacitor c=5.44448e-17
C134 (\5\:qint VSS) capacitor c=4.6912e-17
C135 (\3\:n42 VSS) capacitor c=8.07711e-17
C136 (\3\:n40 VSS) capacitor c=8.14268e-17
C137 (\1\:QN VSS) capacitor c=3.98213e-17
C138 (\19\:n35 VSS) capacitor c=9.35735e-17
C139 (\11\:n35g VSS) capacitor c=2.94181e-17
C140 (\6\:RTb VSS) capacitor c=1.85147e-16
C141 (\9\:n35g VSS) capacitor c=8.36239e-17
C142 (\19\:qbint VSS) capacitor c=2.27182e-17
C143 (\11\:n35 VSS) capacitor c=2.55971e-17
C144 (\9\:n35 VSS) capacitor c=2.61597e-17
C145 (\11\:mout VSS) capacitor c=3.71471e-17
C146 (\13\:mout VSS) capacitor c=3.82409e-17
C147 (\20\:CKNb VSS) capacitor c=5.06296e-17
C148 (\3\:net426 VSS) capacitor c=1.00173e-16
C149 (\15\:CKNbb VSS) capacitor c=4.73823e-17
C150 (\14\:n20 VSS) capacitor c=5.96474e-17
C151 (\12\:n20 VSS) capacitor c=8.58402e-17
C152 (\14\:RNb VSS) capacitor c=7.34902e-17
C153 (VDD VSS) capacitor c=5.30266e-17
C154 (\2\:D VSS) capacitor c=6.16991e-17
C155 (\2\:CKN VSS) capacitor c=4.21681e-17
C156 (\5\:RNb VSS) capacitor c=1.78422e-16
C157 (\4\:CKNbb VSS) capacitor c=9.07671e-17
C158 (\5\:CKNbb VSS) capacitor c=9.27207e-17
C159 (\2\:n35g VSS) capacitor c=3.44877e-17
C160 (\4\:SN VSS) capacitor c=2.11916e-16
C161 (\2\:qbint VSS) capacitor c=4.29647e-17
C162 (\7\:CKNb VSS) capacitor c=1.28817e-16
C163 (\8\:CKNb VSS) capacitor c=7.32144e-17
C164 (\2\:RT VSS) capacitor c=1.69808e-16
C165 (\3\:RT VSS) capacitor c=1.23614e-16
C166 (\2\:qint VSS) capacitor c=1.60465e-17
C167 (\5\:RN VSS) capacitor c=2.032e-17
C168 (\6\:RN VSS) capacitor c=4.12857e-17
C169 (\13\:RNb VSS) capacitor c=1.06837e-16
C170 (\5\:D VSS) capacitor c=3.93524e-17
C171 (\14\:CKNb VSS) capacitor c=1.55651e-16
C172 (\15\:CKNb VSS) capacitor c=1.37959e-16
C173 (\8\:qbint VSS) capacitor c=5.09694e-17
C174 (\9\:qbint VSS) capacitor c=7.70021e-17
C175 (\10\:n20 VSS) capacitor c=7.77765e-17
C176 (\11\:n20 VSS) capacitor c=9.26184e-17
C177 (\16\:n20 VSS) capacitor c=7.24905e-17
C178 (\17\:n20 VSS) capacitor c=6.22298e-17
C179 (\11\:CKNbb VSS) capacitor c=3.34717e-17
C180 (\14\:CKNbb VSS) capacitor c=5.52379e-17
C181 (\12\:SN VSS) capacitor c=3.46687e-17
C182 (\13\:SN VSS) capacitor c=4.69886e-17
C183 (\7\:CKN VSS) capacitor c=2.75835e-17
C184 (\16\:CKNb VSS) capacitor c=3.94812e-17
C185 (\17\:CKNb VSS) capacitor c=4.56597e-17
C186 (\20\:n20 VSS) capacitor c=7.68801e-17
C187 (\21\:n20 VSS) capacitor c=7.95904e-17
C188 (\16\:RNb VSS) capacitor c=7.12857e-17
C189 (\17\:RNb VSS) capacitor c=8.15912e-17
C190 (\7\:mout VSS) capacitor c=1.55721e-16
C191 (\8\:mout VSS) capacitor c=5.3216e-17
C192 (\9\:mout VSS) capacitor c=9.99555e-17
C193 (\10\:mout VSS) capacitor c=8.64285e-17
C194 (\17\:mout VSS) capacitor c=6.966e-17
C195 (\7\:n35 VSS) capacitor c=7.78991e-17
C196 (\8\:n35 VSS) capacitor c=1.20587e-16
C197 (\6\:n35g VSS) capacitor c=3.78131e-17
C198 (\13\:ExtVDD VSS) capacitor c=4.09546e-17
C199 (\15\:qbint VSS) capacitor c=9.02634e-17
C200 (\16\:qbint VSS) capacitor c=1.09415e-16
C201 (\13\:n35g VSS) capacitor c=1.05417e-16
C202 (\14\:n35g VSS) capacitor c=1.17203e-16
C203 (\14\:SN VSS) capacitor c=3.34439e-17
C204 (\15\:SN VSS) capacitor c=5.07691e-17
C205 (\15\:n35 VSS) capacitor c=8.70436e-17
C206 (\16\:n35 VSS) capacitor c=7.46794e-17
C207 (\5\:RTb VSS) capacitor c=8.22395e-17
C208 (\8\:RTb VSS) capacitor c=1.02093e-16
C209 (\16\:SN VSS) capacitor c=8.38912e-17
C210 (\17\:SN VSS) capacitor c=8.4246e-17
C211 (\22\:CKNb VSS) capacitor c=1.2601e-16
C212 (\23\:CKNb VSS) capacitor c=1.25397e-16
C213 (\21\:qbint VSS) capacitor c=2.37761e-17
C214 (\22\:qbint VSS) capacitor c=2.96829e-17
C215 (\8\:RT VSS) capacitor c=4.62106e-17
C216 (\17\:CKNbb VSS) capacitor c=3.42585e-16
C217 (\18\:CKNbb VSS) capacitor c=3.83129e-16
C218 (\18\:RNb VSS) capacitor c=3.8052e-16
C219 (\19\:RNb VSS) capacitor c=3.25706e-16
C220 (\3\:QN VSS) capacitor c=3.57486e-17
C221 (\21\:n35 VSS) capacitor c=4.04494e-17
C222 (\7\:qint VSS) capacitor c=5.38692e-17
C223 (\8\:qint VSS) capacitor c=3.53277e-17
C224 (\3\:VDD VSS) capacitor c=3.04319e-17
C225 (\4\:VDD VSS) capacitor c=3.28494e-17
C226 (\6\:VDD VSS) capacitor c=1.00014e-17
C227 (\7\:VDD VSS) capacitor c=2.89438e-16
C228 (\8\:VDD VSS) capacitor c=2.38913e-16
C229 (\10\:VDD VSS) capacitor c=4.43963e-17
C230 (\19\:VDD VSS) capacitor c=1.41202e-17
C231 (\24\:VDD VSS) capacitor c=2.90118e-17
C232 (\26\:VDD VSS) capacitor c=3.51224e-17
Rk76 (\2\:Q Q) resistor r=0.1743 c=0
Rk77 (Q \4\:Q) resistor r=0.3098 c=0
Rk92 (\2\:VDD \3\:VDD) resistor r=0.3391 c=0
Rk93 (\3\:VDD \4\:VDD) resistor r=0.2189 c=0
Rk94 (\4\:VDD \6\:VDD) resistor r=0.06709 c=0
Rk95 (\6\:VDD \7\:VDD) resistor r=0.05214 c=0
Rk96 (\7\:VDD \8\:VDD) resistor r=1.6493 c=0
Rk97 (\8\:VDD \10\:VDD) resistor r=0.2216 c=0
Rk98 (\3\:VDD \12\:VDD) resistor r=0.3594 c=0
Rk99 (\4\:VDD \14\:VDD) resistor r=0.2953 c=0
Rk100 (\7\:VDD \16\:VDD) resistor r=0.3642 c=0
Rk101 (\8\:VDD \18\:VDD) resistor r=0.2033 c=0
Rk102 (\10\:VDD \19\:VDD) resistor r=0.09511 c=0
Rk103 (\19\:VDD \21\:VDD) resistor r=0.2308 c=0
Rk104 (\10\:VDD \23\:VDD) resistor r=0.356 c=0
Rk107 (\24\:VDD VDD) resistor r=0.1964 c=0
Rk105 (\19\:VDD \24\:VDD) resistor r=0.07686 c=0
Rk106 (\24\:VDD \25\:VDD) resistor r=0.2207 c=0
Rk108 (VDD \26\:VDD) resistor r=0.06983 c=0
Rk109 (\26\:VDD VDD) resistor r=0.1671 c=0
Rk110 (VDD \28\:VDD) resistor r=0.3808 c=0
Rk111 (\26\:VDD \30\:VDD) resistor r=0.2828 c=0
Rk19 (\5\:CKN CKN) resistor r=0.003631 c=0
Rk21 (\5\:CKN \7\:CKN) resistor r=0.01537 c=0
Rk20 (\6\:CKN \7\:CKN) resistor r=0.005673 c=0
Rk68 (\3\:QN QN) resistor r=0.01883 c=0
Rk67 (\2\:QN \3\:QN) resistor r=0.2918 c=0
Rk69 (\3\:QN \5\:QN) resistor r=0.3294 c=0
Rk85 (VSS VSS) resistor r=0.8423 c=0
Rk80 (\2\:VSS \3\:VSS) resistor r=0.02971 c=0
Rk81 (\3\:VSS \4\:VSS) resistor r=0.2689 c=0
Rk82 (\4\:VSS \5\:VSS) resistor r=0.7852 c=0
Rk84 (\6\:VSS VSS) resistor r=0.2988 c=0
Rk83 (\5\:VSS \6\:VSS) resistor r=0.06211 c=0
Rk86 (VSS \7\:VSS) resistor r=0.05507 c=0
Rk87 (\7\:VSS \8\:VSS) resistor r=0.1369 c=0
Rk88 (\8\:VSS \10\:VSS) resistor r=0.6667 c=0
Rk89 (\3\:VSS \12\:VSS) resistor r=0.2507 c=0
Rk90 (\5\:VSS \14\:VSS) resistor r=0.1674 c=0
Rk91 (\8\:VSS \16\:VSS) resistor r=0.2532 c=0
Rk112 (\18\:VSS \20\:VSS) resistor r=0.3664 c=0
Rk113 (\20\:VSS \21\:VSS) resistor r=0.2365 c=0
Rk114 (\21\:VSS \22\:VSS) resistor r=0.3611 c=0
Rk115 (\22\:VSS \23\:VSS) resistor r=0.3138 c=0
Rk117 (\24\:VSS VSS) resistor r=0.1242 c=0
Rk116 (\23\:VSS \24\:VSS) resistor r=0.2089 c=0
Rk119 (\25\:VSS VSS) resistor r=0.543 c=0
Rk118 (VSS \25\:VSS) resistor r=0.2993 c=0
Rk120 (VSS \26\:VSS) resistor r=0.03743 c=0
Rk121 (\26\:VSS \27\:VSS) resistor r=0.2166 c=0
Rk122 (\27\:VSS \28\:VSS) resistor r=0.2042 c=0
Rk123 (\28\:VSS \29\:VSS) resistor r=0.0945 c=0
Rk124 (\21\:VSS \31\:VSS) resistor r=0.2657 c=0
Rk125 (\23\:VSS \33\:VSS) resistor r=0.1908 c=0
Rk126 (\24\:VSS \35\:VSS) resistor r=0.1959 c=0
Rk127 (\26\:VSS \37\:VSS) resistor r=0.2425 c=0
Rk128 (\28\:VSS \39\:VSS) resistor r=0.2302 c=0
Rk46 (ExtVDD ExtVDD) resistor r=0.002123 c=0
Rk43 (\4\:ExtVDD \5\:ExtVDD) resistor r=0.02229 c=0
Rk44 (\5\:ExtVDD \7\:ExtVDD) resistor r=0.02229 c=0
Rk47 (\8\:ExtVDD ExtVDD) resistor r=0.01538 c=0
Rk45 (\5\:ExtVDD \8\:ExtVDD) resistor r=0.02006 c=0
Rk49 (\12\:ExtVDD \13\:ExtVDD) resistor r=0.08224 c=0
Rk17 (\12\:SN SN) resistor r=0.03613 c=0
Rk18 (SN \13\:SN) resistor r=0.2361 c=0
Rk56 (\14\:SN \15\:SN) resistor r=0.1984 c=0
Rk61 (\16\:SN \17\:SN) resistor r=0.4598 c=0
Rk6 (\5\:D D) resistor r=0.05276 c=0
Rk1 (RN \5\:RN) resistor r=0.004334 c=0
Rk3 (\5\:RN \6\:RN) resistor r=0.01326 c=0
Rk2 (\6\:RN \7\:RN) resistor r=0.004334 c=0
Rk64 (RT \8\:RT) resistor r=0.06408 c=0
Rk8 (\9\:n20 \10\:n20) resistor r=0.3483 c=0
Rk9 (\9\:n20 \11\:n20) resistor r=0.2313 c=0
Rk10 (\11\:n20 \13\:n20) resistor r=0.5005 c=0
Rk11 (\15\:n20 \16\:n20) resistor r=0.4746 c=0
Rk12 (\16\:n20 \17\:n20) resistor r=0.3431 c=0
Rk13 (\16\:n20 \19\:n20) resistor r=0.165 c=0
Rk25 (\20\:n20 \21\:n20) resistor r=0.4665 c=0
Rk7 (\14\:CKNb \15\:CKNb) resistor r=0.8559 c=0
Rk22 (\16\:CKNb \17\:CKNb) resistor r=0.2188 c=0
Rk23 (\17\:CKNb \19\:CKNb) resistor r=0.2577 c=0
Rk24 (\17\:CKNb \21\:CKNb) resistor r=0.3312 c=0
Rk62 (\22\:CKNb \23\:CKNb) resistor r=0.7116 c=0
Rk28 (\6\:mout \7\:mout) resistor r=0.7682 c=0
Rk29 (\7\:mout \8\:mout) resistor r=0.3554 c=0
Rk30 (\8\:mout \9\:mout) resistor r=0.1724 c=0
Rk31 (\9\:mout \10\:mout) resistor r=0.3428 c=0
Rk32 (\7\:mout \12\:mout) resistor r=0.124 c=0
Rk33 (\8\:mout \14\:mout) resistor r=0.1005 c=0
Rk34 (\9\:mout \16\:mout) resistor r=0.5127 c=0
Rk35 (\10\:mout \17\:mout) resistor r=0.4285 c=0
Rk4 (\12\:RNb \13\:RNb) resistor r=0.1647 c=0
Rk5 (\13\:RNb \15\:RNb) resistor r=0.3933 c=0
Rk27 (\16\:RNb \17\:RNb) resistor r=0.3493 c=0
Rk66 (\18\:RNb \19\:RNb) resistor r=2.354 c=0
Rk14 (\11\:CKNbb \13\:CKNbb) resistor r=0.1525 c=0
Rk15 (\13\:CKNbb \14\:CKNbb) resistor r=0.5025 c=0
Rk16 (\14\:CKNbb \16\:CKNbb) resistor r=0.23 c=0
Rk65 (\17\:CKNbb \18\:CKNbb) resistor r=2.3458 c=0
Rk41 (\6\:n35g \8\:n35g) resistor r=0.1274 c=0
Rk42 (\8\:n35g \10\:n35g) resistor r=0.5913 c=0
Rk53 (\12\:n35g \13\:n35g) resistor r=0.245 c=0
Rk54 (\13\:n35g \14\:n35g) resistor r=0.5703 c=0
Rk55 (\13\:n35g \16\:n35g) resistor r=0.4355 c=0
Rk50 (\15\:qbint \16\:qbint) resistor r=0.4987 c=0
Rk51 (\16\:qbint \18\:qbint) resistor r=0.5718 c=0
Rk52 (\16\:qbint \20\:qbint) resistor r=0.1475 c=0
Rk63 (\21\:qbint \22\:qbint) resistor r=0.2135 c=0
Rk36 (\6\:n35 \7\:n35) resistor r=0.4146 c=0
Rk37 (\7\:n35 \8\:n35) resistor r=0.5509 c=0
Rk38 (\8\:n35 \10\:n35) resistor r=0.1724 c=0
Rk39 (\7\:n35 \12\:n35) resistor r=0.1502 c=0
Rk40 (\8\:n35 \14\:n35) resistor r=0.5954 c=0
Rk57 (\15\:n35 \16\:n35) resistor r=0.4131 c=0
Rk70 (\18\:n35 \20\:n35) resistor r=0.6618 c=0
Rk71 (\20\:n35 \21\:n35) resistor r=0.1239 c=0
Rk58 (\5\:RTb \7\:RTb) resistor r=0.5298 c=0
Rk59 (\7\:RTb \8\:RTb) resistor r=0.7279 c=0
Rk60 (\8\:RTb \10\:RTb) resistor r=0.1206 c=0
Rk72 (\6\:qint \7\:qint) resistor r=0.2561 c=0
Rk73 (\7\:qint \8\:qint) resistor r=0.1622 c=0
Rk74 (\7\:qint \10\:qint) resistor r=0.2924 c=0
Rk78 (\2\:n41 \4\:n41) resistor r=0.7195 c=0
Rk26 (\2\:net426 \4\:net426) resistor r=0.5568 c=0
Rk75 (\2\:n40 \4\:n40) resistor r=0.6308 c=0
Rk79 (\2\:n42 \4\:n42) resistor r=0.5345 c=0
Rl18 (\2\:CKN \4\:CKN) resistor r=193.945 c=0
Rl16 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl17 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl38 (\1\:ExtVDD \2\:ExtVDD) resistor r=149.73 c=0
Rl75 (\9\:SN \10\:SN) resistor r=237.735 c=0
Rl76 (\10\:SN \11\:SN) resistor r=491.014 c=0
Rl58 (\7\:SN \8\:SN) resistor r=131.297 c=0
Rl11 (\1\:SN \2\:SN) resistor r=37.2721 c=0
Rl39 (\3\:SN \4\:SN) resistor r=95.229 c=0
Rl41 (\4\:SN \6\:SN) resistor r=842.68 c=0
Rl40 (\4\:SN \5\:SN) resistor r=12.5751 c=0
Rl7 (\2\:D \4\:D) resistor r=107.406 c=0
Rl5 (\1\:D \2\:D) resistor r=149.714 c=0
Rl6 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl55 (\2\:RT \5\:RT) resistor r=741.185 c=0
Rl52 (\1\:RT \2\:RT) resistor r=0.6084 c=0
Rl57 (\3\:RT \7\:RT) resistor r=35.9829 c=0
Rl54 (\3\:RT \4\:RT) resistor r=273.346 c=0
Rl56 (\3\:RT \6\:RT) resistor r=195.631 c=0
Rl53 (\2\:RT \3\:RT) resistor r=206.132 c=0
Rl21 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl19 (\3\:n20 \4\:n20) resistor r=30.6172 c=0
Rl20 (\4\:n20 \5\:n20) resistor r=279.747 c=0
Rl4 (n20 \2\:n20) resistor r=283.74 c=0
Rl60 (\12\:CKNb \13\:CKNb) resistor r=195.656 c=0
Rl12 (CKNb \2\:CKNb) resistor r=135.348 c=0
Rl15 (\2\:CKNb \5\:CKNb) resistor r=95.9489 c=0
Rl13 (\2\:CKNb \3\:CKNb) resistor r=285.906 c=0
Rl14 (\3\:CKNb \4\:CKNb) resistor r=306.38 c=0
Rl47 (\6\:CKNb \7\:CKNb) resistor r=66.1349 c=0
Rl50 (\7\:CKNb \10\:CKNb) resistor r=762.322 c=0
Rl51 (\8\:CKNb \11\:CKNb) resistor r=60.7265 c=0
Rl49 (\8\:CKNb \9\:CKNb) resistor r=81.3209 c=0
Rl48 (\7\:CKNb \8\:CKNb) resistor r=462.851 c=0
Rl8 (mout \2\:mout) resistor r=24.2328 c=0
Rl9 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl65 (\8\:RNb \9\:RNb) resistor r=234.8 c=0
Rl66 (\9\:RNb \10\:RNb) resistor r=259.682 c=0
Rl22 (RNb \2\:RNb) resistor r=62.7075 c=0
Rl23 (\3\:RNb \4\:RNb) resistor r=180.578 c=0
Rl26 (\5\:RNb \7\:RNb) resistor r=63.8867 c=0
Rl24 (\4\:RNb \5\:RNb) resistor r=55.666 c=0
Rl25 (\5\:RNb \6\:RNb) resistor r=470.821 c=0
Rl61 (\9\:CKNbb \10\:CKNbb) resistor r=130.93 c=0
Rl10 (CKNbb \2\:CKNbb) resistor r=168.841 c=0
Rl30 (\4\:CKNbb \7\:CKNbb) resistor r=127.816 c=0
Rl27 (\3\:CKNbb \4\:CKNbb) resistor r=337.866 c=0
Rl29 (\5\:CKNbb \6\:CKNbb) resistor r=215.834 c=0
Rl31 (\5\:CKNbb \8\:CKNbb) resistor r=5.1123 c=0
Rl28 (\4\:CKNbb \5\:CKNbb) resistor r=359.734 c=0
Rl35 (\3\:n35g \5\:n35g) resistor r=332.357 c=0
Rl32 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl33 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl34 (\2\:n35g \4\:n35g) resistor r=92.0109 c=0
Rl67 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl72 (\11\:qbint \12\:qbint) resistor r=237.758 c=0
Rl74 (\13\:qbint \14\:qbint) resistor r=199.018 c=0
Rl46 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl43 (qbint \2\:qbint) resistor r=112.732 c=0
Rl45 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl44 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl68 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl71 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl73 (\9\:qbint \13\:qbint) resistor r=89.4853 c=0
Rl70 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl69 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl59 (\3\:n35 \4\:n35) resistor r=232.465 c=0
Rl37 (n35 \2\:n35) resistor r=149.925 c=0
Rl42 (\3\:RTb \4\:RTb) resistor r=344.856 c=0
Rl36 (RTb \2\:RTb) resistor r=115.333 c=0
Rl62 (qint \2\:qint) resistor r=3.1216 c=0
Rl63 (\2\:qint \3\:qint) resistor r=66.0494 c=0
Rl64 (\2\:qint \4\:qint) resistor r=75.4463 c=0
Rz22 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz17 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz25 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz26 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz27 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz28 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz31 (\17\:VSS \18\:VSS) resistor r=37.5 c=0
Rz32 (\30\:VSS \31\:VSS) resistor r=37.5 c=0
Rz33 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz34 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz35 (\36\:VSS \37\:VSS) resistor r=75 c=0
Rz36 (\38\:VSS \39\:VSS) resistor r=75 c=0
Rz2 (\12\:n20 \13\:n20) resistor r=75 c=0
Rz3 (\14\:n20 \15\:n20) resistor r=75 c=0
Rz5 (\20\:CKNb \21\:CKNb) resistor r=75 c=0
Rz8 (\11\:mout \12\:mout) resistor r=75 c=0
Rz9 (\13\:mout \14\:mout) resistor r=75 c=0
Rz1 (\14\:RNb \15\:RNb) resistor r=75 c=0
Rz4 (\15\:CKNbb \16\:CKNbb) resistor r=75 c=0
Rz12 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz10 (\9\:n35 \10\:n35) resistor r=75 c=0
Rz11 (\11\:n35 \12\:n35) resistor r=75 c=0
Rz18 (\19\:n35 \20\:n35) resistor r=75 c=0
Rz16 (\6\:RTb \7\:RTb) resistor r=75 c=0
Rz19 (\5\:qint \6\:qint) resistor r=75 c=0
Rz6 (net426 \2\:net426) resistor r=75 c=0
Rz7 (\3\:net426 \4\:net426) resistor r=75 c=0
Rz20 (n40 \2\:n40) resistor r=75 c=0
Rz21 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz23 (n42 \2\:n42) resistor r=75 c=0
Rz24 (\3\:n42 \4\:n42) resistor r=75 c=0
Ry20 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry27 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry28 (\11\:VDD \12\:VDD) resistor r=20.6667 c=0
Ry29 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry30 (\15\:VDD \16\:VDD) resistor r=20.6667 c=0
Ry31 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry32 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry33 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry34 (\20\:VDD \25\:VDD) resistor r=62 c=0
Ry35 (\27\:VDD \28\:VDD) resistor r=62 c=0
Ry36 (\29\:VDD \30\:VDD) resistor r=62 c=0
Ry17 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry23 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry24 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry25 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry26 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry37 (\19\:VSS \20\:VSS) resistor r=12.4 c=0
Ry38 (\19\:VSS \22\:VSS) resistor r=8.8571 c=0
Ry39 (\19\:VSS \25\:VSS) resistor r=5.1667 c=0
Ry40 (\19\:VSS \27\:VSS) resistor r=15.5 c=0
Ry41 (\19\:VSS \29\:VSS) resistor r=31 c=0
Ry11 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry12 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry13 (\11\:ExtVDD \12\:ExtVDD) resistor r=62 c=0
Ry2 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry3 (\18\:n20 \19\:n20) resistor r=62 c=0
Ry5 (\18\:CKNb \19\:CKNb) resistor r=62 c=0
Ry6 (\5\:mout \6\:mout) resistor r=62 c=0
Ry7 (\15\:mout \16\:mout) resistor r=31 c=0
Ry1 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry4 (\12\:CKNbb \13\:CKNbb) resistor r=62 c=0
Ry10 (\7\:n35g \8\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry8 (\5\:n35 \6\:n35) resistor r=62 c=0
Ry9 (\13\:n35 \14\:n35) resistor r=62 c=0
Ry18 (\17\:n35 \18\:n35) resistor r=62 c=0
Ry16 (\9\:RTb \10\:RTb) resistor r=62 c=0
Ry19 (\9\:qint \10\:qint) resistor r=62 c=0
Ry21 (n41 \2\:n41) resistor r=62 c=0
Ry22 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx13 (\3\:CKN \6\:CKN) resistor r=45 c=0
Rx23 (\2\:ExtVDD \8\:ExtVDD) resistor r=15 c=0
Rx24 (\1\:ExtVDD \13\:ExtVDD) resistor r=45 c=0
Rx11 (\5\:SN \12\:SN) resistor r=45 c=0
Rx12 (\2\:SN \13\:SN) resistor r=45 c=0
Rx27 (\6\:SN \14\:SN) resistor r=45 c=0
Rx28 (\7\:SN \15\:SN) resistor r=45 c=0
Rx33 (\8\:SN \16\:SN) resistor r=45 c=0
Rx34 (\11\:SN \17\:SN) resistor r=45 c=0
Rx3 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (\3\:RN \7\:RN) resistor r=45 c=0
Rx39 (\1\:RT \8\:RT) resistor r=45 c=0
Rx6 (\2\:n20 \10\:n20) resistor r=45 c=0
Rx7 (\5\:n20 \11\:n20) resistor r=45 c=0
Rx8 (n20 \17\:n20) resistor r=45 c=0
Rx15 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx16 (\7\:n20 \21\:n20) resistor r=45 c=0
Rx4 (\4\:CKNb \14\:CKNb) resistor r=45 c=0
Rx5 (\9\:CKNb \15\:CKNb) resistor r=45 c=0
Rx14 (\2\:CKNb \16\:CKNb) resistor r=45 c=0
Rx35 (\13\:CKNb \22\:CKNb) resistor r=45 c=0
Rx36 (\10\:CKNb \23\:CKNb) resistor r=45 c=0
Rx19 (\4\:mout \10\:mout) resistor r=45 c=0
Rx20 (\2\:mout \17\:mout) resistor r=45 c=0
Rx2 (\6\:RNb \13\:RNb) resistor r=45 c=0
Rx17 (\4\:RNb \16\:RNb) resistor r=45 c=0
Rx18 (\2\:RNb \17\:RNb) resistor r=45 c=0
Rx42 (\10\:RNb \18\:RNb) resistor r=45 c=0
Rx43 (\3\:RNb \19\:RNb) resistor r=45 c=0
Rx9 (\8\:CKNbb \11\:CKNbb) resistor r=45 c=0
Rx10 (\2\:CKNbb \14\:CKNbb) resistor r=45 c=0
Rx40 (\3\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx41 (\10\:CKNbb \18\:CKNbb) resistor r=45 c=0
Rx22 (\5\:n35g \6\:n35g) resistor r=45 c=0
Rx26 (n35g \14\:n35g) resistor r=45 c=0
Rx25 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx37 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx38 (qbint \22\:qbint) resistor r=45 c=0
Rx21 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx29 (\4\:n35 \15\:n35) resistor r=45 c=0
Rx30 (n35 \16\:n35) resistor r=45 c=0
Rx44 (\3\:n35 \21\:n35) resistor r=45 c=0
Rx31 (\2\:RTb \5\:RTb) resistor r=45 c=0
Rx32 (\3\:RTb \8\:RTb) resistor r=45 c=0
Rx45 (qint \8\:qint) resistor r=45 c=0
mn22 (\14\:RNb \4\:RN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (n21 \1\:D \38\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\14\:n20 CKNbb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\12\:n20 \11\:CKNb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (n30 \3\:mout \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\15\:CKNbb CKNb \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (\3\:net426 \3\:SN \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=4.858e-14 ps=6.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\20\:CKNb \1\:CKN \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\13\:mout \6\:n20 \3\:net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn31 (\11\:mout RNb net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn40 (\9\:n35 \6\:CKNb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
NM0 (\9\:n35g RTb \11\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM1 (\19\:qbint \4\:n35g \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0121 \5\:qbint \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\6\:RTb \6\:RT \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.81e-14 ps=5.7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \5\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\19\:n35 \9\:CKNbb \3\:n40 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:qint \30\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.71058e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn56 (\5\:qint \14\:qbint \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn51 (n40 \8\:RNb \3\:n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n40 \12\:qbint n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn50 (n42 \10\:SN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp25 (n22 \4\:D \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=8.07243 \
        scb=0.00427526 scc=2.63824e-05 m=(1)
mp26 (\18\:n20 \3\:CKNb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=7.39501 \
        scb=0.00357259 scc=2.44217e-05 m=(1)
mp36 (\8\:n20 \6\:CKNbb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.035e-06 sd=160n sca=5.57121 \
        scb=0.00131629 scc=2.54339e-06 m=(1)
mp35 (n31 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=1.29e-14 ps=1.06e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=9.3e-07 sd=160n sca=5.28562 \
        scb=0.00121296 scc=2.51356e-06 m=(1)
mp21 (\12\:CKNbb \5\:CKNb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=6.48645 \
        scb=0.00312433 scc=2.40957e-05 m=(1)
mp30 (\15\:mout \1\:SN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.773e-14 ad=6.02e-14 ps=1.06e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=5.7e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp20 (\18\:CKNb \4\:CKN \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=6.65589 \
        scb=0.00316356 scc=2.41007e-05 m=(1)
mp32 (\15\:mout \3\:n20 net402 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.02e-14 ps=5.5e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp31 (net402 \7\:RNb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.4e-07 sd=160n sca=6.44121 \
        scb=0.00199344 scc=3.60278e-06 m=(1)
mp40 (\13\:n35 \7\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
PM0 (\7\:n35g \4\:RT \5\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.1589 \
        scb=0.0273077 scc=0.0026732 m=(1)
PM1 (\17\:qbint \3\:n35g \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\9\:RTb \7\:RT \11\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.4484 \
        scb=0.0260103 scc=0.00229228 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\17\:n35 \12\:CKNb \3\:n41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:qint \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=28.6983 \
        scb=0.0316799 scc=0.00295254 m=(1)
mp56 (\9\:qint \13\:qbint \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.5823 \
        scb=0.0110312 scc=0.000167593 m=(1)
mp51 (n43 \9\:RNb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=9.47524 \
        scb=0.00528697 scc=3.19779e-05 m=(1)
mp52 (n41 \11\:qbint n43 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=10.003 \
        scb=0.00635741 scc=4.31501e-05 m=(1)
mp55 (\3\:Q \7\:qbint \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.9109 \
        scb=0.0151829 scc=0.000449446 m=(1)
mp50 (n41 \9\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=15.4344 \
        scb=0.0162184 scc=0.000550454 m=(1)
ends RDFFNSRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:45:17 2012 )
// Library name: gsclib045
// Cell name: RDFFNSX1
// View name: extracted

simulator lang=spectre

subckt RDFFNSX1 CKN D ExtVDD Q QN RT SN VDD VSS
mp25 (n22 \3\:D \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (Q VSS) capacitor c=5.9948e-17
C2 (QN VSS) capacitor c=2.46243e-17
C3 (VDD VSS) capacitor c=6.12659e-16
C4 (ExtVDD VSS) capacitor c=1.9778e-16
C5 (SN VSS) capacitor c=5.70924e-17
C6 (D VSS) capacitor c=4.55297e-17
C7 (RT VSS) capacitor c=3.84348e-17
C8 (CKN VSS) capacitor c=3.86991e-17
C9 (CKNb VSS) capacitor c=4.7398e-17
C10 (mout VSS) capacitor c=5.78803e-17
C11 (n20 VSS) capacitor c=9.37821e-17
C12 (CKNbb VSS) capacitor c=5.24602e-17
C13 (n35g VSS) capacitor c=1.77664e-17
C14 (qbint VSS) capacitor c=4.57835e-17
C15 (RTb VSS) capacitor c=5.17974e-17
C16 (qint VSS) capacitor c=2.23822e-17
C17 (n35 VSS) capacitor c=1.71424e-16
C18 (n41 VSS) capacitor c=8.43054e-17
C19 (net095 VSS) capacitor c=3.64524e-17
C20 (\7\:qbint VSS) capacitor c=4.61734e-17
C21 (\7\:SN VSS) capacitor c=6.76703e-17
C22 (\11\:qbint VSS) capacitor c=7.51174e-17
C23 (\13\:qbint VSS) capacitor c=4.78576e-17
C24 (\3\:qint VSS) capacitor c=5.98296e-17
C25 (\13\:CKNb VSS) capacitor c=4.50737e-17
C26 (\4\:RTb VSS) capacitor c=9.93379e-17
C27 (\6\:RT VSS) capacitor c=2.22357e-17
C28 (\4\:qbint VSS) capacitor c=5.36719e-17
C29 (\3\:n35g VSS) capacitor c=5.78049e-17
C30 (\5\:RT VSS) capacitor c=6.34884e-17
C31 (\6\:CKNbb VSS) capacitor c=1.08001e-16
C32 (\3\:n20 VSS) capacitor c=3.33207e-17
C33 (\4\:CKN VSS) capacitor c=4.88733e-17
C34 (\5\:CKNb VSS) capacitor c=2.58224e-17
C35 (\1\:SN VSS) capacitor c=3.80128e-17
C36 (\5\:CKNbb VSS) capacitor c=7.5352e-17
C37 (\3\:CKNb VSS) capacitor c=1.81097e-16
C38 (\3\:D VSS) capacitor c=5.64293e-17
C39 (\6\:qbint VSS) capacitor c=3.65688e-17
C40 (\8\:SN VSS) capacitor c=1.32068e-16
C41 (\12\:qbint VSS) capacitor c=1.03084e-16
C42 (\14\:qbint VSS) capacitor c=4.43309e-17
C43 (\4\:qint VSS) capacitor c=3.96554e-17
C44 (\8\:CKNbb VSS) capacitor c=2.23049e-16
C45 (\8\:RT VSS) capacitor c=1.21626e-16
C46 (\2\:RT VSS) capacitor c=6.21796e-17
C47 (\5\:qbint VSS) capacitor c=3.89434e-17
C48 (\5\:n35g VSS) capacitor c=2.77014e-17
C49 (\2\:RTb VSS) capacitor c=4.64723e-17
C50 (\7\:CKNb VSS) capacitor c=2.68763e-17
C51 (\1\:CKN VSS) capacitor c=2.98642e-17
C52 (\6\:n20 VSS) capacitor c=6.25702e-17
C53 (\6\:SN VSS) capacitor c=6.49368e-17
C54 (\3\:mout VSS) capacitor c=4.54723e-17
C55 (\12\:CKNb VSS) capacitor c=5.02123e-17
C56 (\2\:CKNbb VSS) capacitor c=8.22071e-17
C57 (\1\:D VSS) capacitor c=6.58599e-17
C58 (\10\:qbint VSS) capacitor c=8.46507e-17
C59 (\14\:CKNb VSS) capacitor c=5.20312e-17
C60 (\3\:SN VSS) capacitor c=2.91741e-16
C61 (\9\:SN VSS) capacitor c=8.57288e-17
C62 (\7\:RT VSS) capacitor c=1.44468e-16
C63 (\11\:CKNb VSS) capacitor c=1.77344e-16
C64 (\3\:RT VSS) capacitor c=3.93703e-17
C65 (\1\:RT VSS) capacitor c=5.27398e-17
C66 (\3\:RTb VSS) capacitor c=7.62362e-17
C67 (\3\:qbint VSS) capacitor c=4.44311e-17
C68 (\2\:n35 VSS) capacitor c=2.61705e-16
C69 (\4\:n35g VSS) capacitor c=5.00701e-17
C70 (\7\:CKNbb VSS) capacitor c=5.81809e-17
C71 (\9\:CKNbb VSS) capacitor c=2.18386e-16
C72 (\3\:n35 VSS) capacitor c=1.21659e-16
C73 (\4\:n20 VSS) capacitor c=1.00891e-16
C74 (\7\:n20 VSS) capacitor c=5.45979e-17
C75 (\3\:CKN VSS) capacitor c=2.32503e-17
C76 (\6\:CKNb VSS) capacitor c=2.19171e-17
C77 (\3\:CKNbb VSS) capacitor c=4.70772e-17
C78 (\2\:SN VSS) capacitor c=4.36474e-17
C79 (\5\:SN VSS) capacitor c=2.88514e-17
C80 (\2\:mout VSS) capacitor c=4.84983e-17
C81 (\4\:mout VSS) capacitor c=3.16028e-17
C82 (\5\:n20 VSS) capacitor c=8.55816e-17
C83 (\2\:n20 VSS) capacitor c=6.49828e-17
C84 (\2\:D VSS) capacitor c=5.44644e-17
C85 (\4\:CKNb VSS) capacitor c=7.92929e-17
C86 (\10\:CKNb VSS) capacitor c=3.11267e-17
C87 (\1\:VDD VSS) capacitor c=4.34306e-17
C88 (\7\:VDD VSS) capacitor c=2.91304e-17
C89 (\3\:Q VSS) capacitor c=7.1221e-17
C90 (\9\:VDD VSS) capacitor c=5.32143e-17
C91 (\9\:qint VSS) capacitor c=5.21032e-17
C92 (\16\:VDD VSS) capacitor c=8.00185e-17
C93 (\3\:n41 VSS) capacitor c=8.40625e-17
C94 (\4\:QN VSS) capacitor c=6.14537e-17
C95 (\14\:n35 VSS) capacitor c=5.44524e-17
C96 (\15\:n35g VSS) capacitor c=5.61339e-17
C97 (\6\:RTb VSS) capacitor c=7.2835e-17
C98 (\1\:ExtVDD VSS) capacitor c=2.76864e-16
C99 (\9\:n35 VSS) capacitor c=6.2545e-17
C100 (\17\:qbint VSS) capacitor c=6.57872e-17
C101 (\6\:n35g VSS) capacitor c=8.96816e-17
C102 (\4\:n35 VSS) capacitor c=4.98817e-17
C103 (\5\:mout VSS) capacitor c=7.97773e-17
C104 (\14\:VDD VSS) capacitor c=4.70573e-17
C105 (\21\:CKNb VSS) capacitor c=3.05154e-17
C106 (\19\:mout VSS) capacitor c=4.30544e-17
C107 (\22\:VDD VSS) capacitor c=6.55752e-17
C108 (\16\:mout VSS) capacitor c=4.67369e-17
C109 (\14\:CKNbb VSS) capacitor c=5.21767e-17
C110 (\20\:VDD VSS) capacitor c=5.39817e-17
C111 (\16\:n20 VSS) capacitor c=6.30567e-17
C112 (\8\:n20 VSS) capacitor c=2.50886e-17
C113 (\25\:VDD VSS) capacitor c=3.60572e-17
C114 (\1\:Q VSS) capacitor c=5.48952e-17
C115 (\5\:qint VSS) capacitor c=5.01504e-17
C116 (\3\:net095 VSS) capacitor c=4.63057e-17
C117 (\1\:QN VSS) capacitor c=4.19618e-17
C118 (\17\:n35 VSS) capacitor c=4.64399e-17
C119 (\11\:n35g VSS) capacitor c=2.98389e-17
C120 (\10\:RTb VSS) capacitor c=5.8314e-17
C121 (\12\:n35 VSS) capacitor c=6.36732e-17
C122 (\19\:qbint VSS) capacitor c=2.27954e-17
C123 (\9\:n35g VSS) capacitor c=8.03039e-17
C124 (\7\:n35 VSS) capacitor c=4.06032e-17
C125 (\11\:VDD VSS) capacitor c=2.12375e-16
C126 (\11\:mout VSS) capacitor c=2.18821e-17
C127 (\17\:CKNb VSS) capacitor c=4.67064e-17
C128 (\13\:mout VSS) capacitor c=1.72205e-17
C129 (\10\:CKNbb VSS) capacitor c=3.49251e-17
C130 (\14\:n20 VSS) capacitor c=5.88107e-17
C131 (\12\:n20 VSS) capacitor c=5.94694e-17
C132 (VDD VSS) capacitor c=6.81515e-18
C133 (\2\:CKNb VSS) capacitor c=7.17838e-17
C134 (\2\:CKN VSS) capacitor c=3.34802e-17
C135 (\4\:CKNbb VSS) capacitor c=1.00379e-16
C136 (\2\:n35g VSS) capacitor c=3.38357e-17
C137 (ExtVDD VSS) capacitor c=3.93674e-17
C138 (\4\:RT VSS) capacitor c=4.60848e-17
C139 (\2\:qbint VSS) capacitor c=4.10889e-17
C140 (\8\:CKNb VSS) capacitor c=1.15856e-16
C141 (\9\:CKNb VSS) capacitor c=8.16738e-17
C142 (\4\:SN VSS) capacitor c=3.13386e-16
C143 (\2\:qint VSS) capacitor c=1.75568e-17
C144 (\15\:CKNb VSS) capacitor c=5.3132e-17
C145 (\16\:CKNb VSS) capacitor c=6.96089e-17
C146 (\8\:qbint VSS) capacitor c=3.96012e-17
C147 (\9\:qbint VSS) capacitor c=6.26197e-17
C148 (\10\:n20 VSS) capacitor c=4.04322e-17
C149 (\11\:n20 VSS) capacitor c=6.26569e-17
C150 (\18\:n20 VSS) capacitor c=4.18102e-17
C151 (\13\:CKNbb VSS) capacitor c=7.74902e-17
C152 (\16\:CKNbb VSS) capacitor c=5.19456e-17
C153 (\10\:SN VSS) capacitor c=4.85656e-17
C154 (\5\:CKN VSS) capacitor c=5.79918e-18
C155 (\6\:CKN VSS) capacitor c=3.44417e-17
C156 (\19\:CKNb VSS) capacitor c=4.81424e-17
C157 (\20\:CKNb VSS) capacitor c=4.82622e-17
C158 (\19\:n20 VSS) capacitor c=5.19461e-17
C159 (\20\:n20 VSS) capacitor c=6.01353e-17
C160 (\7\:mout VSS) capacitor c=7.2852e-17
C161 (\8\:mout VSS) capacitor c=3.59356e-17
C162 (\9\:mout VSS) capacitor c=7.15874e-17
C163 (\10\:mout VSS) capacitor c=7.7688e-17
C164 (\15\:mout VSS) capacitor c=6.71789e-17
C165 (\18\:mout VSS) capacitor c=6.43242e-17
C166 (\6\:n35 VSS) capacitor c=6.55097e-17
C167 (\17\:CKNbb VSS) capacitor c=2.96864e-17
C168 (\18\:CKNbb VSS) capacitor c=3.2633e-17
C169 (\8\:n35g VSS) capacitor c=2.94004e-17
C170 (\11\:n35 VSS) capacitor c=7.53835e-17
C171 (\15\:qbint VSS) capacitor c=8.81276e-17
C172 (\16\:qbint VSS) capacitor c=1.09674e-16
C173 (\13\:n35g VSS) capacitor c=1.02521e-16
C174 (\14\:n35g VSS) capacitor c=1.16145e-16
C175 (\5\:RTb VSS) capacitor c=4.97019e-17
C176 (\8\:RTb VSS) capacitor c=9.95416e-17
C177 (\9\:RTb VSS) capacitor c=9.15552e-17
C178 (\12\:SN VSS) capacitor c=8.3139e-17
C179 (\13\:SN VSS) capacitor c=7.95586e-17
C180 (\23\:CKNb VSS) capacitor c=1.32993e-16
C181 (\24\:CKNb VSS) capacitor c=1.3649e-16
C182 (\21\:qbint VSS) capacitor c=2.38824e-17
C183 (\22\:qbint VSS) capacitor c=3.00681e-17
C184 (\9\:RT VSS) capacitor c=1.10054e-16
C185 (\10\:RT VSS) capacitor c=1.18375e-16
C186 (\11\:RT VSS) capacitor c=5.64107e-17
C187 (\3\:QN VSS) capacitor c=3.53163e-17
C188 (\16\:n35 VSS) capacitor c=4.37128e-17
C189 (\7\:qint VSS) capacitor c=4.94893e-17
C190 (\8\:qint VSS) capacitor c=3.68367e-17
C191 (\3\:VDD VSS) capacitor c=2.35941e-17
C192 (\4\:VDD VSS) capacitor c=2.96923e-17
C193 (\6\:VDD VSS) capacitor c=2.35721e-16
C194 (\13\:VDD VSS) capacitor c=1.71403e-17
C195 (\19\:VDD VSS) capacitor c=4.32418e-17
C196 (\24\:VDD VSS) capacitor c=3.89591e-17
Rk70 (\2\:Q Q) resistor r=0.1754 c=0
Rk71 (Q \4\:Q) resistor r=0.3054 c=0
Rk61 (\3\:QN QN) resistor r=0.01678 c=0
Rk60 (\2\:QN \3\:QN) resistor r=0.2894 c=0
Rk62 (\3\:QN \5\:QN) resistor r=0.3267 c=0
Rk88 (\2\:VDD \3\:VDD) resistor r=0.3804 c=0
Rk89 (\3\:VDD \4\:VDD) resistor r=0.1958 c=0
Rk90 (\4\:VDD \6\:VDD) resistor r=0.1089 c=0
Rk91 (\3\:VDD \8\:VDD) resistor r=0.3186 c=0
Rk92 (\4\:VDD \10\:VDD) resistor r=0.3013 c=0
Rk93 (\6\:VDD \12\:VDD) resistor r=1.6247 c=0
Rk94 (\12\:VDD \13\:VDD) resistor r=0.07668 c=0
Rk95 (\13\:VDD \15\:VDD) resistor r=0.2739 c=0
Rk96 (\6\:VDD \17\:VDD) resistor r=0.4063 c=0
Rk97 (\13\:VDD \18\:VDD) resistor r=0.1613 c=0
Rk101 (\19\:VDD VDD) resistor r=0.1012 c=0
Rk98 (\18\:VDD \19\:VDD) resistor r=0.1762 c=0
Rk99 (\19\:VDD \21\:VDD) resistor r=0.2753 c=0
Rk100 (\18\:VDD \23\:VDD) resistor r=0.4487 c=0
Rk102 (VDD \24\:VDD) resistor r=0.1464 c=0
Rk103 (\24\:VDD VDD) resistor r=0.08883 c=0
Rk104 (\24\:VDD \26\:VDD) resistor r=0.3585 c=0
Rk41 (ExtVDD ExtVDD) resistor r=0.002061 c=0
Rk39 (\2\:ExtVDD ExtVDD) resistor r=0.02215 c=0
Rk42 (ExtVDD \5\:ExtVDD) resistor r=0.02014 c=0
Rk43 (ExtVDD \6\:ExtVDD) resistor r=0.1056 c=0
Rk13 (\10\:SN SN) resistor r=0.006597 c=0
Rk54 (\12\:SN \13\:SN) resistor r=0.5357 c=0
Rk72 (\2\:VSS \4\:VSS) resistor r=0.3613 c=0
Rk73 (\4\:VSS \5\:VSS) resistor r=0.2379 c=0
Rk74 (\5\:VSS \6\:VSS) resistor r=0.5553 c=0
Rk75 (\6\:VSS \7\:VSS) resistor r=0.1164 c=0
Rk77 (\8\:VSS VSS) resistor r=0.07147 c=0
Rk76 (\7\:VSS \8\:VSS) resistor r=0.2079 c=0
Rk79 (\9\:VSS VSS) resistor r=0.1188 c=0
Rk78 (VSS \9\:VSS) resistor r=0.7441 c=0
Rk80 (VSS \10\:VSS) resistor r=0.03725 c=0
Rk81 (\10\:VSS \11\:VSS) resistor r=0.4236 c=0
Rk82 (\11\:VSS \12\:VSS) resistor r=0.06428 c=0
Rk83 (\5\:VSS \14\:VSS) resistor r=0.2636 c=0
Rk84 (\7\:VSS \16\:VSS) resistor r=0.1891 c=0
Rk85 (\8\:VSS \18\:VSS) resistor r=0.1942 c=0
Rk86 (\10\:VSS \20\:VSS) resistor r=0.2364 c=0
Rk87 (\11\:VSS \22\:VSS) resistor r=0.2282 c=0
Rk105 (\24\:VSS \26\:VSS) resistor r=0.6178 c=0
Rk106 (\26\:VSS \27\:VSS) resistor r=0.5655 c=0
Rk108 (\28\:VSS VSS) resistor r=0.04935 c=0
Rk107 (\27\:VSS \28\:VSS) resistor r=0.2775 c=0
Rk110 (\29\:VSS VSS) resistor r=0.1213 c=0
Rk109 (VSS \29\:VSS) resistor r=0.8433 c=0
Rk111 (VSS \31\:VSS) resistor r=0.3941 c=0
Rk112 (\27\:VSS \33\:VSS) resistor r=0.2434 c=0
Rk2 (\4\:D D) resistor r=0.006855 c=0
Rk57 (RT \9\:RT) resistor r=0.1906 c=0
Rk58 (\9\:RT \10\:RT) resistor r=0.6461 c=0
Rk59 (RT \11\:RT) resistor r=0.008147 c=0
Rk14 (CKN \5\:CKN) resistor r=0.002046 c=0
Rk17 (\5\:CKN \6\:CKN) resistor r=0.01545 c=0
Rk16 (\6\:CKN \7\:CKN) resistor r=0.004534 c=0
Rk1 (\15\:CKNb \16\:CKNb) resistor r=0.6157 c=0
Rk18 (\18\:CKNb \19\:CKNb) resistor r=0.3363 c=0
Rk19 (\19\:CKNb \20\:CKNb) resistor r=0.1632 c=0
Rk20 (\19\:CKNb \22\:CKNb) resistor r=0.2009 c=0
Rk55 (\23\:CKNb \24\:CKNb) resistor r=0.8263 c=0
Rk22 (\6\:mout \7\:mout) resistor r=0.5291 c=0
Rk23 (\7\:mout \8\:mout) resistor r=0.2963 c=0
Rk24 (\8\:mout \9\:mout) resistor r=0.1025 c=0
Rk25 (\9\:mout \10\:mout) resistor r=0.3335 c=0
Rk26 (\7\:mout \12\:mout) resistor r=0.1278 c=0
Rk27 (\8\:mout \14\:mout) resistor r=0.09193 c=0
Rk28 (\9\:mout \15\:mout) resistor r=0.4807 c=0
Rk29 (\15\:mout \17\:mout) resistor r=0.04481 c=0
Rk30 (\10\:mout \18\:mout) resistor r=0.3477 c=0
Rk31 (\15\:mout \20\:mout) resistor r=0.03462 c=0
Rk3 (\9\:n20 \10\:n20) resistor r=0.1922 c=0
Rk4 (\9\:n20 \11\:n20) resistor r=0.2104 c=0
Rk5 (\11\:n20 \13\:n20) resistor r=0.3761 c=0
Rk6 (\15\:n20 \17\:n20) resistor r=0.4887 c=0
Rk7 (\17\:n20 \18\:n20) resistor r=0.1441 c=0
Rk21 (\19\:n20 \20\:n20) resistor r=0.2687 c=0
Rk8 (\11\:CKNbb \12\:CKNbb) resistor r=0.2129 c=0
Rk9 (\12\:CKNbb \13\:CKNbb) resistor r=0.01514 c=0
Rk10 (\12\:CKNbb \15\:CKNbb) resistor r=0.3382 c=0
Rk11 (\15\:CKNbb \16\:CKNbb) resistor r=0.2715 c=0
Rk34 (\17\:CKNbb \18\:CKNbb) resistor r=0.2997 c=0
Rk35 (\7\:n35g \8\:n35g) resistor r=0.2407 c=0
Rk36 (\7\:n35g \10\:n35g) resistor r=0.6914 c=0
Rk47 (\12\:n35g \13\:n35g) resistor r=0.2429 c=0
Rk48 (\13\:n35g \14\:n35g) resistor r=0.5654 c=0
Rk49 (\13\:n35g \16\:n35g) resistor r=0.4319 c=0
Rk44 (\15\:qbint \16\:qbint) resistor r=0.4944 c=0
Rk45 (\16\:qbint \18\:qbint) resistor r=0.567 c=0
Rk46 (\16\:qbint \20\:qbint) resistor r=0.1463 c=0
Rk56 (\21\:qbint \22\:qbint) resistor r=0.2118 c=0
Rk50 (\5\:RTb \7\:RTb) resistor r=0.2162 c=0
Rk51 (\7\:RTb \8\:RTb) resistor r=0.4165 c=0
Rk52 (\8\:RTb \9\:RTb) resistor r=0.6885 c=0
Rk53 (\8\:RTb \11\:RTb) resistor r=0.3065 c=0
Rk65 (\6\:qint \7\:qint) resistor r=0.2828 c=0
Rk66 (\7\:qint \8\:qint) resistor r=0.1614 c=0
Rk67 (\7\:qint \10\:qint) resistor r=0.2612 c=0
Rk32 (\5\:n35 \6\:n35) resistor r=0.3337 c=0
Rk33 (\6\:n35 \8\:n35) resistor r=0.2903 c=0
Rk37 (\10\:n35 \11\:n35) resistor r=0.4009 c=0
Rk38 (\11\:n35 \13\:n35) resistor r=0.3298 c=0
Rk63 (\15\:n35 \16\:n35) resistor r=0.3037 c=0
Rk64 (\16\:n35 \18\:n35) resistor r=0.2747 c=0
Rk69 (\2\:n41 \4\:n41) resistor r=0.6527 c=0
Rk68 (\2\:net095 \4\:net095) resistor r=0.2046 c=0
Rl53 (\7\:SN \8\:SN) resistor r=234.813 c=0
Rl54 (\8\:SN \9\:SN) resistor r=434.764 c=0
Rl7 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl45 (\4\:SN \6\:SN) resistor r=95.229 c=0
Rl43 (\3\:SN \4\:SN) resistor r=1126.2 c=0
Rl44 (\4\:SN \5\:SN) resistor r=14.5488 c=0
Rl2 (\2\:D \3\:D) resistor r=43.4636 c=0
Rl1 (\1\:D \2\:D) resistor r=135.391 c=0
Rl42 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl29 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl32 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl31 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl30 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl15 (\2\:CKN \4\:CKN) resistor r=147.791 c=0
Rl13 (\1\:CKN \2\:CKN) resistor r=63.1757 c=0
Rl14 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl48 (\13\:CKNb \14\:CKNb) resistor r=166.412 c=0
Rl10 (\3\:CKNb \4\:CKNb) resistor r=446.586 c=0
Rl8 (CKNb \2\:CKNb) resistor r=147.923 c=0
Rl11 (\2\:CKNb \5\:CKNb) resistor r=59.4618 c=0
Rl9 (\2\:CKNb \3\:CKNb) resistor r=237.282 c=0
Rl12 (\2\:CKNb \6\:CKNb) resistor r=4.3228 c=0
Rl37 (\7\:CKNb \8\:CKNb) resistor r=66.1349 c=0
Rl40 (\8\:CKNb \11\:CKNb) resistor r=794.708 c=0
Rl41 (\9\:CKNb \12\:CKNb) resistor r=66.8717 c=0
Rl39 (\9\:CKNb \10\:CKNb) resistor r=129.238 c=0
Rl38 (\8\:CKNb \9\:CKNb) resistor r=430.133 c=0
Rl4 (mout \2\:mout) resistor r=24.2328 c=0
Rl5 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl16 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl18 (\6\:n20 \7\:n20) resistor r=105.531 c=0
Rl17 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl3 (n20 \2\:n20) resistor r=236.609 c=0
Rl6 (CKNbb \2\:CKNbb) resistor r=183.837 c=0
Rl22 (\6\:CKNbb \7\:CKNbb) resistor r=196.122 c=0
Rl49 (\8\:CKNbb \9\:CKNbb) resistor r=870.726 c=0
Rl21 (\4\:CKNbb \6\:CKNbb) resistor r=422.225 c=0
Rl20 (\4\:CKNbb \5\:CKNbb) resistor r=113.702 c=0
Rl19 (\3\:CKNbb \4\:CKNbb) resistor r=158.657 c=0
Rl25 (\3\:n35g \4\:n35g) resistor r=250.512 c=0
Rl23 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl24 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl26 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl55 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl60 (\11\:qbint \12\:qbint) resistor r=252.671 c=0
Rl62 (\13\:qbint \14\:qbint) resistor r=199.892 c=0
Rl36 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl33 (qbint \2\:qbint) resistor r=112.732 c=0
Rl35 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl34 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl56 (\7\:qbint \8\:qbint) resistor r=135.6 c=0
Rl59 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl61 (\9\:qbint \13\:qbint) resistor r=90.3157 c=0
Rl58 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl57 (\8\:qbint \9\:qbint) resistor r=68.3971 c=0
Rl27 (RTb \2\:RTb) resistor r=112.412 c=0
Rl28 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl50 (qint \2\:qint) resistor r=3.1216 c=0
Rl51 (\2\:qint \3\:qint) resistor r=56.4891 c=0
Rl52 (\2\:qint \4\:qint) resistor r=85.455 c=0
Rl46 (n35 \2\:n35) resistor r=508.667 c=0
Rl47 (\2\:n35 \3\:n35) resistor r=367.189 c=0
Rz19 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz14 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz27 (\11\:VDD \12\:VDD) resistor r=25 c=0
Rz28 (\11\:VDD \18\:VDD) resistor r=15 c=0
Rz20 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz21 (\13\:VSS \14\:VSS) resistor r=37.5 c=0
Rz22 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz23 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz24 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz25 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz29 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz30 (\30\:VSS \31\:VSS) resistor r=37.5 c=0
Rz31 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz4 (\17\:CKNb \18\:CKNb) resistor r=75 c=0
Rz5 (\11\:mout \12\:mout) resistor r=75 c=0
Rz6 (\13\:mout \14\:mout) resistor r=75 c=0
Rz1 (\12\:n20 \13\:n20) resistor r=75 c=0
Rz2 (\14\:n20 \15\:n20) resistor r=75 c=0
Rz3 (\10\:CKNbb \11\:CKNbb) resistor r=75 c=0
Rz8 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz12 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz11 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz13 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz16 (\5\:qint \6\:qint) resistor r=75 c=0
Rz7 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz9 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz15 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz17 (net095 \2\:net095) resistor r=75 c=0
Rz18 (\3\:net095 \4\:net095) resistor r=75 c=0
Ry22 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry17 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry27 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry28 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry29 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry30 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry31 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry32 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry33 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry34 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry11 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry12 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry23 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry24 (\3\:VSS \6\:VSS) resistor r=5.6364 c=0
Ry25 (\3\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry26 (\3\:VSS \12\:VSS) resistor r=62 c=0
Ry35 (\25\:VSS \26\:VSS) resistor r=5.6364 c=0
Ry36 (\25\:VSS \28\:VSS) resistor r=10.3333 c=0
Ry37 (\25\:VSS \29\:VSS) resistor r=5.1667 c=0
Ry4 (\21\:CKNb \22\:CKNb) resistor r=62 c=0
Ry5 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\16\:mout \17\:mout) resistor r=62 c=0
Ry7 (\19\:mout \20\:mout) resistor r=62 c=0
Ry1 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry2 (\16\:n20 \17\:n20) resistor r=62 c=0
Ry3 (\14\:CKNbb \15\:CKNbb) resistor r=62 c=0
Ry9 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry16 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry19 (\9\:qint \10\:qint) resistor r=62 c=0
Ry8 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry10 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry18 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry20 (n41 \2\:n41) resistor r=62 c=0
Ry21 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx9 (\2\:SN \10\:SN) resistor r=45 c=0
Rx10 (\5\:SN \10\:SN) resistor r=45 c=0
Rx26 (\3\:SN \12\:SN) resistor r=45 c=0
Rx27 (\9\:SN \13\:SN) resistor r=45 c=0
Rx3 (\2\:D \4\:D) resistor r=45 c=0
Rx32 (\3\:RT \9\:RT) resistor r=45 c=0
Rx33 (\1\:RT \10\:RT) resistor r=45 c=0
Rx34 (\7\:RT \11\:RT) resistor r=45 c=0
Rx11 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx1 (\4\:CKNb \15\:CKNb) resistor r=45 c=0
Rx2 (\10\:CKNb \16\:CKNb) resistor r=45 c=0
Rx12 (\6\:CKNb \20\:CKNb) resistor r=45 c=0
Rx28 (\14\:CKNb \23\:CKNb) resistor r=45 c=0
Rx29 (\11\:CKNb \24\:CKNb) resistor r=45 c=0
Rx15 (\4\:mout \10\:mout) resistor r=45 c=0
Rx16 (\2\:mout \18\:mout) resistor r=45 c=0
Rx4 (\2\:n20 \10\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \11\:n20) resistor r=45 c=0
Rx6 (n20 \18\:n20) resistor r=45 c=0
Rx13 (\4\:n20 \19\:n20) resistor r=45 c=0
Rx14 (\7\:n20 \20\:n20) resistor r=45 c=0
Rx7 (CKNbb \13\:CKNbb) resistor r=45 c=0
Rx8 (\3\:CKNbb \16\:CKNbb) resistor r=45 c=0
Rx18 (\7\:CKNbb \17\:CKNbb) resistor r=45 c=0
Rx19 (\9\:CKNbb \18\:CKNbb) resistor r=45 c=0
Rx20 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx23 (n35g \14\:n35g) resistor r=45 c=0
Rx22 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx30 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx31 (qbint \22\:qbint) resistor r=45 c=0
Rx24 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx25 (RTb \9\:RTb) resistor r=45 c=0
Rx36 (qint \8\:qint) resistor r=45 c=0
Rx17 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx21 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx35 (n35 \16\:n35) resistor r=45 c=0
mn25 (n21 \1\:D \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\14\:n20 \2\:CKNbb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\12\:n20 \12\:CKNb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (n30 \3\:mout \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\10\:CKNbb CKNb \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (net426 \6\:SN \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\17\:CKNb \1\:CKN \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\7\:n35 \7\:CKNb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM1 (\19\:qbint \5\:n35g \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0121 \5\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \2\:RT \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \8\:CKNbb \3\:net095 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:qint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.71058e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn56 (\5\:qint \14\:qbint \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn52 (net095 \12\:qbint n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (n42 \8\:SN \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp26 (\16\:n20 \3\:CKNb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3011 \
        scb=0.0111155 scc=0.000221731 m=(1)
mp36 (\8\:n20 \5\:CKNbb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=8.20139 \
        scb=0.00436827 scc=2.20651e-05 m=(1)
mp35 (n31 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=7.36777 \
        scb=0.00335337 scc=1.75985e-05 m=(1)
mp30 (\16\:mout \1\:SN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=6.506 scb=0.00275822 \
        scc=1.68594e-05 m=(1)
mp21 (\14\:CKNbb \5\:CKNb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp20 (\21\:CKNb \4\:CKN \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.52288 \
        scb=0.00778605 scc=0.000197359 m=(1)
mp32 (\19\:mout \3\:n20 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.97126 \
        scb=0.00301321 scc=1.70301e-05 m=(1)
mp40 (\4\:n35 \6\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.2199 \
        scb=0.0159497 scc=0.000584328 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
PM1 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \13\:CKNb \3\:n41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:qint \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=28.6983 \
        scb=0.0316799 scc=0.00295254 m=(1)
mp56 (\9\:qint \13\:qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.5253 \
        scb=0.0111823 scc=0.000178214 m=(1)
mp52 (n41 \11\:qbint \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp50 (n41 \7\:SN \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1714 \
        scb=0.00703773 scc=5.55028e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends RDFFNSX1
// End of subcircuit definition.

// Generated for: spectre (Mar 22 13:27:04 2012 )
// Library name: gsclib045
// Cell name: RDFFNX1
// View name: extracted

simulator lang=spectre

subckt RDFFNX1 CKN D ExtVDD Q QN RT VDD VSS
mp25 (n22 \4\:D \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.9347 \
        scb=0.0157363 scc=0.000368461 m=(1)
C1 (Q VSS) capacitor c=2.66219e-17
C2 (ExtVDD VSS) capacitor c=1.66902e-16
C3 (CKN VSS) capacitor c=4.69201e-17
C4 (D VSS) capacitor c=4.86477e-17
C5 (QN VSS) capacitor c=3.67284e-17
C6 (VDD VSS) capacitor c=4.90796e-16
C7 (RT VSS) capacitor c=6.758e-17
C8 (CKNb VSS) capacitor c=2.30698e-17
C9 (n20 VSS) capacitor c=4.53919e-17
C10 (CKNbb VSS) capacitor c=4.96187e-17
C11 (mout VSS) capacitor c=5.65117e-17
C12 (n35 VSS) capacitor c=1.45783e-16
C13 (n35g VSS) capacitor c=1.77389e-17
C14 (qbint VSS) capacitor c=4.82369e-17
C15 (RTb VSS) capacitor c=3.93753e-17
C16 (qint VSS) capacitor c=2.24871e-17
C17 (\7\:qbint VSS) capacitor c=5.20802e-17
C18 (\11\:qbint VSS) capacitor c=4.53012e-17
C19 (\13\:qbint VSS) capacitor c=1.40956e-16
C20 (\3\:qint VSS) capacitor c=5.94447e-17
C21 (\14\:CKNb VSS) capacitor c=8.73828e-17
C22 (\4\:RTb VSS) capacitor c=9.84044e-17
C23 (\8\:RT VSS) capacitor c=2.17681e-17
C24 (\4\:qbint VSS) capacitor c=6.83431e-17
C25 (\3\:n35g VSS) capacitor c=4.88491e-17
C26 (\6\:RT VSS) capacitor c=7.62395e-17
C27 (\8\:CKNbb VSS) capacitor c=2.84412e-17
C28 (\4\:CKN VSS) capacitor c=3.3372e-17
C29 (\3\:n20 VSS) capacitor c=5.75688e-17
C30 (\7\:CKNb VSS) capacitor c=2.93475e-17
C31 (\6\:CKNbb VSS) capacitor c=9.46442e-17
C32 (\4\:CKNb VSS) capacitor c=1.27752e-16
C33 (\4\:D VSS) capacitor c=6.43067e-17
C34 (\6\:qbint VSS) capacitor c=3.72934e-17
C35 (\12\:qbint VSS) capacitor c=4.56651e-17
C36 (\14\:qbint VSS) capacitor c=9.13732e-17
C37 (\4\:qint VSS) capacitor c=3.78602e-17
C38 (\3\:CKNbb VSS) capacitor c=3.41987e-16
C39 (\7\:RT VSS) capacitor c=1.6648e-16
C40 (\1\:RT VSS) capacitor c=4.42713e-17
C41 (\5\:qbint VSS) capacitor c=3.90657e-17
C42 (\5\:n35g VSS) capacitor c=3.44721e-17
C43 (\12\:CKNb VSS) capacitor c=2.92085e-17
C44 (\1\:CKN VSS) capacitor c=4.30465e-17
C45 (\6\:n20 VSS) capacitor c=5.10978e-17
C46 (\6\:CKNb VSS) capacitor c=2.94587e-17
C47 (\3\:mout VSS) capacitor c=4.90535e-17
C48 (\13\:CKNb VSS) capacitor c=5.01877e-17
C49 (\2\:CKNbb VSS) capacitor c=7.90197e-17
C50 (\1\:D VSS) capacitor c=5.29799e-17
C51 (\15\:CKNb VSS) capacitor c=5.64002e-17
C52 (\8\:CKNb VSS) capacitor c=1.27374e-16
C53 (\10\:qbint VSS) capacitor c=5.74086e-17
C54 (\3\:RT VSS) capacitor c=1.67817e-16
C55 (\3\:RTb VSS) capacitor c=7.34091e-17
C56 (\4\:RT VSS) capacitor c=4.35254e-17
C57 (\2\:RT VSS) capacitor c=3.89058e-17
C58 (\3\:qbint VSS) capacitor c=3.52551e-17
C59 (\2\:RTb VSS) capacitor c=4.00519e-17
C60 (\2\:n35 VSS) capacitor c=1.65829e-16
C61 (\4\:n35g VSS) capacitor c=6.80084e-17
C62 (\3\:n35 VSS) capacitor c=4.35542e-17
C63 (\3\:CKN VSS) capacitor c=2.68344e-17
C64 (\2\:mout VSS) capacitor c=3.86121e-17
C65 (\4\:mout VSS) capacitor c=4.0206e-17
C66 (\7\:CKNbb VSS) capacitor c=4.20921e-17
C67 (\5\:n20 VSS) capacitor c=4.33896e-17
C68 (\2\:n20 VSS) capacitor c=4.50121e-17
C69 (\5\:CKNb VSS) capacitor c=6.13678e-17
C70 (\11\:CKNb VSS) capacitor c=3.01016e-17
C71 (\3\:D VSS) capacitor c=1.32182e-17
C72 (\1\:VDD VSS) capacitor c=4.83252e-17
C73 (\1\:Q VSS) capacitor c=8.36476e-17
C74 (\9\:qint VSS) capacitor c=5.46365e-17
C75 (\11\:VDD VSS) capacitor c=2.50873e-17
C76 (\13\:VDD VSS) capacitor c=7.93185e-17
C77 (\1\:QN VSS) capacitor c=6.1791e-17
C78 (\15\:n35 VSS) capacitor c=4.34926e-17
C79 (\15\:n35g VSS) capacitor c=4.65303e-17
C80 (\6\:RTb VSS) capacitor c=5.92917e-17
C81 (\1\:ExtVDD VSS) capacitor c=2.90238e-16
C82 (\10\:n35 VSS) capacitor c=5.11268e-17
C83 (\17\:qbint VSS) capacitor c=6.61641e-17
C84 (\6\:n35g VSS) capacitor c=8.75619e-17
C85 (\4\:n35 VSS) capacitor c=4.00017e-17
C86 (\22\:CKNb VSS) capacitor c=4.43336e-17
C87 (\5\:mout VSS) capacitor c=5.94436e-17
C88 (\15\:VDD VSS) capacitor c=6.70103e-17
C89 (\17\:VDD VSS) capacitor c=5.98691e-17
C90 (\13\:CKNbb VSS) capacitor c=6.49063e-17
C91 (\13\:n20 VSS) capacitor c=4.6032e-17
C92 (\9\:n20 VSS) capacitor c=8.19741e-17
C93 (\20\:VDD VSS) capacitor c=3.4933e-17
C94 (\3\:VDD VSS) capacitor c=2.54028e-16
C95 (\3\:Q VSS) capacitor c=6.28218e-17
C96 (\5\:qint VSS) capacitor c=4.70126e-17
C97 (\3\:QN VSS) capacitor c=4.58838e-17
C98 (\18\:n35 VSS) capacitor c=6.04504e-17
C99 (\11\:n35g VSS) capacitor c=2.94918e-17
C100 (\10\:RTb VSS) capacitor c=5.97655e-17
C101 (\13\:n35 VSS) capacitor c=5.58349e-17
C102 (\19\:qbint VSS) capacitor c=2.32266e-17
C103 (\9\:n35g VSS) capacitor c=7.65622e-17
C104 (\7\:n35 VSS) capacitor c=4.4942e-17
C105 (\18\:CKNb VSS) capacitor c=2.84594e-17
C106 (\10\:mout VSS) capacitor c=5.24732e-17
C107 (\9\:CKNbb VSS) capacitor c=3.87742e-17
C108 (\16\:n20 VSS) capacitor c=4.3754e-17
C109 (\7\:n20 VSS) capacitor c=7.42477e-17
C110 (VDD VSS) capacitor c=1.39702e-18
C111 (\2\:D VSS) capacitor c=4.3991e-17
C112 (\2\:CKNb VSS) capacitor c=2.80262e-17
C113 (\3\:CKNb VSS) capacitor c=5.87263e-17
C114 (\4\:n20 VSS) capacitor c=4.72351e-17
C115 (\2\:CKN VSS) capacitor c=3.64304e-17
C116 (\2\:n35g VSS) capacitor c=3.47779e-17
C117 (\2\:qbint VSS) capacitor c=3.99345e-17
C118 (\5\:RT VSS) capacitor c=5.09635e-17
C119 (\9\:CKNb VSS) capacitor c=1.09059e-16
C120 (\10\:CKNb VSS) capacitor c=4.17719e-17
C121 (\4\:CKNbb VSS) capacitor c=2.47221e-16
C122 (\5\:CKNbb VSS) capacitor c=4.15344e-17
C123 (\2\:qint VSS) capacitor c=1.80004e-17
C124 (\8\:qbint VSS) capacitor c=5.61125e-17
C125 (\9\:qbint VSS) capacitor c=1.33632e-16
C126 (\16\:CKNb VSS) capacitor c=9.7508e-17
C127 (\17\:CKNb VSS) capacitor c=8.61806e-17
C128 (\11\:n20 VSS) capacitor c=4.5579e-17
C129 (\12\:n20 VSS) capacitor c=5.21768e-17
C130 (\15\:n20 VSS) capacitor c=5.25715e-17
C131 (\12\:CKNbb VSS) capacitor c=8.91102e-17
C132 (\15\:CKNbb VSS) capacitor c=4.56355e-17
C133 (\6\:CKN VSS) capacitor c=5.65557e-18
C134 (\7\:CKN VSS) capacitor c=4.03807e-17
C135 (\7\:mout VSS) capacitor c=4.29073e-17
C136 (\8\:mout VSS) capacitor c=2.73157e-17
C137 (\9\:mout VSS) capacitor c=2.48939e-17
C138 (\12\:mout VSS) capacitor c=2.50574e-17
C139 (\20\:CKNb VSS) capacitor c=4.31301e-17
C140 (\21\:CKNb VSS) capacitor c=5.29833e-17
C141 (\6\:n35 VSS) capacitor c=6.84178e-17
C142 (\9\:n35 VSS) capacitor c=6.21697e-17
C143 (\8\:n35g VSS) capacitor c=3.19866e-17
C144 (\12\:n35 VSS) capacitor c=6.04519e-17
C145 (\15\:qbint VSS) capacitor c=8.88704e-17
C146 (\16\:qbint VSS) capacitor c=1.03115e-16
C147 (\13\:n35g VSS) capacitor c=1.1254e-16
C148 (\14\:n35g VSS) capacitor c=1.16555e-16
C149 (\9\:RT VSS) capacitor c=6.73012e-17
C150 (\10\:RT VSS) capacitor c=6.14517e-17
C151 (\5\:RTb VSS) capacitor c=3.80611e-17
C152 (\8\:RTb VSS) capacitor c=1.11714e-16
C153 (\9\:RTb VSS) capacitor c=6.96605e-17
C154 (\21\:qbint VSS) capacitor c=2.3018e-17
C155 (\22\:qbint VSS) capacitor c=3.10729e-17
C156 (\24\:CKNb VSS) capacitor c=1.20934e-16
C157 (\25\:CKNb VSS) capacitor c=9.80016e-17
C158 (\17\:n35 VSS) capacitor c=6.15631e-17
C159 (\7\:qint VSS) capacitor c=4.59049e-17
C160 (\8\:qint VSS) capacitor c=3.6687e-17
C161 (\5\:VDD VSS) capacitor c=1.5381e-17
C162 (\6\:VDD VSS) capacitor c=9.63788e-18
C163 (\8\:VDD VSS) capacitor c=1.90827e-16
C164 (\10\:VDD VSS) capacitor c=3.37888e-17
C165 (\19\:VDD VSS) capacitor c=3.84856e-17
Rk58 (Q \2\:Q) resistor r=0.2995 c=0
Rk59 (Q \4\:Q) resistor r=0.2327 c=0
Rk33 (ExtVDD ExtVDD) resistor r=0.002056 c=0
Rk31 (\2\:ExtVDD ExtVDD) resistor r=0.02209 c=0
Rk34 (ExtVDD \5\:ExtVDD) resistor r=0.02008 c=0
Rk35 (ExtVDD \6\:ExtVDD) resistor r=0.1492 c=0
Rk36 (\7\:ExtVDD \8\:ExtVDD) resistor r=0.02869 c=0
Rk12 (\5\:CKN CKN) resistor r=0.004158 c=0
Rk13 (CKN \6\:CKN) resistor r=0.004009 c=0
Rk14 (\5\:CKN \6\:CKN) resistor r=0.01695 c=0
Rk15 (\6\:CKN \7\:CKN) resistor r=0.02156 c=0
Rk51 (QN \2\:QN) resistor r=0.2664 c=0
Rk52 (QN \4\:QN) resistor r=0.2357 c=0
Rk77 (\2\:VDD \4\:VDD) resistor r=0.488 c=0
Rk78 (\4\:VDD \5\:VDD) resistor r=0.1506 c=0
Rk79 (\5\:VDD \6\:VDD) resistor r=0.05152 c=0
Rk80 (\6\:VDD \7\:VDD) resistor r=0.03441 c=0
Rk81 (\7\:VDD \8\:VDD) resistor r=1.5569 c=0
Rk87 (\10\:VDD VDD) resistor r=0.1804 c=0
Rk82 (\8\:VDD \10\:VDD) resistor r=0.05479 c=0
Rk83 (\5\:VDD \12\:VDD) resistor r=0.2893 c=0
Rk84 (\6\:VDD \14\:VDD) resistor r=0.363 c=0
Rk85 (\8\:VDD \16\:VDD) resistor r=0.4002 c=0
Rk86 (\10\:VDD \18\:VDD) resistor r=0.3555 c=0
Rk88 (VDD \19\:VDD) resistor r=0.1508 c=0
Rk89 (\19\:VDD VDD) resistor r=0.08359 c=0
Rk90 (\19\:VDD \21\:VDD) resistor r=0.3575 c=0
Rk43 (\9\:RT \10\:RT) resistor r=0.4439 c=0
Rk48 (RT \11\:RT) resistor r=0.006174 c=0
Rk60 (\2\:VSS \4\:VSS) resistor r=0.3602 c=0
Rk61 (\4\:VSS \5\:VSS) resistor r=0.2346 c=0
Rk62 (\5\:VSS \6\:VSS) resistor r=0.2099 c=0
Rk64 (\7\:VSS VSS) resistor r=0.133 c=0
Rk63 (\6\:VSS \7\:VSS) resistor r=0.4595 c=0
Rk65 (VSS \8\:VSS) resistor r=0.0742 c=0
Rk66 (\8\:VSS \9\:VSS) resistor r=0.1234 c=0
Rk68 (\10\:VSS VSS) resistor r=0.0218 c=0
Rk67 (\9\:VSS \10\:VSS) resistor r=0.5905 c=0
Rk69 (VSS \11\:VSS) resistor r=0.1782 c=0
Rk70 (\11\:VSS \12\:VSS) resistor r=0.1852 c=0
Rk71 (\12\:VSS \13\:VSS) resistor r=0.06159 c=0
Rk72 (\5\:VSS \15\:VSS) resistor r=0.2661 c=0
Rk73 (\7\:VSS \17\:VSS) resistor r=0.1886 c=0
Rk74 (\8\:VSS \19\:VSS) resistor r=0.1936 c=0
Rk75 (\10\:VSS \21\:VSS) resistor r=0.2397 c=0
Rk76 (\12\:VSS \23\:VSS) resistor r=0.2275 c=0
Rk91 (\25\:VSS \27\:VSS) resistor r=0.3502 c=0
Rk92 (\27\:VSS \28\:VSS) resistor r=0.5608 c=0
Rk94 (\29\:VSS VSS) resistor r=0.04918 c=0
Rk93 (\28\:VSS \29\:VSS) resistor r=0.1308 c=0
Rk96 (\30\:VSS VSS) resistor r=0.1184 c=0
Rk95 (VSS \30\:VSS) resistor r=0.6923 c=0
Rk97 (VSS \32\:VSS) resistor r=0.3448 c=0
Rk98 (\28\:VSS \34\:VSS) resistor r=0.3466 c=0
Rk2 (\16\:CKNb \17\:CKNb) resistor r=0.833 c=0
Rk21 (\19\:CKNb \20\:CKNb) resistor r=0.1942 c=0
Rk22 (\20\:CKNb \21\:CKNb) resistor r=0.1635 c=0
Rk23 (\20\:CKNb \23\:CKNb) resistor r=0.3386 c=0
Rk50 (\24\:CKNb \25\:CKNb) resistor r=0.8593 c=0
Rk3 (\8\:n20 \10\:n20) resistor r=0.4916 c=0
Rk4 (\10\:n20 \11\:n20) resistor r=0.3146 c=0
Rk5 (\12\:n20 \14\:n20) resistor r=0.2755 c=0
Rk6 (\14\:n20 \15\:n20) resistor r=0.2391 c=0
Rk7 (\12\:n20 \17\:n20) resistor r=0.2331 c=0
Rk8 (\10\:CKNbb \11\:CKNbb) resistor r=0.1978 c=0
Rk9 (\11\:CKNbb \12\:CKNbb) resistor r=0.0234 c=0
Rk10 (\11\:CKNbb \14\:CKNbb) resistor r=0.3406 c=0
Rk11 (\14\:CKNbb \15\:CKNbb) resistor r=0.2716 c=0
Rk16 (\6\:mout \7\:mout) resistor r=0.3047 c=0
Rk17 (\7\:mout \8\:mout) resistor r=0.1491 c=0
Rk18 (\8\:mout \9\:mout) resistor r=0.124 c=0
Rk19 (\7\:mout \11\:mout) resistor r=0.2731 c=0
Rk20 (\8\:mout \12\:mout) resistor r=0.1306 c=0
Rk24 (\5\:n35 \6\:n35) resistor r=0.2862 c=0
Rk25 (\6\:n35 \8\:n35) resistor r=0.2718 c=0
Rk26 (\6\:n35 \9\:n35) resistor r=0.5666 c=0
Rk29 (\11\:n35 \12\:n35) resistor r=0.2717 c=0
Rk30 (\12\:n35 \14\:n35) resistor r=0.3267 c=0
Rk53 (\16\:n35 \17\:n35) resistor r=0.1699 c=0
Rk54 (\17\:n35 \19\:n35) resistor r=0.4261 c=0
Rk27 (\7\:n35g \8\:n35g) resistor r=0.2288 c=0
Rk28 (\7\:n35g \10\:n35g) resistor r=0.6045 c=0
Rk40 (\12\:n35g \13\:n35g) resistor r=0.2422 c=0
Rk41 (\13\:n35g \14\:n35g) resistor r=0.5637 c=0
Rk42 (\13\:n35g \16\:n35g) resistor r=0.4306 c=0
Rk37 (\15\:qbint \16\:qbint) resistor r=0.4929 c=0
Rk38 (\16\:qbint \18\:qbint) resistor r=0.5654 c=0
Rk39 (\16\:qbint \20\:qbint) resistor r=0.1458 c=0
Rk49 (\21\:qbint \22\:qbint) resistor r=0.2111 c=0
Rk44 (\5\:RTb \7\:RTb) resistor r=0.2259 c=0
Rk45 (\7\:RTb \8\:RTb) resistor r=0.2725 c=0
Rk46 (\8\:RTb \9\:RTb) resistor r=0.6686 c=0
Rk47 (\8\:RTb \11\:RTb) resistor r=0.3323 c=0
Rk55 (\6\:qint \7\:qint) resistor r=0.2539 c=0
Rk56 (\7\:qint \8\:qint) resistor r=0.1616 c=0
Rk57 (\7\:qint \10\:qint) resistor r=0.2766 c=0
Rl19 (\2\:CKN \4\:CKN) resistor r=70.868 c=0
Rl17 (\1\:CKN \2\:CKN) resistor r=140.099 c=0
Rl18 (\2\:CKN \3\:CKN) resistor r=2.0166 c=0
Rl3 (\2\:D \4\:D) resistor r=111.253 c=0
Rl1 (\1\:D \2\:D) resistor r=99.7141 c=0
Rl2 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl34 (\3\:RT \7\:RT) resistor r=709.9 c=0
Rl31 (\3\:RT \4\:RT) resistor r=72.2057 c=0
Rl25 (\1\:RT \2\:RT) resistor r=125.877 c=0
Rl35 (\5\:RT \8\:RT) resistor r=30.9873 c=0
Rl33 (\5\:RT \6\:RT) resistor r=273.765 c=0
Rl32 (\4\:RT \5\:RT) resistor r=78.204 c=0
Rl43 (\14\:CKNb \15\:CKNb) resistor r=115.79 c=0
Rl11 (\4\:CKNb \5\:CKNb) resistor r=246.721 c=0
Rl8 (CKNb \2\:CKNb) resistor r=0.6084 c=0
Rl12 (\2\:CKNb \6\:CKNb) resistor r=73.8796 c=0
Rl13 (\3\:CKNb \7\:CKNb) resistor r=64.6458 c=0
Rl10 (\3\:CKNb \4\:CKNb) resistor r=208.713 c=0
Rl9 (\2\:CKNb \3\:CKNb) resistor r=64.0061 c=0
Rl39 (\9\:CKNb \12\:CKNb) resistor r=64.1356 c=0
Rl36 (\8\:CKNb \9\:CKNb) resistor r=862.964 c=0
Rl40 (\10\:CKNb \13\:CKNb) resistor r=64.1356 c=0
Rl38 (\10\:CKNb \11\:CKNb) resistor r=113.909 c=0
Rl37 (\9\:CKNb \10\:CKNb) resistor r=172.374 c=0
Rl4 (n20 \2\:n20) resistor r=112.885 c=0
Rl14 (\3\:n20 \4\:n20) resistor r=103.572 c=0
Rl16 (\4\:n20 \6\:n20) resistor r=96.5354 c=0
Rl15 (\4\:n20 \5\:n20) resistor r=121.254 c=0
Rl5 (CKNbb \2\:CKNbb) resistor r=157.453 c=0
Rl44 (\3\:CKNbb \4\:CKNbb) resistor r=1441.22 c=0
Rl47 (\4\:CKNbb \7\:CKNbb) resistor r=140.831 c=0
Rl48 (\5\:CKNbb \8\:CKNbb) resistor r=66.684 c=0
Rl46 (\5\:CKNbb \6\:CKNbb) resistor r=229.379 c=0
Rl45 (\4\:CKNbb \5\:CKNbb) resistor r=112.483 c=0
Rl6 (mout \2\:mout) resistor r=24.2328 c=0
Rl7 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl41 (n35 \2\:n35) resistor r=499.328 c=0
Rl42 (\2\:n35 \3\:n35) resistor r=104.689 c=0
Rl22 (\3\:n35g \4\:n35g) resistor r=241.174 c=0
Rl20 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl21 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl23 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl52 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl57 (\11\:qbint \12\:qbint) resistor r=195.609 c=0
Rl59 (\13\:qbint \14\:qbint) resistor r=235.906 c=0
Rl30 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl27 (qbint \2\:qbint) resistor r=112.732 c=0
Rl29 (\2\:qbint \4\:qbint) resistor r=148.502 c=0
Rl28 (\2\:qbint \3\:qbint) resistor r=74.1915 c=0
Rl53 (\7\:qbint \8\:qbint) resistor r=203.519 c=0
Rl56 (\8\:qbint \11\:qbint) resistor r=92.0202 c=0
Rl58 (\9\:qbint \13\:qbint) resistor r=355.65 c=0
Rl55 (\9\:qbint \10\:qbint) resistor r=244.214 c=0
Rl54 (\8\:qbint \9\:qbint) resistor r=221.574 c=0
Rl26 (\3\:RTb \4\:RTb) resistor r=242.199 c=0
Rl24 (RTb \2\:RTb) resistor r=124.312 c=0
Rl49 (qint \2\:qint) resistor r=3.1216 c=0
Rl50 (\2\:qint \3\:qint) resistor r=64.1263 c=0
Rl51 (\2\:qint \4\:qint) resistor r=73.7417 c=0
Rz16 (\3\:Q \4\:Q) resistor r=37.5 c=0
Rz13 (\3\:QN \4\:QN) resistor r=37.5 c=0
Rz23 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz24 (\3\:VDD \7\:VDD) resistor r=37.5 c=0
Rz17 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz18 (\14\:VSS \15\:VSS) resistor r=37.5 c=0
Rz19 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz20 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz21 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz22 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz26 (\24\:VSS \25\:VSS) resistor r=75 c=0
Rz27 (\31\:VSS \32\:VSS) resistor r=75 c=0
Rz28 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz5 (\18\:CKNb \19\:CKNb) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\16\:n20 \17\:n20) resistor r=75 c=0
Rz3 (\9\:CKNbb \10\:CKNbb) resistor r=75 c=0
Rz4 (\10\:mout \11\:mout) resistor r=75 c=0
Rz6 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz8 (\13\:n35 \14\:n35) resistor r=75 c=0
Rz14 (\18\:n35 \19\:n35) resistor r=75 c=0
Rz7 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz11 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz10 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz12 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz15 (\5\:qint \6\:qint) resistor r=75 c=0
Ry20 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry9 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry10 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry11 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry12 (\1\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \8\:ExtVDD) resistor r=62 c=0
Ry17 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry26 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry27 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry28 (\13\:VDD \14\:VDD) resistor r=20.6667 c=0
Ry29 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry30 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry31 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry21 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry22 (\3\:VSS \6\:VSS) resistor r=15.5 c=0
Ry23 (\3\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry24 (\3\:VSS \11\:VSS) resistor r=15.5 c=0
Ry25 (\3\:VSS \13\:VSS) resistor r=62 c=0
Ry32 (\26\:VSS \27\:VSS) resistor r=5.6364 c=0
Ry33 (\26\:VSS \29\:VSS) resistor r=20.6667 c=0
Ry34 (\26\:VSS \30\:VSS) resistor r=5.1667 c=0
Ry5 (\22\:CKNb \23\:CKNb) resistor r=62 c=0
Ry1 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry2 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry3 (\13\:CKNbb \14\:CKNbb) resistor r=62 c=0
Ry4 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry8 (\10\:n35 \11\:n35) resistor r=62 c=0
Ry18 (\15\:n35 \16\:n35) resistor r=62 c=0
Ry7 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry16 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry19 (\9\:qint \10\:qint) resistor r=62 c=0
Rx9 (\3\:CKN \7\:CKN) resistor r=45 c=0
Rx1 (\3\:D D) resistor r=45 c=0
Rx18 (\4\:RT \9\:RT) resistor r=45 c=0
Rx19 (\2\:RT \10\:RT) resistor r=45 c=0
Rx22 (\3\:RT \11\:RT) resistor r=45 c=0
Rx2 (\5\:CKNb \16\:CKNb) resistor r=45 c=0
Rx3 (\11\:CKNb \17\:CKNb) resistor r=45 c=0
Rx12 (CKNb \21\:CKNb) resistor r=45 c=0
Rx25 (\15\:CKNb \24\:CKNb) resistor r=45 c=0
Rx26 (\8\:CKNb \25\:CKNb) resistor r=45 c=0
Rx4 (\2\:n20 \11\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \12\:n20) resistor r=45 c=0
Rx6 (n20 \15\:n20) resistor r=45 c=0
Rx7 (CKNbb \12\:CKNbb) resistor r=45 c=0
Rx8 (\7\:CKNbb \15\:CKNbb) resistor r=45 c=0
Rx10 (\4\:mout \9\:mout) resistor r=45 c=0
Rx11 (\2\:mout \12\:mout) resistor r=45 c=0
Rx13 (\3\:n35 \9\:n35) resistor r=45 c=0
Rx15 (\2\:n35 \12\:n35) resistor r=45 c=0
Rx27 (n35 \17\:n35) resistor r=45 c=0
Rx14 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx17 (n35g \14\:n35g) resistor r=45 c=0
Rx16 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx23 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx24 (qbint \22\:qbint) resistor r=45 c=0
Rx20 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx21 (\2\:RTb \9\:RTb) resistor r=45 c=0
Rx28 (qint \8\:qint) resistor r=45 c=0
mn25 (n21 \1\:D \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\7\:n20 \2\:CKNbb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\16\:n20 \13\:CKNb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.55e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn35 (n30 \3\:mout \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.5e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn21 (\9\:CKNbb \6\:CKNb \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\10\:mout \6\:n20 \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.45e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn20 (\18\:CKNb \1\:CKN \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\7\:n35 \12\:CKNb \10\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.4e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
NM0 (\9\:n35g RTb \13\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
NM1 (\19\:qbint \5\:n35g \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0121 \5\:qbint \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \1\:RT \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
NM2 (\11\:n35g \7\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\18\:n35 \3\:CKNbb net095 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\3\:QN \4\:qint \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 scb=0.0162972 \
        scc=0.00139495 m=(1)
mn52 (net095 \14\:qbint \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn56 (\5\:qint \12\:qbint \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn55 (\3\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp26 (\9\:n20 \4\:CKNb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3839 \
        scb=0.011256 scc=0.000224024 m=(1)
mp36 (\13\:n20 \6\:CKNbb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.55e-07 sd=160n sca=8.43833 \
        scb=0.00456328 scc=4.14083e-05 m=(1)
mp35 (n31 mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.5e-07 sd=160n sca=8.66197 \
        scb=0.00491317 scc=4.24157e-05 m=(1)
mp21 (\13\:CKNbb \7\:CKNb \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.3786 \
        scb=0.00949038 scc=0.000203066 m=(1)
mp32 (\5\:mout \3\:n20 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.45e-07 sd=160n sca=10.9141 \
        scb=0.00882323 scc=9.56076e-05 m=(1)
mp20 (\22\:CKNb \4\:CKN \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=15.4857 \
        scb=0.0166783 scc=0.00041931 m=(1)
mp40 (\4\:n35 \8\:CKNbb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.4e-07 sd=160n sca=22.4791 \
        scb=0.0247612 scc=0.0018296 m=(1)
PM0 (\6\:n35g \6\:RT \10\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=35.8476 \
        scb=0.0407387 scc=0.00396292 m=(1)
PM1 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.3457e-13 ad=3.01e-14 ps=3.53e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.3956 \
        scb=0.0259635 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.3457e-13 ad=1.29e-14 ps=3.53e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.6455 \
        scb=0.014432 scc=0.000486925 m=(1)
mp45 (\6\:RTb \8\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.3457e-13 ad=3.01e-14 ps=3.53e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.1e-07 sb=1.4e-07 sd=160n sca=34.1371 \
        scb=0.0394413 scc=0.00358201 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.3956 \
        scb=0.0259635 scc=0.00265434 m=(1)
mp53 (\15\:n35 \14\:CKNb net082 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\1\:QN \3\:qint \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=28.893 \
        scb=0.031948 scc=0.00297886 m=(1)
mp52 (net082 \13\:qbint \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=15.0501 \
        scb=0.0157632 scc=0.000508204 m=(1)
mp56 (\9\:qint \11\:qbint \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.6819 \
        scb=0.0114274 scc=0.000189805 m=(1)
mp55 (\1\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2615 \
        scb=0.0122477 scc=0.000351335 m=(1)
ends RDFFNX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:46:57 2012 )
// Library name: gsclib045
// Cell name: RDFFQX1
// View name: extracted

simulator lang=spectre

subckt RDFFQX1 CK D ExtVDD Q RT VDD VSS
mp25 (n22 \4\:D \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.9347 \
        scb=0.0157363 scc=0.000368461 m=(1)
C1 (ExtVDD VSS) capacitor c=1.24993e-16
C2 (RT VSS) capacitor c=1.92738e-17
C3 (D VSS) capacitor c=2.57169e-17
C4 (VDD VSS) capacitor c=4.37197e-16
C5 (Q VSS) capacitor c=3.45197e-17
C6 (CK VSS) capacitor c=4.66136e-17
C7 (CKbb VSS) capacitor c=4.89819e-17
C8 (n20 VSS) capacitor c=4.53641e-17
C9 (mout VSS) capacitor c=5.65999e-17
C10 (n35 VSS) capacitor c=1.46602e-16
C11 (CKb VSS) capacitor c=3.42148e-16
C12 (n35g VSS) capacitor c=1.77389e-17
C13 (qbint VSS) capacitor c=4.82666e-17
C14 (RTb VSS) capacitor c=3.93726e-17
C15 (\9\:qbint VSS) capacitor c=2.81469e-17
C16 (\10\:qbint VSS) capacitor c=1.99909e-16
C17 (\10\:CKbb VSS) capacitor c=8.73595e-17
C18 (\4\:RTb VSS) capacitor c=9.8215e-17
C19 (\8\:RT VSS) capacitor c=2.17433e-17
C20 (\4\:qbint VSS) capacitor c=6.83862e-17
C21 (\3\:n35g VSS) capacitor c=4.82887e-17
C22 (\6\:RT VSS) capacitor c=7.62252e-17
C23 (\7\:CKb VSS) capacitor c=2.84412e-17
C24 (\4\:CK VSS) capacitor c=3.38134e-17
C25 (\3\:n20 VSS) capacitor c=5.75688e-17
C26 (\3\:CKb VSS) capacitor c=6.05042e-17
C27 (\10\:CKb VSS) capacitor c=9.53393e-17
C28 (\2\:CKbb VSS) capacitor c=1.20454e-16
C29 (\4\:D VSS) capacitor c=6.87857e-17
C30 (\6\:qbint VSS) capacitor c=3.15e-17
C31 (\11\:qbint VSS) capacitor c=9.13804e-17
C32 (\7\:RT VSS) capacitor c=1.67234e-16
C33 (\1\:RT VSS) capacitor c=4.42713e-17
C34 (\5\:qbint VSS) capacitor c=3.91272e-17
C35 (\5\:n35g VSS) capacitor c=2.84973e-17
C36 (\8\:CKbb VSS) capacitor c=2.92085e-17
C37 (\1\:CK VSS) capacitor c=3.81818e-17
C38 (\6\:n20 VSS) capacitor c=5.10978e-17
C39 (\8\:CKb VSS) capacitor c=2.41108e-17
C40 (\3\:mout VSS) capacitor c=4.90535e-17
C41 (\9\:CKbb VSS) capacitor c=5.01877e-17
C42 (\5\:CKb VSS) capacitor c=8.51711e-17
C43 (\1\:D VSS) capacitor c=4.70868e-17
C44 (\11\:CKbb VSS) capacitor c=5.67919e-17
C45 (\4\:CKbb VSS) capacitor c=1.27215e-16
C46 (\8\:qbint VSS) capacitor c=1.06582e-16
C47 (\3\:RT VSS) capacitor c=1.70127e-16
C48 (\3\:RTb VSS) capacitor c=7.31992e-17
C49 (\4\:RT VSS) capacitor c=4.30278e-17
C50 (\2\:RT VSS) capacitor c=3.89013e-17
C51 (\3\:qbint VSS) capacitor c=3.54732e-17
C52 (\2\:RTb VSS) capacitor c=4.00519e-17
C53 (\2\:n35 VSS) capacitor c=1.65824e-16
C54 (\4\:n35g VSS) capacitor c=6.81327e-17
C55 (\3\:n35 VSS) capacitor c=4.35542e-17
C56 (\3\:CK VSS) capacitor c=2.66216e-17
C57 (\9\:CKb VSS) capacitor c=8.54208e-17
C58 (\2\:mout VSS) capacitor c=3.86154e-17
C59 (\4\:mout VSS) capacitor c=4.0206e-17
C60 (\5\:n20 VSS) capacitor c=4.33896e-17
C61 (\2\:n20 VSS) capacitor c=4.09292e-17
C62 (\3\:CKbb VSS) capacitor c=6.09876e-17
C63 (\7\:CKbb VSS) capacitor c=3.01016e-17
C64 (\3\:D VSS) capacitor c=1.68778e-17
C65 (\1\:VDD VSS) capacitor c=4.45124e-17
C66 (\9\:VDD VSS) capacitor c=2.51715e-17
C67 (\3\:Q VSS) capacitor c=6.14543e-17
C68 (\15\:n35 VSS) capacitor c=4.31357e-17
C69 (\15\:n35g VSS) capacitor c=4.74764e-17
C70 (\6\:RTb VSS) capacitor c=5.98034e-17
C71 (\1\:ExtVDD VSS) capacitor c=2.89868e-16
C72 (\10\:n35 VSS) capacitor c=5.11249e-17
C73 (\14\:qbint VSS) capacitor c=6.81343e-17
C74 (\6\:n35g VSS) capacitor c=8.75619e-17
C75 (\4\:n35 VSS) capacitor c=4.00017e-17
C76 (\13\:CKb VSS) capacitor c=5.9987e-17
C77 (\5\:mout VSS) capacitor c=5.94436e-17
C78 (\11\:VDD VSS) capacitor c=6.78123e-17
C79 (\13\:VDD VSS) capacitor c=5.98691e-17
C80 (\17\:CKbb VSS) capacitor c=4.42329e-17
C81 (\13\:n20 VSS) capacitor c=4.6032e-17
C82 (\9\:n20 VSS) capacitor c=8.38584e-17
C83 (\16\:VDD VSS) capacitor c=3.49058e-17
C84 (\1\:Q VSS) capacitor c=4.10846e-17
C85 (\18\:n35 VSS) capacitor c=6.04504e-17
C86 (\11\:n35g VSS) capacitor c=2.95193e-17
C87 (\10\:RTb VSS) capacitor c=5.97655e-17
C88 (\13\:n35 VSS) capacitor c=5.58349e-17
C89 (\16\:qbint VSS) capacitor c=2.40684e-17
C90 (\9\:n35g VSS) capacitor c=7.65622e-17
C91 (\7\:n35 VSS) capacitor c=4.4942e-17
C92 (\15\:CKb VSS) capacitor c=3.64522e-17
C93 (\10\:mout VSS) capacitor c=5.24732e-17
C94 (\14\:CKbb VSS) capacitor c=4.92066e-17
C95 (\16\:n20 VSS) capacitor c=4.3754e-17
C96 (\7\:n20 VSS) capacitor c=7.64159e-17
C97 (\2\:D VSS) capacitor c=4.24905e-17
C98 (\4\:n20 VSS) capacitor c=4.72351e-17
C99 (\2\:CK VSS) capacitor c=3.28578e-17
C100 (\2\:n35g VSS) capacitor c=3.01506e-17
C101 (ExtVDD VSS) capacitor c=3.9583e-17
C102 (\2\:qbint VSS) capacitor c=4.01025e-17
C103 (\5\:RT VSS) capacitor c=5.09193e-17
C104 (\5\:CKbb VSS) capacitor c=1.09084e-16
C105 (\6\:CKbb VSS) capacitor c=4.17719e-17
C106 (\2\:CKb VSS) capacitor c=2.58034e-16
C107 (\6\:CKb VSS) capacitor c=4.08512e-17
C108 (\7\:qbint VSS) capacitor c=2.78899e-17
C109 (\12\:CKbb VSS) capacitor c=9.75357e-17
C110 (\13\:CKbb VSS) capacitor c=8.61806e-17
C111 (\5\:D VSS) capacitor c=2.80079e-17
C112 (\11\:n20 VSS) capacitor c=3.77534e-17
C113 (\12\:n20 VSS) capacitor c=5.21768e-17
C114 (\15\:n20 VSS) capacitor c=5.25715e-17
C115 (\16\:CKbb VSS) capacitor c=8.17119e-17
C116 (\7\:mout VSS) capacitor c=4.29254e-17
C117 (\8\:mout VSS) capacitor c=2.73299e-17
C118 (\9\:mout VSS) capacitor c=2.48939e-17
C119 (\12\:mout VSS) capacitor c=2.48691e-17
C120 (\5\:CK VSS) capacitor c=4.6308e-17
C121 (\11\:CKb VSS) capacitor c=5.24227e-17
C122 (\12\:CKb VSS) capacitor c=4.36858e-17
C123 (\6\:n35 VSS) capacitor c=6.84178e-17
C124 (\9\:n35 VSS) capacitor c=6.21997e-17
C125 (\8\:n35g VSS) capacitor c=3.19866e-17
C126 (\12\:n35 VSS) capacitor c=6.04519e-17
C127 (\12\:qbint VSS) capacitor c=8.89171e-17
C128 (\13\:qbint VSS) capacitor c=1.10987e-16
C129 (\13\:n35g VSS) capacitor c=1.13318e-16
C130 (\14\:n35g VSS) capacitor c=1.16555e-16
C131 (\9\:RT VSS) capacitor c=6.33362e-17
C132 (\10\:RT VSS) capacitor c=6.14857e-17
C133 (\5\:RTb VSS) capacitor c=3.69873e-17
C134 (\8\:RTb VSS) capacitor c=1.11714e-16
C135 (\9\:RTb VSS) capacitor c=6.96605e-17
C136 (\11\:RT VSS) capacitor c=3.15307e-17
C137 (\18\:qbint VSS) capacitor c=1.865e-17
C138 (\19\:qbint VSS) capacitor c=3.10309e-17
C139 (\19\:CKbb VSS) capacitor c=1.10574e-16
C140 (\20\:CKbb VSS) capacitor c=9.79989e-17
C141 (\17\:n35 VSS) capacitor c=6.15215e-17
C142 (\3\:VDD VSS) capacitor c=1.17749e-17
C143 (\5\:VDD VSS) capacitor c=2.24994e-16
C144 (\6\:VDD VSS) capacitor c=1.94095e-16
C145 (\8\:VDD VSS) capacitor c=3.02406e-17
C146 (\15\:VDD VSS) capacitor c=3.79947e-17
Rk31 (ExtVDD ExtVDD) resistor r=0.002057 c=0
Rk29 (\2\:ExtVDD ExtVDD) resistor r=0.0221 c=0
Rk32 (ExtVDD \5\:ExtVDD) resistor r=0.0201 c=0
Rk33 (ExtVDD \6\:ExtVDD) resistor r=0.1054 c=0
Rk34 (\7\:ExtVDD \8\:ExtVDD) resistor r=0.02871 c=0
Rk41 (\9\:RT \10\:RT) resistor r=0.4442 c=0
Rk46 (RT \11\:RT) resistor r=0.02248 c=0
Rk2 (D \5\:D) resistor r=0.02028 c=0
Rk67 (\2\:VDD \3\:VDD) resistor r=0.4104 c=0
Rk68 (\3\:VDD \5\:VDD) resistor r=0.07275 c=0
Rk69 (\5\:VDD \6\:VDD) resistor r=1.5656 c=0
Rk74 (\8\:VDD VDD) resistor r=0.1806 c=0
Rk70 (\6\:VDD \8\:VDD) resistor r=0.05483 c=0
Rk71 (\3\:VDD \10\:VDD) resistor r=0.296 c=0
Rk72 (\6\:VDD \12\:VDD) resistor r=0.3788 c=0
Rk73 (\8\:VDD \14\:VDD) resistor r=0.3557 c=0
Rk75 (VDD \15\:VDD) resistor r=0.1509 c=0
Rk76 (\15\:VDD VDD) resistor r=0.08366 c=0
Rk77 (\15\:VDD \17\:VDD) resistor r=0.3577 c=0
Rk51 (\2\:Q Q) resistor r=0.1608 c=0
Rk52 (Q \4\:Q) resistor r=0.3215 c=0
Rk16 (\5\:CK CK) resistor r=0.006226 c=0
Rk15 (\5\:CK \6\:CK) resistor r=0.005454 c=0
Rk53 (\2\:VSS \4\:VSS) resistor r=0.4272 c=0
Rk54 (\4\:VSS \5\:VSS) resistor r=0.5588 c=0
Rk56 (\6\:VSS VSS) resistor r=0.07377 c=0
Rk55 (\5\:VSS \6\:VSS) resistor r=0.2074 c=0
Rk57 (VSS \7\:VSS) resistor r=0.04972 c=0
Rk59 (\8\:VSS VSS) resistor r=0.02182 c=0
Rk58 (\7\:VSS \8\:VSS) resistor r=0.591 c=0
Rk60 (VSS \9\:VSS) resistor r=0.1783 c=0
Rk61 (\9\:VSS \10\:VSS) resistor r=0.1853 c=0
Rk62 (\10\:VSS \11\:VSS) resistor r=0.06165 c=0
Rk63 (\5\:VSS \13\:VSS) resistor r=0.1887 c=0
Rk64 (\6\:VSS \15\:VSS) resistor r=0.1938 c=0
Rk65 (\8\:VSS \17\:VSS) resistor r=0.2399 c=0
Rk66 (\10\:VSS \19\:VSS) resistor r=0.2277 c=0
Rk78 (\21\:VSS \23\:VSS) resistor r=0.4974 c=0
Rk79 (\23\:VSS \24\:VSS) resistor r=0.4129 c=0
Rk81 (\25\:VSS VSS) resistor r=0.1976 c=0
Rk80 (\24\:VSS \25\:VSS) resistor r=0.1309 c=0
Rk83 (\26\:VSS VSS) resistor r=0.1185 c=0
Rk82 (VSS \26\:VSS) resistor r=0.5444 c=0
Rk84 (VSS \28\:VSS) resistor r=0.3451 c=0
Rk85 (\24\:VSS \30\:VSS) resistor r=0.3469 c=0
Rk1 (\12\:CKbb \13\:CKbb) resistor r=0.8336 c=0
Rk8 (\15\:CKbb \16\:CKbb) resistor r=0.3151 c=0
Rk9 (\16\:CKbb \18\:CKbb) resistor r=0.1858 c=0
Rk48 (\19\:CKbb \20\:CKbb) resistor r=0.8499 c=0
Rk3 (\8\:n20 \10\:n20) resistor r=0.4919 c=0
Rk4 (\10\:n20 \11\:n20) resistor r=0.3007 c=0
Rk5 (\12\:n20 \14\:n20) resistor r=0.2757 c=0
Rk6 (\14\:n20 \15\:n20) resistor r=0.2392 c=0
Rk7 (\12\:n20 \17\:n20) resistor r=0.2333 c=0
Rk10 (\6\:mout \7\:mout) resistor r=0.3049 c=0
Rk11 (\7\:mout \8\:mout) resistor r=0.1492 c=0
Rk12 (\8\:mout \9\:mout) resistor r=0.1241 c=0
Rk13 (\7\:mout \11\:mout) resistor r=0.2733 c=0
Rk14 (\8\:mout \12\:mout) resistor r=0.1307 c=0
Rk22 (\5\:n35 \6\:n35) resistor r=0.2864 c=0
Rk23 (\6\:n35 \8\:n35) resistor r=0.272 c=0
Rk24 (\6\:n35 \9\:n35) resistor r=0.567 c=0
Rk27 (\11\:n35 \12\:n35) resistor r=0.2719 c=0
Rk28 (\12\:n35 \14\:n35) resistor r=0.3269 c=0
Rk49 (\16\:n35 \17\:n35) resistor r=0.17 c=0
Rk50 (\17\:n35 \19\:n35) resistor r=0.4264 c=0
Rk19 (\11\:CKb \12\:CKb) resistor r=0.2082 c=0
Rk20 (\12\:CKb \14\:CKb) resistor r=0.3121 c=0
Rk21 (\12\:CKb \16\:CKb) resistor r=0.1956 c=0
Rk25 (\7\:n35g \8\:n35g) resistor r=0.2289 c=0
Rk26 (\7\:n35g \10\:n35g) resistor r=0.6049 c=0
Rk38 (\12\:n35g \13\:n35g) resistor r=0.2424 c=0
Rk39 (\13\:n35g \14\:n35g) resistor r=0.5641 c=0
Rk40 (\13\:n35g \16\:n35g) resistor r=0.4309 c=0
Rk35 (\12\:qbint \13\:qbint) resistor r=0.4933 c=0
Rk36 (\13\:qbint \15\:qbint) resistor r=0.5658 c=0
Rk37 (\13\:qbint \17\:qbint) resistor r=0.1459 c=0
Rk47 (\18\:qbint \19\:qbint) resistor r=0.2113 c=0
Rk42 (\5\:RTb \7\:RTb) resistor r=0.226 c=0
Rk43 (\7\:RTb \8\:RTb) resistor r=0.2727 c=0
Rk44 (\8\:RTb \9\:RTb) resistor r=0.669 c=0
Rk45 (\8\:RTb \11\:RTb) resistor r=0.3325 c=0
Rl29 (\3\:RT \7\:RT) resistor r=709.9 c=0
Rl26 (\3\:RT \4\:RT) resistor r=72.2057 c=0
Rl20 (\1\:RT \2\:RT) resistor r=125.877 c=0
Rl30 (\5\:RT \8\:RT) resistor r=30.9873 c=0
Rl28 (\5\:RT \6\:RT) resistor r=273.765 c=0
Rl27 (\4\:RT \5\:RT) resistor r=78.204 c=0
Rl3 (\2\:D \4\:D) resistor r=132.406 c=0
Rl1 (\1\:D \2\:D) resistor r=78.5603 c=0
Rl2 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl14 (\2\:CK \4\:CK) resistor r=70.868 c=0
Rl12 (\1\:CK \2\:CK) resistor r=140.099 c=0
Rl13 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl5 (CKbb \2\:CKbb) resistor r=147.837 c=0
Rl38 (\10\:CKbb \11\:CKbb) resistor r=115.79 c=0
Rl6 (\2\:CKbb \3\:CKbb) resistor r=246.721 c=0
Rl34 (\5\:CKbb \8\:CKbb) resistor r=64.1356 c=0
Rl31 (\4\:CKbb \5\:CKbb) resistor r=862.964 c=0
Rl35 (\6\:CKbb \9\:CKbb) resistor r=64.1356 c=0
Rl33 (\6\:CKbb \7\:CKbb) resistor r=113.909 c=0
Rl32 (\5\:CKbb \6\:CKbb) resistor r=172.374 c=0
Rl4 (n20 \2\:n20) resistor r=112.885 c=0
Rl9 (\3\:n20 \4\:n20) resistor r=103.572 c=0
Rl11 (\4\:n20 \6\:n20) resistor r=96.5354 c=0
Rl10 (\4\:n20 \5\:n20) resistor r=121.254 c=0
Rl7 (mout \2\:mout) resistor r=24.2328 c=0
Rl8 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl36 (n35 \2\:n35) resistor r=499.328 c=0
Rl37 (\2\:n35 \3\:n35) resistor r=104.689 c=0
Rl39 (CKb \2\:CKb) resistor r=1441.22 c=0
Rl40 (\2\:CKb \3\:CKb) resistor r=214.27 c=0
Rl41 (\3\:CKb \4\:CKb) resistor r=134.462 c=0
Rl45 (\4\:CKb \8\:CKb) resistor r=72.9234 c=0
Rl42 (\4\:CKb \5\:CKb) resistor r=222.576 c=0
Rl46 (\4\:CKb \9\:CKb) resistor r=3.6978 c=0
Rl44 (\6\:CKb \7\:CKb) resistor r=66.684 c=0
Rl47 (\6\:CKb \10\:CKb) resistor r=229.379 c=0
Rl43 (\2\:CKb \6\:CKb) resistor r=112.483 c=0
Rl17 (\3\:n35g \4\:n35g) resistor r=241.174 c=0
Rl15 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl16 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl18 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl52 (\10\:qbint \11\:qbint) resistor r=235.906 c=0
Rl51 (\8\:qbint \10\:qbint) resistor r=601.135 c=0
Rl25 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl22 (qbint \2\:qbint) resistor r=112.732 c=0
Rl24 (\2\:qbint \4\:qbint) resistor r=148.502 c=0
Rl23 (\2\:qbint \3\:qbint) resistor r=74.1915 c=0
Rl50 (\7\:qbint \9\:qbint) resistor r=68.607 c=0
Rl48 (\6\:qbint \7\:qbint) resistor r=78.0039 c=0
Rl49 (\7\:qbint \8\:qbint) resistor r=166.462 c=0
Rl21 (\3\:RTb \4\:RTb) resistor r=242.199 c=0
Rl19 (RTb \2\:RTb) resistor r=124.312 c=0
Rz14 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz15 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz16 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz17 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz18 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz19 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz22 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz23 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz24 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz3 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\16\:n20 \17\:n20) resistor r=75 c=0
Rz4 (\10\:mout \11\:mout) resistor r=75 c=0
Rz6 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz8 (\13\:n35 \14\:n35) resistor r=75 c=0
Rz13 (\18\:n35 \19\:n35) resistor r=75 c=0
Rz5 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz7 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz11 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz10 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz12 (\10\:RTb \11\:RTb) resistor r=75 c=0
Ry9 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry10 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry11 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry12 (\1\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \8\:ExtVDD) resistor r=62 c=0
Ry23 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry24 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry25 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry26 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry27 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry18 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry19 (\3\:VSS \4\:VSS) resistor r=10.3333 c=0
Ry20 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry21 (\3\:VSS \9\:VSS) resistor r=15.5 c=0
Ry22 (\3\:VSS \11\:VSS) resistor r=62 c=0
Ry28 (\22\:VSS \23\:VSS) resistor r=7.75 c=0
Ry29 (\22\:VSS \25\:VSS) resistor r=20.6667 c=0
Ry30 (\22\:VSS \26\:VSS) resistor r=5.1667 c=0
Ry3 (\17\:CKbb \18\:CKbb) resistor r=62 c=0
Ry1 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry2 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry4 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry8 (\10\:n35 \11\:n35) resistor r=62 c=0
Ry17 (\15\:n35 \16\:n35) resistor r=62 c=0
Ry5 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry7 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry16 (\6\:RTb \7\:RTb) resistor r=62 c=0
Rx17 (\4\:RT \9\:RT) resistor r=45 c=0
Rx18 (\2\:RT \10\:RT) resistor r=45 c=0
Rx21 (\3\:RT \11\:RT) resistor r=45 c=0
Rx3 (\3\:D \5\:D) resistor r=45 c=0
Rx10 (\3\:CK \6\:CK) resistor r=45 c=0
Rx1 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx2 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx7 (CKbb \16\:CKbb) resistor r=45 c=0
Rx24 (\11\:CKbb \19\:CKbb) resistor r=45 c=0
Rx25 (\4\:CKbb \20\:CKbb) resistor r=45 c=0
Rx4 (\2\:n20 \11\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \12\:n20) resistor r=45 c=0
Rx6 (n20 \15\:n20) resistor r=45 c=0
Rx8 (\4\:mout \9\:mout) resistor r=45 c=0
Rx9 (\2\:mout \12\:mout) resistor r=45 c=0
Rx12 (\3\:n35 \9\:n35) resistor r=45 c=0
Rx14 (\2\:n35 \12\:n35) resistor r=45 c=0
Rx26 (n35 \17\:n35) resistor r=45 c=0
Rx11 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx13 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx16 (n35g \14\:n35g) resistor r=45 c=0
Rx15 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx22 (\8\:qbint \18\:qbint) resistor r=45 c=0
Rx23 (qbint \19\:qbint) resistor r=45 c=0
Rx19 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx20 (\2\:RTb \9\:RTb) resistor r=45 c=0
mn25 (n21 \1\:D \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\7\:n20 \5\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\16\:n20 \9\:CKbb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.55e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn35 (n30 \3\:mout \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.5e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn21 (\14\:CKbb \8\:CKb \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\10\:mout \6\:n20 \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.45e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn20 (\15\:CKb \1\:CK \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\7\:n35 \8\:CKbb \10\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.4e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
NM0 (\9\:n35g RTb \13\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
NM1 (\16\:qbint \5\:n35g \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0121 \5\:qbint \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \1\:RT \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
NM2 (\11\:n35g \7\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\18\:n35 CKb net095 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (net095 \11\:qbint \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp26 (\9\:n20 \2\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3839 \
        scb=0.011256 scc=0.000224024 m=(1)
mp36 (\13\:n20 \10\:CKb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.55e-07 sd=160n sca=8.43833 \
        scb=0.00456328 scc=4.14083e-05 m=(1)
mp35 (n31 mout \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.5e-07 sd=160n sca=8.66197 \
        scb=0.00491317 scc=4.24157e-05 m=(1)
mp21 (\17\:CKbb \3\:CKb \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.3786 \
        scb=0.00949038 scc=0.000203066 m=(1)
mp32 (\5\:mout \3\:n20 \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.45e-07 sd=160n sca=10.9141 \
        scb=0.00882323 scc=9.56076e-05 m=(1)
mp20 (\13\:CKb \4\:CK \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=15.4857 \
        scb=0.0166783 scc=0.00041931 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.4e-07 sd=160n sca=22.4791 \
        scb=0.0247612 scc=0.0018296 m=(1)
PM0 (\6\:n35g \6\:RT \10\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=35.8476 \
        scb=0.0407387 scc=0.00396292 m=(1)
PM1 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.3457e-13 ad=3.01e-14 ps=3.53e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.3956 \
        scb=0.0259635 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.3457e-13 ad=1.29e-14 ps=3.53e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.6455 \
        scb=0.014432 scc=0.000486925 m=(1)
mp45 (\6\:RTb \8\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.3457e-13 ad=3.01e-14 ps=3.53e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.1e-07 sb=1.4e-07 sd=160n sca=34.1371 \
        scb=0.0394413 scc=0.00358201 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.3956 \
        scb=0.0259635 scc=0.00265434 m=(1)
mp53 (\15\:n35 \10\:CKbb net084 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=28.6011 \
        scb=0.0298676 scc=0.0026875 m=(1)
mp52 (net084 \10\:qbint \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=19.4537 \
        scb=0.0214753 scc=0.000585924 m=(1)
mp55 (\3\:Q \9\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=21.9069 \
        scb=0.0255526 scc=0.000831054 m=(1)
ends RDFFQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:47:43 2012 )
// Library name: gsclib045
// Cell name: RDFFRQX1
// View name: extracted

simulator lang=spectre

subckt RDFFRQX1 CK D ExtVDD Q RN RT VDD VSS
mp25 (n22 \3\:D \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (RT VSS) capacitor c=3.68658e-17
C2 (ExtVDD VSS) capacitor c=2.08302e-16
C3 (D VSS) capacitor c=5.05765e-17
C4 (RN VSS) capacitor c=3.46784e-17
C5 (VDD VSS) capacitor c=6.50641e-16
C6 (Q VSS) capacitor c=1.86834e-17
C7 (CKbb VSS) capacitor c=5.72289e-17
C8 (mout VSS) capacitor c=4.9959e-17
C9 (CKb VSS) capacitor c=2.3442e-17
C10 (n20 VSS) capacitor c=8.22695e-17
C11 (RNb VSS) capacitor c=5.59904e-17
C12 (n35g VSS) capacitor c=1.77671e-17
C13 (qbint VSS) capacitor c=4.57285e-17
C14 (RTb VSS) capacitor c=4.52673e-17
C15 (n35 VSS) capacitor c=1.8145e-16
C16 (net097 VSS) capacitor c=6.13611e-17
C17 (n40 VSS) capacitor c=7.48681e-17
C18 (\7\:qbint VSS) capacitor c=1.25053e-16
C19 (\2\:RNb VSS) capacitor c=3.01452e-16
C20 (\10\:qbint VSS) capacitor c=3.42792e-17
C21 (\10\:CKbb VSS) capacitor c=7.18853e-17
C22 (\4\:RTb VSS) capacitor c=9.85972e-17
C23 (\6\:RT VSS) capacitor c=2.24672e-17
C24 (\4\:qbint VSS) capacitor c=5.35139e-17
C25 (\3\:n35g VSS) capacitor c=6.24285e-17
C26 (\5\:RT VSS) capacitor c=8.45408e-17
C27 (\9\:CKb VSS) capacitor c=1.01492e-16
C28 (\4\:RN VSS) capacitor c=3.22183e-17
C29 (\5\:RNb VSS) capacitor c=6.41482e-17
C30 (\3\:n20 VSS) capacitor c=7.34077e-17
C31 (\4\:CK VSS) capacitor c=5.66637e-17
C32 (\5\:CKb VSS) capacitor c=2.96373e-17
C33 (\7\:CKb VSS) capacitor c=8.92957e-17
C34 (\2\:CKbb VSS) capacitor c=1.56218e-16
C35 (\3\:D VSS) capacitor c=5.61805e-17
C36 (\6\:qbint VSS) capacitor c=5.79729e-17
C37 (\11\:qbint VSS) capacitor c=4.11209e-17
C38 (\11\:CKb VSS) capacitor c=1.94321e-16
C39 (\7\:RT VSS) capacitor c=1.18624e-16
C40 (\2\:RT VSS) capacitor c=5.6984e-17
C41 (\5\:qbint VSS) capacitor c=3.87694e-17
C42 (\5\:n35g VSS) capacitor c=3.48637e-17
C43 (\2\:RTb VSS) capacitor c=4.91473e-17
C44 (\4\:CKbb VSS) capacitor c=3.23618e-17
C45 (\1\:RN VSS) capacitor c=3.41738e-17
C46 (\7\:RNb VSS) capacitor c=6.11841e-17
C47 (\1\:CK VSS) capacitor c=2.82836e-17
C48 (\6\:n20 VSS) capacitor c=6.24185e-17
C49 (\8\:CKb VSS) capacitor c=2.55255e-17
C50 (\3\:mout VSS) capacitor c=5.02446e-17
C51 (\9\:CKbb VSS) capacitor c=4.99683e-17
C52 (\4\:CKb VSS) capacitor c=8.52413e-17
C53 (\1\:D VSS) capacitor c=6.59513e-17
C54 (\9\:qbint VSS) capacitor c=8.23941e-17
C55 (\11\:CKbb VSS) capacitor c=7.33672e-17
C56 (\8\:RT VSS) capacitor c=1.51701e-16
C57 (\8\:CKbb VSS) capacitor c=1.43255e-16
C58 (\3\:RT VSS) capacitor c=5.7677e-17
C59 (\1\:RT VSS) capacitor c=4.85351e-17
C60 (\3\:RTb VSS) capacitor c=7.49641e-17
C61 (\3\:qbint VSS) capacitor c=4.41629e-17
C62 (\2\:n35 VSS) capacitor c=2.63216e-16
C63 (\4\:n35g VSS) capacitor c=7.15717e-17
C64 (\10\:CKb VSS) capacitor c=5.61043e-17
C65 (\12\:CKb VSS) capacitor c=2.28276e-16
C66 (\3\:n35 VSS) capacitor c=1.20797e-16
C67 (\6\:RNb VSS) capacitor c=7.98703e-17
C68 (\3\:RN VSS) capacitor c=4.87646e-17
C69 (\3\:CK VSS) capacitor c=2.36447e-17
C70 (\2\:mout VSS) capacitor c=3.99948e-17
C71 (\4\:mout VSS) capacitor c=3.90488e-17
C72 (\5\:n20 VSS) capacitor c=3.95559e-17
C73 (\2\:n20 VSS) capacitor c=7.16181e-17
C74 (\3\:CKbb VSS) capacitor c=8.28107e-17
C75 (\7\:CKbb VSS) capacitor c=3.16235e-17
C76 (\2\:D VSS) capacitor c=5.24695e-17
C77 (\1\:VDD VSS) capacitor c=4.75934e-17
C78 (\12\:VDD VSS) capacitor c=4.93534e-17
C79 (\4\:Q VSS) capacitor c=5.60929e-17
C80 (\3\:net097 VSS) capacitor c=9.8275e-17
C81 (\14\:n35 VSS) capacitor c=4.57629e-17
C82 (\15\:n35g VSS) capacitor c=5.80512e-17
C83 (\6\:RTb VSS) capacitor c=8.36625e-17
C84 (\1\:ExtVDD VSS) capacitor c=2.81284e-16
C85 (\9\:n35 VSS) capacitor c=5.47753e-17
C86 (\14\:qbint VSS) capacitor c=6.93329e-17
C87 (\6\:n35g VSS) capacitor c=9.13721e-17
C88 (\4\:n35 VSS) capacitor c=5.54247e-17
C89 (\11\:RNb VSS) capacitor c=2.80641e-17
C90 (\5\:mout VSS) capacitor c=7.06156e-17
C91 (\14\:VDD VSS) capacitor c=5.14906e-17
C92 (\16\:VDD VSS) capacitor c=4.40366e-17
C93 (\17\:CKb VSS) capacitor c=4.55655e-17
C94 (\17\:mout VSS) capacitor c=3.51139e-17
C95 (\18\:VDD VSS) capacitor c=6.01243e-17
C96 (\20\:VDD VSS) capacitor c=4.6265e-17
C97 (\18\:CKbb VSS) capacitor c=4.10725e-17
C98 (\7\:n20 VSS) capacitor c=4.09741e-17
C99 (\15\:n20 VSS) capacitor c=6.7896e-17
C100 (\23\:VDD VSS) capacitor c=4.06813e-17
C101 (\1\:Q VSS) capacitor c=3.83825e-17
C102 (\3\:n40 VSS) capacitor c=7.90524e-17
C103 (\17\:n35 VSS) capacitor c=4.8912e-17
C104 (\11\:n35g VSS) capacitor c=2.71993e-17
C105 (\10\:RTb VSS) capacitor c=4.83653e-17
C106 (\12\:n35 VSS) capacitor c=6.15791e-17
C107 (\16\:qbint VSS) capacitor c=2.32084e-17
C108 (\9\:n35g VSS) capacitor c=7.74366e-17
C109 (\7\:n35 VSS) capacitor c=4.51039e-17
C110 (\8\:RNb VSS) capacitor c=3.95412e-17
C111 (\8\:VDD VSS) capacitor c=4.43348e-17
C112 (\13\:mout VSS) capacitor c=5.50921e-17
C113 (\13\:CKb VSS) capacitor c=6.05153e-17
C114 (\15\:mout VSS) capacitor c=3.62361e-17
C115 (\14\:CKbb VSS) capacitor c=5.01654e-17
C116 (\11\:n20 VSS) capacitor c=6.1664e-17
C117 (\13\:n20 VSS) capacitor c=5.62535e-17
C118 (\2\:CK VSS) capacitor c=3.421e-17
C119 (\4\:n20 VSS) capacitor c=6.67549e-17
C120 (\2\:CKb VSS) capacitor c=2.75486e-17
C121 (\3\:CKb VSS) capacitor c=5.72619e-17
C122 (\6\:CKb VSS) capacitor c=9.31845e-17
C123 (\2\:n35g VSS) capacitor c=3.24215e-17
C124 (ExtVDD VSS) capacitor c=3.9408e-17
C125 (\4\:RT VSS) capacitor c=7.41198e-17
C126 (\2\:qbint VSS) capacitor c=4.14513e-17
C127 (\5\:CKbb VSS) capacitor c=1.24521e-16
C128 (\6\:CKbb VSS) capacitor c=6.28227e-17
C129 (\3\:RNb VSS) capacitor c=4.95009e-16
C130 (\4\:RNb VSS) capacitor c=1.13142e-16
C131 (\12\:CKbb VSS) capacitor c=6.34123e-17
C132 (\13\:CKbb VSS) capacitor c=7.45499e-17
C133 (\8\:qbint VSS) capacitor c=9.81296e-17
C134 (\9\:n20 VSS) capacitor c=2.90276e-17
C135 (\10\:n20 VSS) capacitor c=4.9973e-17
C136 (\17\:n20 VSS) capacitor c=3.11418e-17
C137 (\17\:CKbb VSS) capacitor c=7.44988e-17
C138 (\5\:CK VSS) capacitor c=4.81945e-17
C139 (\6\:CK VSS) capacitor c=3.77805e-17
C140 (\15\:CKb VSS) capacitor c=6.48315e-17
C141 (\16\:CKb VSS) capacitor c=5.04401e-17
C142 (\5\:RN VSS) capacitor c=4.60138e-17
C143 (\7\:mout VSS) capacitor c=5.29625e-17
C144 (\8\:mout VSS) capacitor c=4.64473e-17
C145 (\9\:mout VSS) capacitor c=1.01018e-17
C146 (\10\:mout VSS) capacitor c=2.76899e-17
C147 (\11\:mout VSS) capacitor c=1.52245e-17
C148 (\12\:mout VSS) capacitor c=3.03965e-17
C149 (\10\:RNb VSS) capacitor c=6.08734e-17
C150 (\6\:n35 VSS) capacitor c=5.90017e-17
C151 (\19\:CKb VSS) capacitor c=3.24421e-17
C152 (\20\:CKb VSS) capacitor c=3.22711e-17
C153 (\8\:n35g VSS) capacitor c=3.24313e-17
C154 (\11\:n35 VSS) capacitor c=6.21676e-17
C155 (\12\:qbint VSS) capacitor c=8.82866e-17
C156 (\13\:qbint VSS) capacitor c=1.03557e-16
C157 (\13\:n35g VSS) capacitor c=1.04671e-16
C158 (\14\:n35g VSS) capacitor c=1.16408e-16
C159 (\5\:RTb VSS) capacitor c=4.80617e-17
C160 (\8\:RTb VSS) capacitor c=8.74815e-17
C161 (\9\:RTb VSS) capacitor c=5.09192e-17
C162 (\20\:CKbb VSS) capacitor c=9.87475e-17
C163 (\21\:CKbb VSS) capacitor c=9.4266e-17
C164 (\18\:qbint VSS) capacitor c=1.98282e-17
C165 (\19\:qbint VSS) capacitor c=3.00914e-17
C166 (\9\:RT VSS) capacitor c=1.0663e-16
C167 (\10\:RT VSS) capacitor c=1.18671e-16
C168 (\11\:RT VSS) capacitor c=5.39499e-17
C169 (\16\:n35 VSS) capacitor c=4.42287e-17
C170 (\3\:Q VSS) capacitor c=1.5153e-17
C171 (\3\:VDD VSS) capacitor c=3.90517e-17
C172 (\5\:VDD VSS) capacitor c=2.37912e-16
C173 (\6\:VDD VSS) capacitor c=1.92159e-16
C174 (\7\:VDD VSS) capacitor c=5.47507e-18
C175 (\10\:VDD VSS) capacitor c=2.00447e-17
C176 (\22\:VDD VSS) capacitor c=2.69722e-17
Rk53 (RT \9\:RT) resistor r=0.1902 c=0
Rk54 (\9\:RT \10\:RT) resistor r=0.6402 c=0
Rk55 (RT \11\:RT) resistor r=0.008131 c=0
Rk38 (ExtVDD ExtVDD) resistor r=0.002057 c=0
Rk36 (\2\:ExtVDD ExtVDD) resistor r=0.0221 c=0
Rk39 (ExtVDD \5\:ExtVDD) resistor r=0.0201 c=0
Rk40 (ExtVDD \6\:ExtVDD) resistor r=0.1054 c=0
Rk11 (CK \5\:CK) resistor r=0.004344 c=0
Rk13 (\5\:CK \6\:CK) resistor r=0.01403 c=0
Rk12 (\6\:CK \7\:CK) resistor r=0.004525 c=0
Rk2 (\4\:D D) resistor r=0.006804 c=0
Rk17 (RN \5\:RN) resistor r=0.0381 c=0
Rk96 (\2\:VDD \3\:VDD) resistor r=0.4044 c=0
Rk97 (\3\:VDD \5\:VDD) resistor r=0.06659 c=0
Rk98 (\5\:VDD \6\:VDD) resistor r=1.6793 c=0
Rk99 (\6\:VDD \7\:VDD) resistor r=0.0293 c=0
Rk100 (\7\:VDD \9\:VDD) resistor r=0.04186 c=0
Rk101 (\9\:VDD \10\:VDD) resistor r=0.1482 c=0
Rk108 (\11\:VDD VDD) resistor r=0.218 c=0
Rk102 (\10\:VDD \11\:VDD) resistor r=0.05917 c=0
Rk103 (\3\:VDD \13\:VDD) resistor r=0.2921 c=0
Rk104 (\6\:VDD \15\:VDD) resistor r=0.3582 c=0
Rk105 (\7\:VDD \17\:VDD) resistor r=0.201 c=0
Rk106 (\10\:VDD \19\:VDD) resistor r=0.3788 c=0
Rk107 (\11\:VDD \21\:VDD) resistor r=0.2464 c=0
Rk109 (VDD \22\:VDD) resistor r=0.146 c=0
Rk110 (\22\:VDD VDD) resistor r=0.08861 c=0
Rk111 (\22\:VDD \24\:VDD) resistor r=0.3577 c=0
Rk59 (\3\:Q Q) resistor r=0.003941 c=0
Rk58 (\2\:Q \3\:Q) resistor r=0.2887 c=0
Rk60 (\3\:Q \5\:Q) resistor r=0.3259 c=0
Rk63 (\2\:VSS \3\:VSS) resistor r=0.03444 c=0
Rk64 (\3\:VSS \4\:VSS) resistor r=0.1136 c=0
Rk65 (\4\:VSS \5\:VSS) resistor r=0.08885 c=0
Rk66 (\5\:VSS \6\:VSS) resistor r=0.356 c=0
Rk68 (\7\:VSS VSS) resistor r=0.3755 c=0
Rk67 (\6\:VSS \7\:VSS) resistor r=0.3661 c=0
Rk69 (VSS \8\:VSS) resistor r=0.1487 c=0
Rk71 (\9\:VSS VSS) resistor r=0.2073 c=0
Rk70 (\8\:VSS \9\:VSS) resistor r=0.5564 c=0
Rk72 (VSS \10\:VSS) resistor r=0.01737 c=0
Rk73 (\10\:VSS \11\:VSS) resistor r=0.1086 c=0
Rk74 (\3\:VSS \13\:VSS) resistor r=0.2393 c=0
Rk75 (\5\:VSS \15\:VSS) resistor r=0.2456 c=0
Rk76 (\7\:VSS \17\:VSS) resistor r=0.2429 c=0
Rk77 (\9\:VSS \19\:VSS) resistor r=0.2393 c=0
Rk78 (\10\:VSS \21\:VSS) resistor r=0.2393 c=0
Rk79 (\23\:VSS \24\:VSS) resistor r=0.07154 c=0
Rk80 (\24\:VSS \25\:VSS) resistor r=0.6701 c=0
Rk81 (\25\:VSS \26\:VSS) resistor r=0.1655 c=0
Rk83 (\27\:VSS VSS) resistor r=0.1208 c=0
Rk82 (\26\:VSS \27\:VSS) resistor r=0.2074 c=0
Rk84 (VSS \28\:VSS) resistor r=0.6283 c=0
Rk86 (\29\:VSS VSS) resistor r=0.1185 c=0
Rk85 (\28\:VSS \29\:VSS) resistor r=0.06412 c=0
Rk87 (VSS \30\:VSS) resistor r=0.03716 c=0
Rk88 (\30\:VSS \31\:VSS) resistor r=0.4226 c=0
Rk89 (\31\:VSS \32\:VSS) resistor r=0.06412 c=0
Rk90 (\24\:VSS \34\:VSS) resistor r=0.2598 c=0
Rk91 (\26\:VSS \36\:VSS) resistor r=0.1887 c=0
Rk92 (\27\:VSS \38\:VSS) resistor r=0.1938 c=0
Rk93 (\28\:VSS \40\:VSS) resistor r=0.2353 c=0
Rk94 (\30\:VSS \42\:VSS) resistor r=0.2358 c=0
Rk95 (\31\:VSS \44\:VSS) resistor r=0.2277 c=0
Rk1 (\12\:CKbb \13\:CKbb) resistor r=0.6826 c=0
Rk8 (\15\:CKbb \16\:CKbb) resistor r=0.3389 c=0
Rk9 (\16\:CKbb \17\:CKbb) resistor r=0.0151 c=0
Rk10 (\16\:CKbb \19\:CKbb) resistor r=0.2128 c=0
Rk51 (\20\:CKbb \21\:CKbb) resistor r=0.7171 c=0
Rk18 (\6\:mout \7\:mout) resistor r=0.4253 c=0
Rk19 (\7\:mout \8\:mout) resistor r=0.3621 c=0
Rk20 (\8\:mout \9\:mout) resistor r=0.1413 c=0
Rk21 (\9\:mout \10\:mout) resistor r=0.1929 c=0
Rk22 (\7\:mout \11\:mout) resistor r=0.1185 c=0
Rk23 (\11\:mout \12\:mout) resistor r=0.2157 c=0
Rk24 (\8\:mout \14\:mout) resistor r=0.3227 c=0
Rk25 (\9\:mout \16\:mout) resistor r=0.1036 c=0
Rk26 (\11\:mout \18\:mout) resistor r=0.1202 c=0
Rk14 (\14\:CKb \15\:CKb) resistor r=0.3397 c=0
Rk15 (\15\:CKb \16\:CKb) resistor r=0.1628 c=0
Rk16 (\15\:CKb \18\:CKb) resistor r=0.2061 c=0
Rk31 (\19\:CKb \20\:CKb) resistor r=0.2958 c=0
Rk3 (\8\:n20 \9\:n20) resistor r=0.2062 c=0
Rk4 (\8\:n20 \10\:n20) resistor r=0.2091 c=0
Rk5 (\10\:n20 \12\:n20) resistor r=0.4399 c=0
Rk6 (\14\:n20 \16\:n20) resistor r=0.4876 c=0
Rk7 (\16\:n20 \17\:n20) resistor r=0.1574 c=0
Rk27 (\9\:RNb \10\:RNb) resistor r=0.3424 c=0
Rk28 (\10\:RNb \12\:RNb) resistor r=0.1478 c=0
Rk32 (\7\:n35g \8\:n35g) resistor r=0.2401 c=0
Rk33 (\7\:n35g \10\:n35g) resistor r=0.6898 c=0
Rk44 (\12\:n35g \13\:n35g) resistor r=0.2424 c=0
Rk45 (\13\:n35g \14\:n35g) resistor r=0.5641 c=0
Rk46 (\13\:n35g \16\:n35g) resistor r=0.4309 c=0
Rk41 (\12\:qbint \13\:qbint) resistor r=0.4933 c=0
Rk42 (\13\:qbint \15\:qbint) resistor r=0.5658 c=0
Rk43 (\13\:qbint \17\:qbint) resistor r=0.1459 c=0
Rk52 (\18\:qbint \19\:qbint) resistor r=0.2113 c=0
Rk47 (\5\:RTb \7\:RTb) resistor r=0.2157 c=0
Rk48 (\7\:RTb \8\:RTb) resistor r=0.5203 c=0
Rk49 (\8\:RTb \9\:RTb) resistor r=0.3878 c=0
Rk50 (\8\:RTb \11\:RTb) resistor r=0.2011 c=0
Rk29 (\5\:n35 \6\:n35) resistor r=0.3193 c=0
Rk30 (\6\:n35 \8\:n35) resistor r=0.4233 c=0
Rk34 (\10\:n35 \11\:n35) resistor r=0.3178 c=0
Rk35 (\11\:n35 \13\:n35) resistor r=0.3869 c=0
Rk56 (\15\:n35 \16\:n35) resistor r=0.2315 c=0
Rk57 (\16\:n35 \18\:n35) resistor r=0.3583 c=0
Rk62 (\2\:net097 \4\:net097) resistor r=0.7055 c=0
Rk61 (\2\:n40 \4\:n40) resistor r=0.6241 c=0
Rl45 (\7\:RT \8\:RT) resistor r=650.933 c=0
Rl32 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl35 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl34 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl33 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl10 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl8 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl9 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl2 (\2\:D \3\:D) resistor r=43.4636 c=0
Rl1 (\1\:D \2\:D) resistor r=135.391 c=0
Rl16 (\2\:RN \4\:RN) resistor r=62.3411 c=0
Rl14 (\1\:RN \2\:RN) resistor r=152.726 c=0
Rl15 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl4 (CKbb \2\:CKbb) resistor r=172.517 c=0
Rl48 (\10\:CKbb \11\:CKbb) resistor r=159.438 c=0
Rl5 (\2\:CKbb \3\:CKbb) resistor r=349.426 c=0
Rl40 (\4\:CKbb \5\:CKbb) resistor r=66.1349 c=0
Rl43 (\5\:CKbb \8\:CKbb) resistor r=820.277 c=0
Rl44 (\6\:CKbb \9\:CKbb) resistor r=66.8717 c=0
Rl42 (\6\:CKbb \7\:CKbb) resistor r=132.647 c=0
Rl41 (\5\:CKbb \6\:CKbb) resistor r=339.792 c=0
Rl6 (mout \2\:mout) resistor r=24.2328 c=0
Rl7 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl25 (\9\:CKb \10\:CKb) resistor r=177.372 c=0
Rl49 (\11\:CKb \12\:CKb) resistor r=908.226 c=0
Rl17 (CKb \2\:CKb) resistor r=1.2334 c=0
Rl20 (\2\:CKb \5\:CKb) resistor r=60.4181 c=0
Rl23 (\3\:CKb \8\:CKb) resistor r=69.2058 c=0
Rl19 (\3\:CKb \4\:CKb) resistor r=236.258 c=0
Rl18 (\2\:CKb \3\:CKb) resistor r=75.7777 c=0
Rl24 (\6\:CKb \9\:CKb) resistor r=422.837 c=0
Rl21 (\5\:CKb \6\:CKb) resistor r=86.9066 c=0
Rl22 (\6\:CKb \7\:CKb) resistor r=236.429 c=0
Rl3 (n20 \2\:n20) resistor r=205.495 c=0
Rl11 (\3\:n20 \4\:n20) resistor r=154.568 c=0
Rl13 (\4\:n20 \6\:n20) resistor r=191.976 c=0
Rl12 (\4\:n20 \5\:n20) resistor r=128.737 c=0
Rl50 (RNb \2\:RNb) resistor r=234.8 c=0
Rl51 (\2\:RNb \3\:RNb) resistor r=1125.6 c=0
Rl54 (\3\:RNb \6\:RNb) resistor r=707.521 c=0
Rl53 (\4\:RNb \5\:RNb) resistor r=106.884 c=0
Rl55 (\4\:RNb \7\:RNb) resistor r=197.09 c=0
Rl52 (\3\:RNb \4\:RNb) resistor r=336.011 c=0
Rl28 (\3\:n35g \4\:n35g) resistor r=250.512 c=0
Rl26 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl27 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl29 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl56 (\6\:qbint \7\:qbint) resistor r=237.758 c=0
Rl60 (\10\:qbint \11\:qbint) resistor r=149.805 c=0
Rl39 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl36 (qbint \2\:qbint) resistor r=112.732 c=0
Rl38 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl37 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl57 (\7\:qbint \8\:qbint) resistor r=252.339 c=0
Rl59 (\8\:qbint \10\:qbint) resistor r=60.508 c=0
Rl58 (\8\:qbint \9\:qbint) resistor r=419.685 c=0
Rl30 (RTb \2\:RTb) resistor r=121.113 c=0
Rl31 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl46 (n35 \2\:n35) resistor r=508.667 c=0
Rl47 (\2\:n35 \3\:n35) resistor r=358.667 c=0
Rz31 (\8\:VDD \9\:VDD) resistor r=15 c=0
Rz32 (\8\:VDD \11\:VDD) resistor r=37.5 c=0
Rz16 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz19 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz20 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz21 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz22 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz23 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz24 (\33\:VSS \34\:VSS) resistor r=37.5 c=0
Rz25 (\35\:VSS \36\:VSS) resistor r=75 c=0
Rz26 (\37\:VSS \38\:VSS) resistor r=75 c=0
Rz27 (\39\:VSS \40\:VSS) resistor r=75 c=0
Rz28 (\41\:VSS \42\:VSS) resistor r=75 c=0
Rz29 (\43\:VSS \44\:VSS) resistor r=75 c=0
Rz3 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz5 (\13\:mout \14\:mout) resistor r=75 c=0
Rz6 (\15\:mout \16\:mout) resistor r=75 c=0
Rz4 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz1 (\11\:n20 \12\:n20) resistor r=75 c=0
Rz2 (\13\:n20 \14\:n20) resistor r=75 c=0
Rz7 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz9 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz13 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz12 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz14 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz8 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz10 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz15 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz17 (n40 \2\:n40) resistor r=75 c=0
Rz18 (\3\:n40 \4\:n40) resistor r=75 c=0
Ry11 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry12 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry30 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry31 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry32 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry33 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry34 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry35 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry36 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry18 (\4\:Q \5\:Q) resistor r=20.6667 c=0
Ry21 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry22 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry23 (\1\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry24 (\1\:VSS \8\:VSS) resistor r=5.6364 c=0
Ry25 (\1\:VSS \11\:VSS) resistor r=8.8571 c=0
Ry26 (\22\:VSS \23\:VSS) resistor r=20.6667 c=0
Ry27 (\22\:VSS \25\:VSS) resistor r=5.1667 c=0
Ry28 (\22\:VSS \29\:VSS) resistor r=5.1667 c=0
Ry29 (\22\:VSS \32\:VSS) resistor r=62 c=0
Ry3 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry5 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\17\:mout \18\:mout) resistor r=62 c=0
Ry4 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry1 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry2 (\15\:n20 \16\:n20) resistor r=62 c=0
Ry7 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry9 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry16 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry8 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry10 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry17 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry19 (net097 \2\:net097) resistor r=62 c=0
Ry20 (\3\:net097 \4\:net097) resistor r=62 c=0
Rx27 (\3\:RT \9\:RT) resistor r=45 c=0
Rx28 (\1\:RT \10\:RT) resistor r=45 c=0
Rx29 (\8\:RT \11\:RT) resistor r=45 c=0
Rx8 (\3\:CK \7\:CK) resistor r=45 c=0
Rx3 (\2\:D \4\:D) resistor r=45 c=0
Rx10 (\3\:RN \5\:RN) resistor r=45 c=0
Rx1 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx2 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx7 (CKbb \17\:CKbb) resistor r=45 c=0
Rx23 (\11\:CKbb \20\:CKbb) resistor r=45 c=0
Rx24 (\8\:CKbb \21\:CKbb) resistor r=45 c=0
Rx11 (\4\:mout \10\:mout) resistor r=45 c=0
Rx12 (\2\:mout \12\:mout) resistor r=45 c=0
Rx9 (CKb \16\:CKb) resistor r=45 c=0
Rx15 (\10\:CKb \19\:CKb) resistor r=45 c=0
Rx16 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx4 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \10\:n20) resistor r=45 c=0
Rx6 (n20 \17\:n20) resistor r=45 c=0
Rx13 (\6\:RNb \10\:RNb) resistor r=45 c=0
Rx17 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx20 (n35g \14\:n35g) resistor r=45 c=0
Rx19 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx25 (\9\:qbint \18\:qbint) resistor r=45 c=0
Rx26 (qbint \19\:qbint) resistor r=45 c=0
Rx21 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx22 (RTb \9\:RTb) resistor r=45 c=0
Rx14 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx18 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx30 (n35 \16\:n35) resistor r=45 c=0
mn25 (n21 \1\:D \43\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\13\:n20 \4\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\11\:n20 \9\:CKbb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (n30 \3\:mout \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\14\:CKbb \8\:CKb \41\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\15\:mout \6\:n20 \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \41\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn31 (\13\:mout \7\:RNb \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn22 (\8\:RNb \1\:RN \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\7\:n35 \4\:CKbb \13\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM3 (net0121 \5\:qbint \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\16\:qbint \5\:n35g \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \2\:RT \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \7\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb \3\:n40 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \11\:qbint \33\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn51 (n40 RNb \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n40 \6\:qbint \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp26 (\15\:n20 \2\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3011 \
        scb=0.0111155 scc=0.000221731 m=(1)
mp36 (\7\:n20 \7\:CKb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp35 (n31 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp21 (\18\:CKbb \5\:CKb \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp20 (\17\:CKb \4\:CK \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.52288 \
        scb=0.00778605 scc=0.000197359 m=(1)
mp32 (\17\:mout \3\:n20 net402 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.71023 \
        scb=0.00138809 scc=2.58214e-06 m=(1)
mp31 (net402 \5\:RNb \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.19408 \
        scb=0.00174819 scc=3.02997e-06 m=(1)
mp22 (\11\:RNb \4\:RN \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.8901 \
        scb=0.0121892 scc=0.000217629 m=(1)
mp40 (\4\:n35 \9\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=18.8142 \
        scb=0.0201994 scc=0.00140887 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
PM1 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \10\:CKbb \3\:net097 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.26 scb=0.0274419 \
        scc=0.00267566 m=(1)
mp55 (\4\:Q \10\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2692 \
        scb=0.0111076 scc=0.000317226 m=(1)
mp51 (n43 \2\:RNb \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=11.021 \
        scb=0.00760198 scc=5.42807e-05 m=(1)
mp52 (net097 \7\:qbint n43 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.9152 \
        scb=0.0114244 scc=0.000185803 m=(1)
ends RDFFRQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:48:37 2012 )
// Library name: gsclib045
// Cell name: RDFFRX1
// View name: extracted

simulator lang=spectre

subckt RDFFRX1 CK D ExtVDD Q QN RN RT VDD VSS
mp25 (n22 \3\:D \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (RT VSS) capacitor c=3.76701e-17
C2 (Q VSS) capacitor c=6.07673e-17
C3 (D VSS) capacitor c=5.46364e-17
C4 (QN VSS) capacitor c=2.47441e-17
C5 (RN VSS) capacitor c=4.38371e-17
C6 (VDD VSS) capacitor c=6.75033e-16
C7 (ExtVDD VSS) capacitor c=2.07242e-16
C8 (CKbb VSS) capacitor c=5.57462e-17
C9 (mout VSS) capacitor c=4.99619e-17
C10 (CKb VSS) capacitor c=2.35852e-17
C11 (n20 VSS) capacitor c=8.25819e-17
C12 (RNb VSS) capacitor c=5.59904e-17
C13 (n35g VSS) capacitor c=1.77616e-17
C14 (qbint VSS) capacitor c=4.54322e-17
C15 (RTb VSS) capacitor c=4.52686e-17
C16 (qint VSS) capacitor c=2.24057e-17
C17 (n35 VSS) capacitor c=1.81481e-16
C18 (net097 VSS) capacitor c=6.31181e-17
C19 (n40 VSS) capacitor c=7.4778e-17
C20 (\7\:qbint VSS) capacitor c=3.41927e-17
C21 (\11\:qbint VSS) capacitor c=1.20616e-16
C22 (\2\:RNb VSS) capacitor c=3.0368e-16
C23 (\13\:qbint VSS) capacitor c=4.58314e-17
C24 (\3\:qint VSS) capacitor c=6.09652e-17
C25 (\10\:CKbb VSS) capacitor c=7.12703e-17
C26 (\4\:RTb VSS) capacitor c=9.91427e-17
C27 (\6\:RT VSS) capacitor c=2.22202e-17
C28 (\4\:qbint VSS) capacitor c=5.36588e-17
C29 (\3\:n35g VSS) capacitor c=6.24243e-17
C30 (\5\:RT VSS) capacitor c=8.45437e-17
C31 (\9\:CKb VSS) capacitor c=1.01584e-16
C32 (\4\:RN VSS) capacitor c=3.22092e-17
C33 (\5\:RNb VSS) capacitor c=6.41482e-17
C34 (\3\:n20 VSS) capacitor c=7.34077e-17
C35 (\4\:CK VSS) capacitor c=5.63515e-17
C36 (\5\:CKb VSS) capacitor c=2.92537e-17
C37 (\7\:CKb VSS) capacitor c=8.91078e-17
C38 (\2\:CKbb VSS) capacitor c=1.54425e-16
C39 (\3\:D VSS) capacitor c=5.61805e-17
C40 (\6\:qbint VSS) capacitor c=3.6771e-17
C41 (\12\:qbint VSS) capacitor c=5.80863e-17
C42 (\14\:qbint VSS) capacitor c=4.68018e-17
C43 (\4\:qint VSS) capacitor c=3.83881e-17
C44 (\11\:CKb VSS) capacitor c=1.94344e-16
C45 (\8\:RT VSS) capacitor c=1.21376e-16
C46 (\2\:RT VSS) capacitor c=5.6984e-17
C47 (\5\:qbint VSS) capacitor c=3.89215e-17
C48 (\5\:n35g VSS) capacitor c=3.48888e-17
C49 (\2\:RTb VSS) capacitor c=4.91473e-17
C50 (\4\:CKbb VSS) capacitor c=3.23618e-17
C51 (\1\:RN VSS) capacitor c=3.41669e-17
C52 (\7\:RNb VSS) capacitor c=6.11841e-17
C53 (\1\:CK VSS) capacitor c=2.82836e-17
C54 (\6\:n20 VSS) capacitor c=6.24185e-17
C55 (\8\:CKb VSS) capacitor c=2.55255e-17
C56 (\3\:mout VSS) capacitor c=5.02446e-17
C57 (\9\:CKbb VSS) capacitor c=4.99683e-17
C58 (\4\:CKb VSS) capacitor c=8.45255e-17
C59 (\1\:D VSS) capacitor c=6.59513e-17
C60 (\10\:qbint VSS) capacitor c=8.52229e-17
C61 (\11\:CKbb VSS) capacitor c=7.29256e-17
C62 (\7\:RT VSS) capacitor c=1.52306e-16
C63 (\8\:CKbb VSS) capacitor c=1.43231e-16
C64 (\3\:RT VSS) capacitor c=5.77121e-17
C65 (\1\:RT VSS) capacitor c=4.85351e-17
C66 (\3\:RTb VSS) capacitor c=7.61077e-17
C67 (\3\:qbint VSS) capacitor c=4.43228e-17
C68 (\2\:n35 VSS) capacitor c=2.6322e-16
C69 (\4\:n35g VSS) capacitor c=7.15717e-17
C70 (\10\:CKb VSS) capacitor c=5.61043e-17
C71 (\12\:CKb VSS) capacitor c=2.28294e-16
C72 (\3\:n35 VSS) capacitor c=1.20797e-16
C73 (\6\:RNb VSS) capacitor c=7.96818e-17
C74 (\3\:RN VSS) capacitor c=5.01817e-17
C75 (\3\:CK VSS) capacitor c=2.36447e-17
C76 (\2\:mout VSS) capacitor c=3.99943e-17
C77 (\4\:mout VSS) capacitor c=3.90488e-17
C78 (\5\:n20 VSS) capacitor c=3.95559e-17
C79 (\2\:n20 VSS) capacitor c=7.16181e-17
C80 (\3\:CKbb VSS) capacitor c=8.28107e-17
C81 (\7\:CKbb VSS) capacitor c=3.16235e-17
C82 (\2\:D VSS) capacitor c=5.17205e-17
C83 (\1\:VDD VSS) capacitor c=4.94682e-17
C84 (\3\:Q VSS) capacitor c=7.43426e-17
C85 (\13\:VDD VSS) capacitor c=4.93356e-17
C86 (\9\:qint VSS) capacitor c=5.45123e-17
C87 (\15\:VDD VSS) capacitor c=7.92013e-17
C88 (\3\:net097 VSS) capacitor c=9.89292e-17
C89 (\4\:QN VSS) capacitor c=6.26049e-17
C90 (\14\:n35 VSS) capacitor c=4.5721e-17
C91 (\15\:n35g VSS) capacitor c=5.61339e-17
C92 (\6\:RTb VSS) capacitor c=8.35178e-17
C93 (\1\:ExtVDD VSS) capacitor c=2.81199e-16
C94 (\9\:n35 VSS) capacitor c=5.47196e-17
C95 (\17\:qbint VSS) capacitor c=6.92846e-17
C96 (\6\:n35g VSS) capacitor c=9.12984e-17
C97 (\4\:n35 VSS) capacitor c=5.53723e-17
C98 (\11\:RNb VSS) capacitor c=2.80375e-17
C99 (\5\:mout VSS) capacitor c=7.05526e-17
C100 (\17\:VDD VSS) capacitor c=5.55652e-17
C101 (\19\:VDD VSS) capacitor c=4.3987e-17
C102 (\17\:CKb VSS) capacitor c=4.55148e-17
C103 (\17\:mout VSS) capacitor c=3.50701e-17
C104 (\21\:VDD VSS) capacitor c=6.01272e-17
C105 (\23\:VDD VSS) capacitor c=4.62128e-17
C106 (\18\:CKbb VSS) capacitor c=4.02034e-17
C107 (\7\:n20 VSS) capacitor c=4.09378e-17
C108 (\15\:n20 VSS) capacitor c=6.73271e-17
C109 (\26\:VDD VSS) capacitor c=4.0655e-17
C110 (\1\:Q VSS) capacitor c=5.4717e-17
C111 (\5\:qint VSS) capacitor c=4.73705e-17
C112 (\3\:n40 VSS) capacitor c=7.89738e-17
C113 (\1\:QN VSS) capacitor c=4.00005e-17
C114 (\17\:n35 VSS) capacitor c=4.88666e-17
C115 (\11\:n35g VSS) capacitor c=2.98389e-17
C116 (\10\:RTb VSS) capacitor c=4.8316e-17
C117 (\12\:n35 VSS) capacitor c=6.15223e-17
C118 (\19\:qbint VSS) capacitor c=2.31844e-17
C119 (\9\:n35g VSS) capacitor c=7.73799e-17
C120 (\7\:n35 VSS) capacitor c=4.50666e-17
C121 (\8\:RNb VSS) capacitor c=3.95049e-17
C122 (\9\:VDD VSS) capacitor c=4.43919e-17
C123 (\13\:mout VSS) capacitor c=5.5039e-17
C124 (\13\:CKb VSS) capacitor c=6.04482e-17
C125 (\15\:mout VSS) capacitor c=3.61946e-17
C126 (\14\:CKbb VSS) capacitor c=5.1458e-17
C127 (\11\:n20 VSS) capacitor c=6.16014e-17
C128 (\13\:n20 VSS) capacitor c=5.66722e-17
C129 (\2\:CK VSS) capacitor c=3.43413e-17
C130 (\4\:n20 VSS) capacitor c=6.67307e-17
C131 (\2\:CKb VSS) capacitor c=2.75697e-17
C132 (\3\:CKb VSS) capacitor c=5.60977e-17
C133 (\6\:CKb VSS) capacitor c=9.31227e-17
C134 (\2\:n35g VSS) capacitor c=3.24287e-17
C135 (ExtVDD VSS) capacitor c=3.93674e-17
C136 (\4\:RT VSS) capacitor c=7.41198e-17
C137 (\2\:qbint VSS) capacitor c=4.10714e-17
C138 (\5\:CKbb VSS) capacitor c=1.24521e-16
C139 (\6\:CKbb VSS) capacitor c=6.28227e-17
C140 (\2\:qint VSS) capacitor c=1.61002e-17
C141 (\3\:RNb VSS) capacitor c=4.9517e-16
C142 (\4\:RNb VSS) capacitor c=1.13142e-16
C143 (\12\:CKbb VSS) capacitor c=6.33677e-17
C144 (\13\:CKbb VSS) capacitor c=7.4503e-17
C145 (\8\:qbint VSS) capacitor c=5.12411e-17
C146 (\9\:qbint VSS) capacitor c=7.80353e-17
C147 (\9\:n20 VSS) capacitor c=2.90055e-17
C148 (\10\:n20 VSS) capacitor c=4.99215e-17
C149 (\17\:n20 VSS) capacitor c=3.09082e-17
C150 (\17\:CKbb VSS) capacitor c=7.39193e-17
C151 (\5\:CK VSS) capacitor c=4.81487e-17
C152 (\6\:CK VSS) capacitor c=3.77438e-17
C153 (\15\:CKb VSS) capacitor c=6.85218e-17
C154 (\16\:CKb VSS) capacitor c=5.04878e-17
C155 (\5\:RN VSS) capacitor c=5.75238e-17
C156 (\7\:mout VSS) capacitor c=5.29314e-17
C157 (\8\:mout VSS) capacitor c=4.64134e-17
C158 (\9\:mout VSS) capacitor c=1.00981e-17
C159 (\10\:mout VSS) capacitor c=2.76676e-17
C160 (\11\:mout VSS) capacitor c=1.52135e-17
C161 (\12\:mout VSS) capacitor c=3.03697e-17
C162 (\10\:RNb VSS) capacitor c=6.71886e-17
C163 (\6\:n35 VSS) capacitor c=5.89566e-17
C164 (\19\:CKb VSS) capacitor c=3.24096e-17
C165 (\20\:CKb VSS) capacitor c=3.2244e-17
C166 (\8\:n35g VSS) capacitor c=3.24063e-17
C167 (\11\:n35 VSS) capacitor c=6.21139e-17
C168 (\15\:qbint VSS) capacitor c=8.81276e-17
C169 (\16\:qbint VSS) capacitor c=1.03491e-16
C170 (\13\:n35g VSS) capacitor c=1.0249e-16
C171 (\14\:n35g VSS) capacitor c=1.16302e-16
C172 (\5\:RTb VSS) capacitor c=4.9715e-17
C173 (\8\:RTb VSS) capacitor c=8.74147e-17
C174 (\9\:RTb VSS) capacitor c=5.09307e-17
C175 (\20\:CKbb VSS) capacitor c=9.88109e-17
C176 (\21\:CKbb VSS) capacitor c=9.41719e-17
C177 (\21\:qbint VSS) capacitor c=2.41296e-17
C178 (\22\:qbint VSS) capacitor c=3.01215e-17
C179 (\9\:RT VSS) capacitor c=1.06524e-16
C180 (\10\:RT VSS) capacitor c=1.18558e-16
C181 (\11\:RT VSS) capacitor c=5.63965e-17
C182 (\3\:QN VSS) capacitor c=3.52562e-17
C183 (\16\:n35 VSS) capacitor c=4.41949e-17
C184 (\7\:qint VSS) capacitor c=5.32634e-17
C185 (\8\:qint VSS) capacitor c=3.54281e-17
C186 (\3\:VDD VSS) capacitor c=5.10362e-17
C187 (\5\:VDD VSS) capacitor c=9.85367e-18
C188 (\6\:VDD VSS) capacitor c=2.44293e-16
C189 (\7\:VDD VSS) capacitor c=1.87789e-16
C190 (\8\:VDD VSS) capacitor c=5.51768e-18
C191 (\11\:VDD VSS) capacitor c=2.00314e-17
C192 (\25\:VDD VSS) capacitor c=2.80541e-17
Rk53 (RT \9\:RT) resistor r=0.1911 c=0
Rk54 (\9\:RT \10\:RT) resistor r=0.641 c=0
Rk55 (RT \11\:RT) resistor r=0.007893 c=0
Rk65 (\2\:Q Q) resistor r=0.1752 c=0
Rk66 (Q \4\:Q) resistor r=0.3061 c=0
Rk11 (CK \5\:CK) resistor r=0.004349 c=0
Rk13 (\5\:CK \6\:CK) resistor r=0.01405 c=0
Rk12 (\6\:CK \7\:CK) resistor r=0.004531 c=0
Rk2 (\4\:D D) resistor r=0.006093 c=0
Rk57 (\3\:QN QN) resistor r=0.01677 c=0
Rk56 (\2\:QN \3\:QN) resistor r=0.2891 c=0
Rk58 (\3\:QN \5\:QN) resistor r=0.3264 c=0
Rk17 (RN \5\:RN) resistor r=0.02543 c=0
Rk86 (\2\:VDD \3\:VDD) resistor r=0.5756 c=0
Rk87 (\3\:VDD \5\:VDD) resistor r=0.0667 c=0
Rk88 (\5\:VDD \6\:VDD) resistor r=0.05184 c=0
Rk89 (\6\:VDD \7\:VDD) resistor r=1.6299 c=0
Rk90 (\7\:VDD \8\:VDD) resistor r=0.02934 c=0
Rk91 (\8\:VDD \10\:VDD) resistor r=0.04193 c=0
Rk92 (\10\:VDD \11\:VDD) resistor r=0.1485 c=0
Rk100 (\12\:VDD VDD) resistor r=0.2184 c=0
Rk93 (\11\:VDD \12\:VDD) resistor r=0.05927 c=0
Rk94 (\3\:VDD \14\:VDD) resistor r=0.2925 c=0
Rk95 (\6\:VDD \16\:VDD) resistor r=0.3607 c=0
Rk96 (\7\:VDD \18\:VDD) resistor r=0.3587 c=0
Rk97 (\8\:VDD \20\:VDD) resistor r=0.2013 c=0
Rk98 (\11\:VDD \22\:VDD) resistor r=0.3794 c=0
Rk99 (\12\:VDD \24\:VDD) resistor r=0.2467 c=0
Rk101 (VDD \25\:VDD) resistor r=0.1462 c=0
Rk102 (\25\:VDD VDD) resistor r=0.08875 c=0
Rk103 (\25\:VDD \27\:VDD) resistor r=0.3582 c=0
Rk38 (ExtVDD ExtVDD) resistor r=0.00206 c=0
Rk36 (\2\:ExtVDD ExtVDD) resistor r=0.02213 c=0
Rk39 (ExtVDD \5\:ExtVDD) resistor r=0.02012 c=0
Rk40 (ExtVDD \6\:ExtVDD) resistor r=0.1055 c=0
Rk68 (\2\:VSS \4\:VSS) resistor r=0.361 c=0
Rk69 (\4\:VSS \5\:VSS) resistor r=0.2377 c=0
Rk70 (\5\:VSS \6\:VSS) resistor r=0.5548 c=0
Rk71 (\6\:VSS \7\:VSS) resistor r=0.1163 c=0
Rk73 (\8\:VSS VSS) resistor r=0.07141 c=0
Rk72 (\7\:VSS \8\:VSS) resistor r=0.2077 c=0
Rk74 (VSS \9\:VSS) resistor r=0.6789 c=0
Rk76 (\10\:VSS VSS) resistor r=0.1187 c=0
Rk75 (\9\:VSS \10\:VSS) resistor r=0.06422 c=0
Rk77 (VSS \11\:VSS) resistor r=0.03722 c=0
Rk78 (\11\:VSS \12\:VSS) resistor r=0.4233 c=0
Rk79 (\12\:VSS \13\:VSS) resistor r=0.06422 c=0
Rk80 (\5\:VSS \15\:VSS) resistor r=0.2632 c=0
Rk81 (\7\:VSS \17\:VSS) resistor r=0.189 c=0
Rk82 (\8\:VSS \19\:VSS) resistor r=0.194 c=0
Rk83 (\9\:VSS \21\:VSS) resistor r=0.2356 c=0
Rk84 (\11\:VSS \23\:VSS) resistor r=0.2362 c=0
Rk85 (\12\:VSS \25\:VSS) resistor r=0.228 c=0
Rk104 (\27\:VSS \28\:VSS) resistor r=0.08405 c=0
Rk105 (\28\:VSS \29\:VSS) resistor r=0.1138 c=0
Rk106 (\29\:VSS \30\:VSS) resistor r=0.089 c=0
Rk107 (\30\:VSS \31\:VSS) resistor r=0.3566 c=0
Rk109 (\32\:VSS VSS) resistor r=0.3266 c=0
Rk108 (\31\:VSS \32\:VSS) resistor r=0.3667 c=0
Rk110 (VSS \33\:VSS) resistor r=0.1985 c=0
Rk112 (\34\:VSS VSS) resistor r=0.2077 c=0
Rk111 (\33\:VSS \34\:VSS) resistor r=0.5573 c=0
Rk113 (VSS \35\:VSS) resistor r=0.0174 c=0
Rk114 (\35\:VSS \36\:VSS) resistor r=0.1088 c=0
Rk115 (\28\:VSS \38\:VSS) resistor r=0.2396 c=0
Rk116 (\30\:VSS \40\:VSS) resistor r=0.2459 c=0
Rk117 (\32\:VSS \42\:VSS) resistor r=0.2432 c=0
Rk118 (\34\:VSS \44\:VSS) resistor r=0.2396 c=0
Rk119 (\35\:VSS \46\:VSS) resistor r=0.2396 c=0
Rk1 (\12\:CKbb \13\:CKbb) resistor r=0.6835 c=0
Rk8 (\15\:CKbb \16\:CKbb) resistor r=0.3491 c=0
Rk9 (\16\:CKbb \17\:CKbb) resistor r=0.01512 c=0
Rk10 (\16\:CKbb \19\:CKbb) resistor r=0.2033 c=0
Rk51 (\20\:CKbb \21\:CKbb) resistor r=0.7181 c=0
Rk18 (\6\:mout \7\:mout) resistor r=0.4259 c=0
Rk19 (\7\:mout \8\:mout) resistor r=0.3627 c=0
Rk20 (\8\:mout \9\:mout) resistor r=0.1415 c=0
Rk21 (\9\:mout \10\:mout) resistor r=0.1932 c=0
Rk22 (\7\:mout \11\:mout) resistor r=0.1187 c=0
Rk23 (\11\:mout \12\:mout) resistor r=0.216 c=0
Rk24 (\8\:mout \14\:mout) resistor r=0.3231 c=0
Rk25 (\9\:mout \16\:mout) resistor r=0.1038 c=0
Rk26 (\11\:mout \18\:mout) resistor r=0.1204 c=0
Rk14 (\14\:CKb \15\:CKb) resistor r=0.3416 c=0
Rk15 (\15\:CKb \16\:CKb) resistor r=0.1631 c=0
Rk16 (\15\:CKb \18\:CKb) resistor r=0.2097 c=0
Rk31 (\19\:CKb \20\:CKb) resistor r=0.2962 c=0
Rk3 (\8\:n20 \9\:n20) resistor r=0.2065 c=0
Rk4 (\8\:n20 \10\:n20) resistor r=0.2094 c=0
Rk5 (\10\:n20 \12\:n20) resistor r=0.4405 c=0
Rk6 (\14\:n20 \16\:n20) resistor r=0.4882 c=0
Rk7 (\16\:n20 \17\:n20) resistor r=0.1576 c=0
Rk27 (\9\:RNb \10\:RNb) resistor r=0.3429 c=0
Rk28 (\10\:RNb \12\:RNb) resistor r=0.1481 c=0
Rk32 (\7\:n35g \8\:n35g) resistor r=0.2405 c=0
Rk33 (\7\:n35g \10\:n35g) resistor r=0.6908 c=0
Rk44 (\12\:n35g \13\:n35g) resistor r=0.2427 c=0
Rk45 (\13\:n35g \14\:n35g) resistor r=0.5649 c=0
Rk46 (\13\:n35g \16\:n35g) resistor r=0.4315 c=0
Rk41 (\15\:qbint \16\:qbint) resistor r=0.494 c=0
Rk42 (\16\:qbint \18\:qbint) resistor r=0.5666 c=0
Rk43 (\16\:qbint \20\:qbint) resistor r=0.1462 c=0
Rk52 (\21\:qbint \22\:qbint) resistor r=0.2116 c=0
Rk47 (\5\:RTb \7\:RTb) resistor r=0.216 c=0
Rk48 (\7\:RTb \8\:RTb) resistor r=0.521 c=0
Rk49 (\8\:RTb \9\:RTb) resistor r=0.3884 c=0
Rk50 (\8\:RTb \11\:RTb) resistor r=0.2014 c=0
Rk61 (\6\:qint \7\:qint) resistor r=0.2574 c=0
Rk62 (\7\:qint \8\:qint) resistor r=0.1613 c=0
Rk63 (\7\:qint \10\:qint) resistor r=0.2859 c=0
Rk29 (\5\:n35 \6\:n35) resistor r=0.3197 c=0
Rk30 (\6\:n35 \8\:n35) resistor r=0.4238 c=0
Rk34 (\10\:n35 \11\:n35) resistor r=0.3183 c=0
Rk35 (\11\:n35 \13\:n35) resistor r=0.3874 c=0
Rk59 (\15\:n35 \16\:n35) resistor r=0.2318 c=0
Rk60 (\16\:n35 \18\:n35) resistor r=0.3588 c=0
Rk67 (\2\:net097 \4\:net097) resistor r=0.7065 c=0
Rk64 (\2\:n40 \4\:n40) resistor r=0.625 c=0
Rl45 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl32 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl35 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl34 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl33 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl10 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl8 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl9 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl2 (\2\:D \3\:D) resistor r=43.4636 c=0
Rl1 (\1\:D \2\:D) resistor r=135.391 c=0
Rl16 (\2\:RN \4\:RN) resistor r=62.3411 c=0
Rl14 (\1\:RN \2\:RN) resistor r=152.726 c=0
Rl15 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl4 (CKbb \2\:CKbb) resistor r=167.403 c=0
Rl48 (\10\:CKbb \11\:CKbb) resistor r=159.438 c=0
Rl5 (\2\:CKbb \3\:CKbb) resistor r=349.426 c=0
Rl40 (\4\:CKbb \5\:CKbb) resistor r=66.1349 c=0
Rl43 (\5\:CKbb \8\:CKbb) resistor r=820.277 c=0
Rl44 (\6\:CKbb \9\:CKbb) resistor r=66.8717 c=0
Rl42 (\6\:CKbb \7\:CKbb) resistor r=132.647 c=0
Rl41 (\5\:CKbb \6\:CKbb) resistor r=339.792 c=0
Rl6 (mout \2\:mout) resistor r=24.2328 c=0
Rl7 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl25 (\9\:CKb \10\:CKb) resistor r=177.372 c=0
Rl49 (\11\:CKb \12\:CKb) resistor r=908.226 c=0
Rl17 (CKb \2\:CKb) resistor r=1.2334 c=0
Rl20 (\2\:CKb \5\:CKb) resistor r=60.4181 c=0
Rl23 (\3\:CKb \8\:CKb) resistor r=69.2058 c=0
Rl19 (\3\:CKb \4\:CKb) resistor r=236.258 c=0
Rl18 (\2\:CKb \3\:CKb) resistor r=75.7777 c=0
Rl24 (\6\:CKb \9\:CKb) resistor r=424.541 c=0
Rl21 (\5\:CKb \6\:CKb) resistor r=86.9066 c=0
Rl22 (\6\:CKb \7\:CKb) resistor r=234.725 c=0
Rl3 (n20 \2\:n20) resistor r=205.495 c=0
Rl11 (\3\:n20 \4\:n20) resistor r=154.568 c=0
Rl13 (\4\:n20 \6\:n20) resistor r=191.976 c=0
Rl12 (\4\:n20 \5\:n20) resistor r=128.737 c=0
Rl53 (RNb \2\:RNb) resistor r=234.8 c=0
Rl54 (\2\:RNb \3\:RNb) resistor r=1125.6 c=0
Rl57 (\3\:RNb \6\:RNb) resistor r=707.521 c=0
Rl56 (\4\:RNb \5\:RNb) resistor r=106.884 c=0
Rl58 (\4\:RNb \7\:RNb) resistor r=197.09 c=0
Rl55 (\3\:RNb \4\:RNb) resistor r=336.011 c=0
Rl28 (\3\:n35g \4\:n35g) resistor r=250.512 c=0
Rl26 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl27 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl29 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl59 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl64 (\11\:qbint \12\:qbint) resistor r=237.758 c=0
Rl66 (\13\:qbint \14\:qbint) resistor r=199.892 c=0
Rl39 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl36 (qbint \2\:qbint) resistor r=112.732 c=0
Rl38 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl37 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl60 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl63 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl65 (\9\:qbint \13\:qbint) resistor r=88.6112 c=0
Rl62 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl61 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl30 (RTb \2\:RTb) resistor r=121.113 c=0
Rl31 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl50 (qint \2\:qint) resistor r=3.1216 c=0
Rl51 (\2\:qint \3\:qint) resistor r=64.1263 c=0
Rl52 (\2\:qint \4\:qint) resistor r=77.1508 c=0
Rl46 (n35 \2\:n35) resistor r=508.667 c=0
Rl47 (\2\:n35 \3\:n35) resistor r=358.667 c=0
Rz20 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz15 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz29 (\9\:VDD \10\:VDD) resistor r=15 c=0
Rz30 (\9\:VDD \12\:VDD) resistor r=37.5 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz22 (\14\:VSS \15\:VSS) resistor r=37.5 c=0
Rz23 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz24 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz25 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz26 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz27 (\24\:VSS \25\:VSS) resistor r=75 c=0
Rz31 (\37\:VSS \38\:VSS) resistor r=75 c=0
Rz32 (\39\:VSS \40\:VSS) resistor r=75 c=0
Rz33 (\41\:VSS \42\:VSS) resistor r=75 c=0
Rz34 (\43\:VSS \44\:VSS) resistor r=75 c=0
Rz35 (\45\:VSS \46\:VSS) resistor r=75 c=0
Rz3 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz5 (\13\:mout \14\:mout) resistor r=75 c=0
Rz6 (\15\:mout \16\:mout) resistor r=75 c=0
Rz4 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz1 (\11\:n20 \12\:n20) resistor r=75 c=0
Rz2 (\13\:n20 \14\:n20) resistor r=75 c=0
Rz7 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz9 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz13 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz12 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz14 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz17 (\5\:qint \6\:qint) resistor r=75 c=0
Rz8 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz10 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz16 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz18 (n40 \2\:n40) resistor r=75 c=0
Rz19 (\3\:n40 \4\:n40) resistor r=75 c=0
Ry20 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry17 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry27 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry28 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry29 (\15\:VDD \16\:VDD) resistor r=20.6667 c=0
Ry30 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry31 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry32 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry33 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry34 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry11 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry12 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry23 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry24 (\3\:VSS \6\:VSS) resistor r=5.6364 c=0
Ry25 (\3\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry26 (\3\:VSS \13\:VSS) resistor r=62 c=0
Ry35 (\26\:VSS \27\:VSS) resistor r=31 c=0
Ry36 (\26\:VSS \29\:VSS) resistor r=31 c=0
Ry37 (\26\:VSS \31\:VSS) resistor r=8.8571 c=0
Ry38 (\26\:VSS \33\:VSS) resistor r=5.6364 c=0
Ry39 (\26\:VSS \36\:VSS) resistor r=8.8571 c=0
Ry3 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry5 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\17\:mout \18\:mout) resistor r=62 c=0
Ry4 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry1 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry2 (\15\:n20 \16\:n20) resistor r=62 c=0
Ry7 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry9 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry16 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry19 (\9\:qint \10\:qint) resistor r=62 c=0
Ry8 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry10 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry18 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry21 (net097 \2\:net097) resistor r=62 c=0
Ry22 (\3\:net097 \4\:net097) resistor r=62 c=0
Rx27 (\3\:RT \9\:RT) resistor r=45 c=0
Rx28 (\1\:RT \10\:RT) resistor r=45 c=0
Rx29 (\7\:RT \11\:RT) resistor r=45 c=0
Rx8 (\3\:CK \7\:CK) resistor r=45 c=0
Rx3 (\2\:D \4\:D) resistor r=45 c=0
Rx10 (\3\:RN \5\:RN) resistor r=45 c=0
Rx1 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx2 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx7 (CKbb \17\:CKbb) resistor r=45 c=0
Rx23 (\11\:CKbb \20\:CKbb) resistor r=45 c=0
Rx24 (\8\:CKbb \21\:CKbb) resistor r=45 c=0
Rx11 (\4\:mout \10\:mout) resistor r=45 c=0
Rx12 (\2\:mout \12\:mout) resistor r=45 c=0
Rx9 (CKb \16\:CKb) resistor r=45 c=0
Rx15 (\10\:CKb \19\:CKb) resistor r=45 c=0
Rx16 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx4 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \10\:n20) resistor r=45 c=0
Rx6 (n20 \17\:n20) resistor r=45 c=0
Rx13 (\6\:RNb \10\:RNb) resistor r=45 c=0
Rx17 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx20 (n35g \14\:n35g) resistor r=45 c=0
Rx19 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx25 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx26 (qbint \22\:qbint) resistor r=45 c=0
Rx21 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx22 (RTb \9\:RTb) resistor r=45 c=0
Rx31 (qint \8\:qint) resistor r=45 c=0
Rx14 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx18 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx30 (n35 \16\:n35) resistor r=45 c=0
mn25 (n21 \1\:D \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\13\:n20 \4\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\11\:n20 \9\:CKbb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (n30 \3\:mout \45\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\14\:CKbb \8\:CKb \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\15\:mout \6\:n20 \45\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn31 (\13\:mout \7\:RNb \43\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn22 (\8\:RNb \1\:RN \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\7\:n35 \4\:CKbb \13\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM3 (net0121 \5\:qbint \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM1 (\19\:qbint \5\:n35g \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \2\:RT \41\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb \3\:n40 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:qint \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.71058e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn56 (\5\:qint \14\:qbint \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn51 (n40 RNb \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n40 \12\:qbint \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp26 (\15\:n20 \2\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3011 \
        scb=0.0111155 scc=0.000221731 m=(1)
mp36 (\7\:n20 \7\:CKb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp35 (n31 mout \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp21 (\18\:CKbb \5\:CKb \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp20 (\17\:CKb \4\:CK \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.52288 \
        scb=0.00778605 scc=0.000197359 m=(1)
mp32 (\17\:mout \3\:n20 net402 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.71023 \
        scb=0.00138809 scc=2.58214e-06 m=(1)
mp31 (net402 \5\:RNb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.19408 \
        scb=0.00174819 scc=3.02997e-06 m=(1)
mp22 (\11\:RNb \4\:RN \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.8901 \
        scb=0.0121892 scc=0.000217629 m=(1)
mp40 (\4\:n35 \9\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=18.8142 \
        scb=0.0201994 scc=0.00140887 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
PM1 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \10\:CKbb \3\:net097 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:qint \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=28.6983 \
        scb=0.0316799 scc=0.00295254 m=(1)
mp56 (\9\:qint \13\:qbint \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.3875 \
        scb=0.0109499 scc=0.000167564 m=(1)
mp51 (n43 \2\:RNb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (net097 \11\:qbint n43 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends RDFFRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:50:43 2012 )
// Library name: gsclib045
// Cell name: RDFFSQX1
// View name: extracted

simulator lang=spectre

subckt RDFFSQX1 CK D ExtVDD Q RT SN VDD VSS
mp25 (n22 \3\:D \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (ExtVDD VSS) capacitor c=1.96954e-16
C2 (VDD VSS) capacitor c=5.95667e-16
C3 (Q VSS) capacitor c=1.81255e-17
C4 (SN VSS) capacitor c=8.50601e-17
C5 (D VSS) capacitor c=5.49767e-17
C6 (RT VSS) capacitor c=3.80641e-17
C7 (CKbb VSS) capacitor c=5.56607e-17
C8 (mout VSS) capacitor c=5.78803e-17
C9 (n20 VSS) capacitor c=9.51161e-17
C10 (CKb VSS) capacitor c=2.28528e-17
C11 (n35g VSS) capacitor c=1.7772e-17
C12 (qbint VSS) capacitor c=4.60466e-17
C13 (RTb VSS) capacitor c=5.17974e-17
C14 (n35 VSS) capacitor c=1.71283e-16
C15 (n41 VSS) capacitor c=8.52477e-17
C16 (net095 VSS) capacitor c=3.65082e-17
C17 (\7\:SN VSS) capacitor c=6.8242e-17
C18 (\7\:qbint VSS) capacitor c=3.73134e-17
C19 (\10\:qbint VSS) capacitor c=7.50039e-17
C20 (\10\:CKbb VSS) capacitor c=4.46527e-17
C21 (\4\:RTb VSS) capacitor c=9.81917e-17
C22 (\6\:RT VSS) capacitor c=2.22357e-17
C23 (\4\:qbint VSS) capacitor c=5.35387e-17
C24 (\3\:n35g VSS) capacitor c=5.78469e-17
C25 (\5\:RT VSS) capacitor c=6.34845e-17
C26 (\9\:CKb VSS) capacitor c=1.07528e-16
C27 (\3\:n20 VSS) capacitor c=3.33207e-17
C28 (\4\:CK VSS) capacitor c=4.95315e-17
C29 (\5\:CKb VSS) capacitor c=4.97213e-17
C30 (\1\:SN VSS) capacitor c=3.80128e-17
C31 (\7\:CKb VSS) capacitor c=7.5352e-17
C32 (\2\:CKbb VSS) capacitor c=1.716e-16
C33 (\3\:D VSS) capacitor c=5.64516e-17
C34 (\8\:SN VSS) capacitor c=1.32006e-16
C35 (\6\:qbint VSS) capacitor c=4.17418e-17
C36 (\11\:qbint VSS) capacitor c=1.03142e-16
C37 (\11\:CKb VSS) capacitor c=2.22205e-16
C38 (\8\:RT VSS) capacitor c=1.20494e-16
C39 (\2\:RT VSS) capacitor c=6.21391e-17
C40 (\5\:qbint VSS) capacitor c=3.87553e-17
C41 (\5\:n35g VSS) capacitor c=2.76764e-17
C42 (\2\:RTb VSS) capacitor c=4.64723e-17
C43 (\4\:CKbb VSS) capacitor c=2.68763e-17
C44 (\1\:CK VSS) capacitor c=2.9896e-17
C45 (\6\:n20 VSS) capacitor c=6.25702e-17
C46 (\6\:SN VSS) capacitor c=6.49368e-17
C47 (\8\:CKb VSS) capacitor c=2.55841e-17
C48 (\3\:mout VSS) capacitor c=4.54723e-17
C49 (\9\:CKbb VSS) capacitor c=5.02123e-17
C50 (\4\:CKb VSS) capacitor c=8.45511e-17
C51 (\1\:D VSS) capacitor c=6.59928e-17
C52 (\9\:qbint VSS) capacitor c=8.58079e-17
C53 (\11\:CKbb VSS) capacitor c=5.14542e-17
C54 (\3\:SN VSS) capacitor c=2.91419e-16
C55 (\9\:SN VSS) capacitor c=8.30134e-17
C56 (\7\:RT VSS) capacitor c=1.46609e-16
C57 (\8\:CKbb VSS) capacitor c=1.77358e-16
C58 (\3\:RT VSS) capacitor c=3.93703e-17
C59 (\1\:RT VSS) capacitor c=5.26113e-17
C60 (\3\:RTb VSS) capacitor c=7.60688e-17
C61 (\3\:qbint VSS) capacitor c=4.39473e-17
C62 (\2\:n35 VSS) capacitor c=2.61705e-16
C63 (\4\:n35g VSS) capacitor c=4.92289e-17
C64 (\10\:CKb VSS) capacitor c=5.81809e-17
C65 (\12\:CKb VSS) capacitor c=2.18386e-16
C66 (\3\:n35 VSS) capacitor c=1.21668e-16
C67 (\4\:n20 VSS) capacitor c=1.01761e-16
C68 (\7\:n20 VSS) capacitor c=5.45979e-17
C69 (\3\:CK VSS) capacitor c=2.37914e-17
C70 (\2\:SN VSS) capacitor c=4.35746e-17
C71 (\5\:SN VSS) capacitor c=2.90285e-17
C72 (\2\:mout VSS) capacitor c=4.86373e-17
C73 (\4\:mout VSS) capacitor c=3.16028e-17
C74 (\5\:n20 VSS) capacitor c=8.55846e-17
C75 (\2\:n20 VSS) capacitor c=6.50319e-17
C76 (\2\:D VSS) capacitor c=5.14036e-17
C77 (\3\:CKbb VSS) capacitor c=7.94552e-17
C78 (\7\:CKbb VSS) capacitor c=3.11267e-17
C79 (\1\:VDD VSS) capacitor c=2.92534e-17
C80 (\12\:VDD VSS) capacitor c=5.00752e-17
C81 (\4\:Q VSS) capacitor c=5.48076e-17
C82 (\14\:VDD VSS) capacitor c=5.32698e-17
C83 (\3\:n41 VSS) capacitor c=8.37796e-17
C84 (\14\:n35 VSS) capacitor c=5.44253e-17
C85 (\15\:n35g VSS) capacitor c=5.70424e-17
C86 (\6\:RTb VSS) capacitor c=7.29059e-17
C87 (\1\:ExtVDD VSS) capacitor c=2.77162e-16
C88 (\9\:n35 VSS) capacitor c=6.26057e-17
C89 (\14\:qbint VSS) capacitor c=6.63638e-17
C90 (\6\:n35g VSS) capacitor c=8.97533e-17
C91 (\4\:n35 VSS) capacitor c=4.99306e-17
C92 (\5\:mout VSS) capacitor c=7.98565e-17
C93 (\10\:VDD VSS) capacitor c=4.71057e-17
C94 (\17\:CKb VSS) capacitor c=2.94694e-17
C95 (\19\:mout VSS) capacitor c=4.31004e-17
C96 (\20\:VDD VSS) capacitor c=6.18907e-17
C97 (\16\:mout VSS) capacitor c=4.27792e-17
C98 (\18\:CKbb VSS) capacitor c=4.05271e-17
C99 (\18\:VDD VSS) capacitor c=5.40371e-17
C100 (\16\:n20 VSS) capacitor c=6.60316e-17
C101 (\8\:n20 VSS) capacitor c=2.51129e-17
C102 (\23\:VDD VSS) capacitor c=4.02576e-17
C103 (\1\:Q VSS) capacitor c=3.78982e-17
C104 (\3\:net095 VSS) capacitor c=4.62418e-17
C105 (\17\:n35 VSS) capacitor c=4.96299e-17
C106 (\11\:n35g VSS) capacitor c=2.63285e-17
C107 (\10\:RTb VSS) capacitor c=5.837e-17
C108 (\12\:n35 VSS) capacitor c=6.3732e-17
C109 (\16\:qbint VSS) capacitor c=2.28194e-17
C110 (\9\:n35g VSS) capacitor c=8.0367e-17
C111 (\7\:n35 VSS) capacitor c=4.06373e-17
C112 (\7\:VDD VSS) capacitor c=2.01914e-16
C113 (\11\:mout VSS) capacitor c=2.19046e-17
C114 (\13\:CKb VSS) capacitor c=4.66974e-17
C115 (\13\:mout VSS) capacitor c=1.72408e-17
C116 (\14\:CKbb VSS) capacitor c=5.21518e-17
C117 (\14\:n20 VSS) capacitor c=5.66979e-17
C118 (\12\:n20 VSS) capacitor c=5.95317e-17
C119 (VDD VSS) capacitor c=6.81622e-18
C120 (\2\:CK VSS) capacitor c=3.39162e-17
C121 (\2\:CKb VSS) capacitor c=2.78494e-17
C122 (\3\:CKb VSS) capacitor c=5.63807e-17
C123 (\6\:CKb VSS) capacitor c=1.29522e-16
C124 (\2\:n35g VSS) capacitor c=3.38232e-17
C125 (ExtVDD VSS) capacitor c=3.9408e-17
C126 (\4\:RT VSS) capacitor c=4.60848e-17
C127 (\2\:qbint VSS) capacitor c=4.11548e-17
C128 (\5\:CKbb VSS) capacitor c=1.15856e-16
C129 (\6\:CKbb VSS) capacitor c=8.1756e-17
C130 (\4\:SN VSS) capacitor c=3.1333e-16
C131 (\12\:CKbb VSS) capacitor c=5.31729e-17
C132 (\13\:CKbb VSS) capacitor c=6.96531e-17
C133 (\8\:qbint VSS) capacitor c=9.27583e-17
C134 (\10\:n20 VSS) capacitor c=4.04663e-17
C135 (\11\:n20 VSS) capacitor c=6.27258e-17
C136 (\18\:n20 VSS) capacitor c=3.50096e-17
C137 (\17\:CKbb VSS) capacitor c=7.4896e-17
C138 (\10\:SN VSS) capacitor c=3.98757e-17
C139 (\11\:SN VSS) capacitor c=4.92716e-17
C140 (\5\:CK VSS) capacitor c=4.93139e-17
C141 (\6\:CK VSS) capacitor c=3.86049e-17
C142 (\15\:CKb VSS) capacitor c=4.83307e-17
C143 (\16\:CKb VSS) capacitor c=5.20097e-17
C144 (\19\:n20 VSS) capacitor c=5.20272e-17
C145 (\20\:n20 VSS) capacitor c=6.02032e-17
C146 (\7\:mout VSS) capacitor c=7.29124e-17
C147 (\8\:mout VSS) capacitor c=3.59705e-17
C148 (\9\:mout VSS) capacitor c=6.70307e-17
C149 (\10\:mout VSS) capacitor c=7.77792e-17
C150 (\15\:mout VSS) capacitor c=6.02359e-17
C151 (\18\:mout VSS) capacitor c=6.53869e-17
C152 (\6\:n35 VSS) capacitor c=6.5573e-17
C153 (\19\:CKb VSS) capacitor c=2.97131e-17
C154 (\20\:CKb VSS) capacitor c=3.26625e-17
C155 (\8\:n35g VSS) capacitor c=2.94235e-17
C156 (\11\:n35 VSS) capacitor c=7.54515e-17
C157 (\12\:qbint VSS) capacitor c=8.83084e-17
C158 (\13\:qbint VSS) capacitor c=1.09817e-16
C159 (\13\:n35g VSS) capacitor c=9.9692e-17
C160 (\14\:n35g VSS) capacitor c=1.16251e-16
C161 (\5\:RTb VSS) capacitor c=4.97464e-17
C162 (\8\:RTb VSS) capacitor c=9.96226e-17
C163 (\9\:RTb VSS) capacitor c=9.16058e-17
C164 (\20\:CKbb VSS) capacitor c=1.32399e-16
C165 (\21\:CKbb VSS) capacitor c=1.38208e-16
C166 (\18\:qbint VSS) capacitor c=1.92101e-17
C167 (\19\:qbint VSS) capacitor c=3.00947e-17
C168 (\9\:RT VSS) capacitor c=1.10152e-16
C169 (\10\:RT VSS) capacitor c=1.18489e-16
C170 (\11\:RT VSS) capacitor c=5.64689e-17
C171 (\12\:SN VSS) capacitor c=5.58681e-17
C172 (\13\:SN VSS) capacitor c=3.70964e-17
C173 (\16\:n35 VSS) capacitor c=4.36861e-17
C174 (\3\:Q VSS) capacitor c=1.69754e-17
C175 (\3\:VDD VSS) capacitor c=2.57101e-17
C176 (\4\:VDD VSS) capacitor c=2.8979e-17
C177 (\6\:VDD VSS) capacitor c=2.22698e-16
C178 (\9\:VDD VSS) capacitor c=1.7149e-17
C179 (\17\:VDD VSS) capacitor c=3.56747e-17
C180 (\22\:VDD VSS) capacitor c=3.60812e-17
Rk38 (ExtVDD ExtVDD) resistor r=0.002059 c=0
Rk36 (\2\:ExtVDD ExtVDD) resistor r=0.02212 c=0
Rk39 (ExtVDD \5\:ExtVDD) resistor r=0.02011 c=0
Rk40 (ExtVDD \6\:ExtVDD) resistor r=0.1054 c=0
Rk65 (\2\:VDD \3\:VDD) resistor r=0.3358 c=0
Rk66 (\3\:VDD \4\:VDD) resistor r=0.1655 c=0
Rk67 (\4\:VDD \6\:VDD) resistor r=0.1087 c=0
Rk68 (\6\:VDD \8\:VDD) resistor r=1.6215 c=0
Rk69 (\8\:VDD \9\:VDD) resistor r=0.07655 c=0
Rk70 (\9\:VDD \11\:VDD) resistor r=0.2734 c=0
Rk71 (\3\:VDD \13\:VDD) resistor r=0.3558 c=0
Rk72 (\4\:VDD \15\:VDD) resistor r=0.3008 c=0
Rk73 (\9\:VDD \16\:VDD) resistor r=0.161 c=0
Rk77 (\17\:VDD VDD) resistor r=0.1011 c=0
Rk74 (\16\:VDD \17\:VDD) resistor r=0.1759 c=0
Rk75 (\17\:VDD \19\:VDD) resistor r=0.2748 c=0
Rk76 (\16\:VDD \21\:VDD) resistor r=0.4245 c=0
Rk78 (VDD \22\:VDD) resistor r=0.1461 c=0
Rk79 (\22\:VDD VDD) resistor r=0.08868 c=0
Rk80 (\22\:VDD \24\:VDD) resistor r=0.358 c=0
Rk62 (\3\:Q Q) resistor r=0.01183 c=0
Rk61 (\2\:Q \3\:Q) resistor r=0.2889 c=0
Rk63 (\3\:Q \5\:Q) resistor r=0.3262 c=0
Rk11 (\10\:SN \11\:SN) resistor r=0.2222 c=0
Rk56 (\12\:SN SN) resistor r=0.3243 c=0
Rk57 (SN \13\:SN) resistor r=0.1941 c=0
Rk81 (\2\:VSS \4\:VSS) resistor r=0.6658 c=0
Rk82 (\4\:VSS \5\:VSS) resistor r=0.5151 c=0
Rk84 (\6\:VSS VSS) resistor r=0.09878 c=0
Rk83 (\5\:VSS \6\:VSS) resistor r=0.2771 c=0
Rk86 (\7\:VSS VSS) resistor r=0.1211 c=0
Rk85 (VSS \7\:VSS) resistor r=0.7924 c=0
Rk87 (VSS \9\:VSS) resistor r=0.3935 c=0
Rk88 (\5\:VSS \11\:VSS) resistor r=0.243 c=0
Rk89 (\13\:VSS \14\:VSS) resistor r=0.05179 c=0
Rk90 (\14\:VSS \15\:VSS) resistor r=0.09635 c=0
Rk91 (\15\:VSS \16\:VSS) resistor r=0.6932 c=0
Rk92 (\16\:VSS \17\:VSS) resistor r=0.1657 c=0
Rk94 (\18\:VSS VSS) resistor r=0.1209 c=0
Rk93 (\17\:VSS \18\:VSS) resistor r=0.2076 c=0
Rk96 (\19\:VSS VSS) resistor r=0.1186 c=0
Rk95 (VSS \19\:VSS) resistor r=0.6934 c=0
Rk97 (VSS \20\:VSS) resistor r=0.03719 c=0
Rk98 (\20\:VSS \21\:VSS) resistor r=0.4229 c=0
Rk99 (\21\:VSS \22\:VSS) resistor r=0.06417 c=0
Rk100 (\14\:VSS \24\:VSS) resistor r=0.26 c=0
Rk101 (\17\:VSS \26\:VSS) resistor r=0.1888 c=0
Rk102 (\18\:VSS \28\:VSS) resistor r=0.1939 c=0
Rk103 (\20\:VSS \30\:VSS) resistor r=0.236 c=0
Rk104 (\21\:VSS \32\:VSS) resistor r=0.2279 c=0
Rk12 (CK \5\:CK) resistor r=0.004347 c=0
Rk14 (\5\:CK \6\:CK) resistor r=0.01373 c=0
Rk13 (\6\:CK \7\:CK) resistor r=0.004528 c=0
Rk2 (\4\:D D) resistor r=0.006089 c=0
Rk53 (RT \9\:RT) resistor r=0.1904 c=0
Rk54 (\9\:RT \10\:RT) resistor r=0.6451 c=0
Rk55 (RT \11\:RT) resistor r=0.008136 c=0
Rk1 (\12\:CKbb \13\:CKbb) resistor r=0.6148 c=0
Rk8 (\15\:CKbb \16\:CKbb) resistor r=0.3488 c=0
Rk9 (\16\:CKbb \17\:CKbb) resistor r=0.01511 c=0
Rk10 (\16\:CKbb \19\:CKbb) resistor r=0.2032 c=0
Rk51 (\20\:CKbb \21\:CKbb) resistor r=0.825 c=0
Rk19 (\6\:mout \7\:mout) resistor r=0.5282 c=0
Rk20 (\7\:mout \8\:mout) resistor r=0.2958 c=0
Rk21 (\8\:mout \9\:mout) resistor r=0.1024 c=0
Rk22 (\9\:mout \10\:mout) resistor r=0.3329 c=0
Rk23 (\7\:mout \12\:mout) resistor r=0.1276 c=0
Rk24 (\8\:mout \14\:mout) resistor r=0.09176 c=0
Rk25 (\9\:mout \15\:mout) resistor r=0.4799 c=0
Rk26 (\15\:mout \17\:mout) resistor r=0.04475 c=0
Rk27 (\10\:mout \18\:mout) resistor r=0.3472 c=0
Rk28 (\15\:mout \20\:mout) resistor r=0.03458 c=0
Rk3 (\9\:n20 \10\:n20) resistor r=0.1919 c=0
Rk4 (\9\:n20 \11\:n20) resistor r=0.21 c=0
Rk5 (\11\:n20 \13\:n20) resistor r=0.3756 c=0
Rk6 (\15\:n20 \17\:n20) resistor r=0.4879 c=0
Rk7 (\17\:n20 \18\:n20) resistor r=0.1439 c=0
Rk18 (\19\:n20 \20\:n20) resistor r=0.2682 c=0
Rk15 (\14\:CKb \15\:CKb) resistor r=0.3357 c=0
Rk16 (\15\:CKb \16\:CKb) resistor r=0.163 c=0
Rk17 (\15\:CKb \18\:CKb) resistor r=0.2006 c=0
Rk31 (\19\:CKb \20\:CKb) resistor r=0.2992 c=0
Rk32 (\7\:n35g \8\:n35g) resistor r=0.2403 c=0
Rk33 (\7\:n35g \10\:n35g) resistor r=0.6903 c=0
Rk44 (\12\:n35g \13\:n35g) resistor r=0.2425 c=0
Rk45 (\13\:n35g \14\:n35g) resistor r=0.5645 c=0
Rk46 (\13\:n35g \16\:n35g) resistor r=0.4312 c=0
Rk41 (\12\:qbint \13\:qbint) resistor r=0.4937 c=0
Rk42 (\13\:qbint \15\:qbint) resistor r=0.5662 c=0
Rk43 (\13\:qbint \17\:qbint) resistor r=0.146 c=0
Rk52 (\18\:qbint \19\:qbint) resistor r=0.2114 c=0
Rk47 (\5\:RTb \7\:RTb) resistor r=0.2158 c=0
Rk48 (\7\:RTb \8\:RTb) resistor r=0.4158 c=0
Rk49 (\8\:RTb \9\:RTb) resistor r=0.6874 c=0
Rk50 (\8\:RTb \11\:RTb) resistor r=0.3061 c=0
Rk29 (\5\:n35 \6\:n35) resistor r=0.3332 c=0
Rk30 (\6\:n35 \8\:n35) resistor r=0.2898 c=0
Rk34 (\10\:n35 \11\:n35) resistor r=0.4003 c=0
Rk35 (\11\:n35 \13\:n35) resistor r=0.3293 c=0
Rk58 (\15\:n35 \16\:n35) resistor r=0.3032 c=0
Rk59 (\16\:n35 \18\:n35) resistor r=0.2743 c=0
Rk64 (\2\:n41 \4\:n41) resistor r=0.6517 c=0
Rk60 (\2\:net095 \4\:net095) resistor r=0.2043 c=0
Rl56 (\7\:SN \8\:SN) resistor r=234.813 c=0
Rl57 (\8\:SN \9\:SN) resistor r=434.764 c=0
Rl8 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl46 (\4\:SN \6\:SN) resistor r=95.229 c=0
Rl44 (\3\:SN \4\:SN) resistor r=1126.2 c=0
Rl45 (\4\:SN \5\:SN) resistor r=14.5488 c=0
Rl11 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl9 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl10 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl2 (\2\:D \3\:D) resistor r=43.4636 c=0
Rl1 (\1\:D \2\:D) resistor r=135.391 c=0
Rl43 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl30 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl33 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl32 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl31 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl6 (CKbb \2\:CKbb) resistor r=167.403 c=0
Rl49 (\10\:CKbb \11\:CKbb) resistor r=166.412 c=0
Rl7 (\2\:CKbb \3\:CKbb) resistor r=446.586 c=0
Rl38 (\4\:CKbb \5\:CKbb) resistor r=66.1349 c=0
Rl41 (\5\:CKbb \8\:CKbb) resistor r=794.708 c=0
Rl42 (\6\:CKbb \9\:CKbb) resistor r=66.8717 c=0
Rl40 (\6\:CKbb \7\:CKbb) resistor r=129.238 c=0
Rl39 (\5\:CKbb \6\:CKbb) resistor r=430.133 c=0
Rl4 (mout \2\:mout) resistor r=24.2328 c=0
Rl5 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl12 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl14 (\6\:n20 \7\:n20) resistor r=105.531 c=0
Rl13 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl3 (n20 \2\:n20) resistor r=236.609 c=0
Rl23 (\9\:CKb \10\:CKb) resistor r=196.122 c=0
Rl50 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl15 (CKb \2\:CKb) resistor r=1.2334 c=0
Rl18 (\2\:CKb \5\:CKb) resistor r=60.4181 c=0
Rl21 (\3\:CKb \8\:CKb) resistor r=69.2058 c=0
Rl17 (\3\:CKb \4\:CKb) resistor r=236.258 c=0
Rl16 (\2\:CKb \3\:CKb) resistor r=75.7777 c=0
Rl22 (\6\:CKb \9\:CKb) resistor r=422.225 c=0
Rl19 (\5\:CKb \6\:CKb) resistor r=293.968 c=0
Rl20 (\6\:CKb \7\:CKb) resistor r=113.702 c=0
Rl26 (\3\:n35g \4\:n35g) resistor r=250.512 c=0
Rl24 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl25 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl27 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl51 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl55 (\10\:qbint \11\:qbint) resistor r=252.671 c=0
Rl37 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl34 (qbint \2\:qbint) resistor r=112.732 c=0
Rl36 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl35 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl52 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl54 (\8\:qbint \10\:qbint) resistor r=180.657 c=0
Rl53 (\8\:qbint \9\:qbint) resistor r=458.889 c=0
Rl28 (RTb \2\:RTb) resistor r=112.412 c=0
Rl29 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl47 (n35 \2\:n35) resistor r=508.667 c=0
Rl48 (\2\:n35 \3\:n35) resistor r=367.189 c=0
Rz19 (\7\:VDD \8\:VDD) resistor r=25 c=0
Rz20 (\7\:VDD \16\:VDD) resistor r=15 c=0
Rz17 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz21 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz22 (\8\:VSS \9\:VSS) resistor r=37.5 c=0
Rz23 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz24 (\23\:VSS \24\:VSS) resistor r=37.5 c=0
Rz25 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz26 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz27 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz28 (\31\:VSS \32\:VSS) resistor r=75 c=0
Rz3 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz5 (\11\:mout \12\:mout) resistor r=75 c=0
Rz6 (\13\:mout \14\:mout) resistor r=75 c=0
Rz1 (\12\:n20 \13\:n20) resistor r=75 c=0
Rz2 (\14\:n20 \15\:n20) resistor r=75 c=0
Rz4 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz8 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz12 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz11 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz13 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz7 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz9 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz14 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz15 (net095 \2\:net095) resistor r=75 c=0
Rz16 (\3\:net095 \4\:net095) resistor r=75 c=0
Ry11 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry12 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry21 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry22 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry23 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry24 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry25 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry26 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry27 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry18 (\4\:Q \5\:Q) resistor r=20.6667 c=0
Ry28 (\3\:VSS \4\:VSS) resistor r=6.2 c=0
Ry29 (\3\:VSS \6\:VSS) resistor r=10.3333 c=0
Ry30 (\3\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry31 (\12\:VSS \13\:VSS) resistor r=62 c=0
Ry32 (\12\:VSS \15\:VSS) resistor r=31 c=0
Ry33 (\12\:VSS \16\:VSS) resistor r=5.1667 c=0
Ry34 (\12\:VSS \19\:VSS) resistor r=5.1667 c=0
Ry35 (\12\:VSS \22\:VSS) resistor r=62 c=0
Ry3 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry5 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\16\:mout \17\:mout) resistor r=62 c=0
Ry7 (\19\:mout \20\:mout) resistor r=62 c=0
Ry1 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry2 (\16\:n20 \17\:n20) resistor r=62 c=0
Ry4 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry9 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry16 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry8 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry10 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry17 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry19 (n41 \2\:n41) resistor r=62 c=0
Ry20 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx8 (\5\:SN \10\:SN) resistor r=45 c=0
Rx9 (\2\:SN \11\:SN) resistor r=45 c=0
Rx32 (\3\:SN \12\:SN) resistor r=45 c=0
Rx33 (\9\:SN \13\:SN) resistor r=45 c=0
Rx10 (\3\:CK \7\:CK) resistor r=45 c=0
Rx3 (\2\:D \4\:D) resistor r=45 c=0
Rx29 (\3\:RT \9\:RT) resistor r=45 c=0
Rx30 (\1\:RT \10\:RT) resistor r=45 c=0
Rx31 (\7\:RT \11\:RT) resistor r=45 c=0
Rx1 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx2 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx7 (CKbb \17\:CKbb) resistor r=45 c=0
Rx25 (\11\:CKbb \20\:CKbb) resistor r=45 c=0
Rx26 (\8\:CKbb \21\:CKbb) resistor r=45 c=0
Rx14 (\4\:mout \10\:mout) resistor r=45 c=0
Rx15 (\2\:mout \18\:mout) resistor r=45 c=0
Rx4 (\2\:n20 \10\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \11\:n20) resistor r=45 c=0
Rx6 (n20 \18\:n20) resistor r=45 c=0
Rx12 (\4\:n20 \19\:n20) resistor r=45 c=0
Rx13 (\7\:n20 \20\:n20) resistor r=45 c=0
Rx11 (CKb \16\:CKb) resistor r=45 c=0
Rx17 (\10\:CKb \19\:CKb) resistor r=45 c=0
Rx18 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx19 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx22 (n35g \14\:n35g) resistor r=45 c=0
Rx21 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx27 (\9\:qbint \18\:qbint) resistor r=45 c=0
Rx28 (qbint \19\:qbint) resistor r=45 c=0
Rx23 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx24 (RTb \9\:RTb) resistor r=45 c=0
Rx16 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx20 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx34 (n35 \16\:n35) resistor r=45 c=0
mn25 (n21 \1\:D \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\14\:n20 \4\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\12\:n20 \9\:CKbb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (n30 \3\:mout \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\14\:CKbb \8\:CKb \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (net426 \6\:SN \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\7\:n35 \4\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM1 (\16\:qbint \5\:n35g \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0121 \5\:qbint \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \2\:RT \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb \3\:net095 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (net095 \11\:qbint n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn50 (n42 \8\:SN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp26 (\16\:n20 \2\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3011 \
        scb=0.0111155 scc=0.000221731 m=(1)
mp36 (\8\:n20 \7\:CKb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=8.20139 \
        scb=0.00436827 scc=2.20651e-05 m=(1)
mp35 (n31 mout \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=7.36777 \
        scb=0.00335337 scc=1.75985e-05 m=(1)
mp30 (\16\:mout \1\:SN \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=6.506 scb=0.00275822 \
        scc=1.68594e-05 m=(1)
mp21 (\18\:CKbb \5\:CKb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp20 (\17\:CKb \4\:CK \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.52288 \
        scb=0.00778605 scc=0.000197359 m=(1)
mp32 (\19\:mout \3\:n20 \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.97126 \
        scb=0.00301321 scc=1.70301e-05 m=(1)
mp40 (\4\:n35 \9\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.2199 \
        scb=0.0159497 scc=0.000584328 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
PM1 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \10\:CKbb \3\:n41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.26 scb=0.0274419 \
        scc=0.00267566 m=(1)
mp52 (n41 \10\:qbint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.021 \
        scb=0.00760198 scc=5.42807e-05 m=(1)
mp55 (\4\:Q \7\:qbint \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.3389 \
        scb=0.0172052 scc=0.000547772 m=(1)
mp50 (n41 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=17.7978 \
        scb=0.0191816 scc=0.000889993 m=(1)
ends RDFFSQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:51:31 2012 )
// Library name: gsclib045
// Cell name: RDFFSRQX1
// View name: extracted

simulator lang=spectre

subckt RDFFSRQX1 CK D ExtVDD Q RN RT SN VDD VSS
mp25 (n22 \3\:D \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (RN VSS) capacitor c=1.108e-16
C2 (RT VSS) capacitor c=2.31666e-17
C3 (SN VSS) capacitor c=4.11311e-17
C4 (D VSS) capacitor c=5.44676e-17
C5 (VDD VSS) capacitor c=7.07526e-16
C6 (Q VSS) capacitor c=3.68013e-17
C7 (ExtVDD VSS) capacitor c=1.98222e-16
C8 (CKbb VSS) capacitor c=5.54361e-17
C9 (mout VSS) capacitor c=5.33797e-17
C10 (n20 VSS) capacitor c=8.26482e-17
C11 (RNb VSS) capacitor c=3.91539e-17
C12 (CKb VSS) capacitor c=2.35786e-17
C13 (n35g VSS) capacitor c=1.7772e-17
C14 (qbint VSS) capacitor c=4.57429e-17
C15 (RTb VSS) capacitor c=5.17974e-17
C16 (n35 VSS) capacitor c=1.71933e-16
C17 (n41 VSS) capacitor c=8.47445e-17
C18 (n42 VSS) capacitor c=7.96264e-17
C19 (n40 VSS) capacitor c=8.46705e-17
C20 (net426 VSS) capacitor c=8.73516e-17
C21 (\7\:SN VSS) capacitor c=7.05736e-17
C22 (\7\:qbint VSS) capacitor c=3.83498e-17
C23 (\10\:qbint VSS) capacitor c=1.41633e-16
C24 (\4\:RNb VSS) capacitor c=3.12604e-16
C25 (\10\:CKbb VSS) capacitor c=5.76814e-17
C26 (\4\:RTb VSS) capacitor c=9.8167e-17
C27 (\6\:RT VSS) capacitor c=2.20496e-17
C28 (\4\:qbint VSS) capacitor c=5.35384e-17
C29 (\3\:n35g VSS) capacitor c=6.18561e-17
C30 (\5\:RT VSS) capacitor c=8.43931e-17
C31 (\9\:CKb VSS) capacitor c=1.11866e-16
C32 (\4\:RN VSS) capacitor c=3.2184e-17
C33 (\7\:RNb VSS) capacitor c=6.92464e-17
C34 (\3\:n20 VSS) capacitor c=4.64244e-17
C35 (\4\:CK VSS) capacitor c=5.66376e-17
C36 (\1\:SN VSS) capacitor c=2.99882e-17
C37 (\5\:CKb VSS) capacitor c=2.92506e-17
C38 (\7\:CKb VSS) capacitor c=9.21771e-17
C39 (\2\:CKbb VSS) capacitor c=1.52748e-16
C40 (\3\:D VSS) capacitor c=7.29689e-17
C41 (\8\:SN VSS) capacitor c=1.32242e-16
C42 (\6\:qbint VSS) capacitor c=4.25184e-17
C43 (\11\:qbint VSS) capacitor c=8.06262e-17
C44 (\3\:RNb VSS) capacitor c=6.80787e-17
C45 (\11\:CKb VSS) capacitor c=2.22469e-16
C46 (\8\:RT VSS) capacitor c=1.20185e-16
C47 (\2\:RT VSS) capacitor c=6.21972e-17
C48 (\5\:qbint VSS) capacitor c=3.87746e-17
C49 (\5\:n35g VSS) capacitor c=2.76477e-17
C50 (\2\:RTb VSS) capacitor c=4.66333e-17
C51 (\4\:CKbb VSS) capacitor c=3.24964e-17
C52 (\1\:RN VSS) capacitor c=3.44907e-17
C53 (\6\:n20 VSS) capacitor c=6.12355e-17
C54 (\6\:SN VSS) capacitor c=4.5982e-17
C55 (\1\:CK VSS) capacitor c=2.82836e-17
C56 (\8\:CKb VSS) capacitor c=2.53139e-17
C57 (\3\:mout VSS) capacitor c=4.58092e-17
C58 (\9\:CKbb VSS) capacitor c=4.97927e-17
C59 (\4\:CKb VSS) capacitor c=8.43185e-17
C60 (\1\:D VSS) capacitor c=4.88945e-17
C61 (\9\:qbint VSS) capacitor c=9.41986e-17
C62 (\11\:CKbb VSS) capacitor c=7.94667e-17
C63 (\3\:SN VSS) capacitor c=3.75485e-16
C64 (\9\:SN VSS) capacitor c=9.14336e-17
C65 (\7\:RT VSS) capacitor c=1.56081e-16
C66 (\8\:CKbb VSS) capacitor c=1.67449e-16
C67 (\3\:RT VSS) capacitor c=5.78493e-17
C68 (\1\:RT VSS) capacitor c=5.2908e-17
C69 (\3\:RTb VSS) capacitor c=7.5773e-17
C70 (\3\:qbint VSS) capacitor c=4.39848e-17
C71 (\2\:n35 VSS) capacitor c=2.52873e-16
C72 (\4\:n35g VSS) capacitor c=7.14465e-17
C73 (\10\:CKb VSS) capacitor c=5.38192e-17
C74 (\12\:CKb VSS) capacitor c=2.1752e-16
C75 (\3\:n35 VSS) capacitor c=1.16128e-16
C76 (\2\:RNb VSS) capacitor c=3.31472e-17
C77 (\9\:RNb VSS) capacitor c=1.06902e-17
C78 (\8\:RNb VSS) capacitor c=8.71934e-17
C79 (\7\:n20 VSS) capacitor c=5.31263e-17
C80 (\3\:RN VSS) capacitor c=4.65564e-17
C81 (\4\:n20 VSS) capacitor c=9.37723e-17
C82 (\3\:CK VSS) capacitor c=2.36445e-17
C83 (\2\:SN VSS) capacitor c=4.18672e-17
C84 (\5\:SN VSS) capacitor c=2.03416e-17
C85 (\2\:mout VSS) capacitor c=4.69245e-17
C86 (\4\:mout VSS) capacitor c=3.1078e-17
C87 (\5\:n20 VSS) capacitor c=7.69595e-17
C88 (\2\:n20 VSS) capacitor c=7.16254e-17
C89 (\3\:CKbb VSS) capacitor c=8.26856e-17
C90 (\7\:CKbb VSS) capacitor c=3.16279e-17
C91 (\2\:D VSS) capacitor c=5.2132e-17
C92 (\1\:VDD VSS) capacitor c=3.00657e-17
C93 (\14\:VDD VSS) capacitor c=4.73736e-17
C94 (\3\:Q VSS) capacitor c=5.30919e-17
C95 (\16\:VDD VSS) capacitor c=4.92132e-17
C96 (\3\:n41 VSS) capacitor c=9.87152e-17
C97 (\14\:n35 VSS) capacitor c=5.37018e-17
C98 (\15\:n35g VSS) capacitor c=5.69979e-17
C99 (\6\:RTb VSS) capacitor c=7.23425e-17
C100 (\1\:ExtVDD VSS) capacitor c=2.78576e-16
C101 (\9\:n35 VSS) capacitor c=6.17077e-17
C102 (\14\:qbint VSS) capacitor c=6.60601e-17
C103 (\6\:n35g VSS) capacitor c=9.10033e-17
C104 (\4\:n35 VSS) capacitor c=6.8905e-17
C105 (\5\:mout VSS) capacitor c=1.28058e-16
C106 (\13\:RNb VSS) capacitor c=2.66872e-17
C107 (\18\:VDD VSS) capacitor c=4.33723e-17
C108 (\20\:VDD VSS) capacitor c=5.21164e-17
C109 (\19\:mout VSS) capacitor c=3.67577e-17
C110 (\17\:CKb VSS) capacitor c=4.52625e-17
C111 (\16\:mout VSS) capacitor c=4.35833e-17
C112 (\22\:VDD VSS) capacitor c=6.0232e-17
C113 (\24\:VDD VSS) capacitor c=4.98798e-17
C114 (\18\:CKbb VSS) capacitor c=4.02072e-17
C115 (\8\:n20 VSS) capacitor c=4.10734e-17
C116 (\16\:n20 VSS) capacitor c=5.59145e-17
C117 (\26\:VDD VSS) capacitor c=3.57195e-17
C118 (\1\:Q VSS) capacitor c=3.74881e-17
C119 (\3\:n42 VSS) capacitor c=8.1219e-17
C120 (\3\:n40 VSS) capacitor c=8.16243e-17
C121 (\17\:n35 VSS) capacitor c=4.84026e-17
C122 (\11\:n35g VSS) capacitor c=2.63056e-17
C123 (\10\:RTb VSS) capacitor c=5.83059e-17
C124 (\12\:n35 VSS) capacitor c=6.36671e-17
C125 (\16\:qbint VSS) capacitor c=2.27954e-17
C126 (\9\:n35g VSS) capacitor c=8.03366e-17
C127 (\7\:n35 VSS) capacitor c=4.91029e-17
C128 (\11\:mout VSS) capacitor c=3.73001e-17
C129 (\10\:RNb VSS) capacitor c=4.40227e-17
C130 (\13\:mout VSS) capacitor c=3.83866e-17
C131 (\3\:net426 VSS) capacitor c=1.00475e-16
C132 (\13\:CKb VSS) capacitor c=6.40048e-17
C133 (\14\:CKbb VSS) capacitor c=5.14005e-17
C134 (\12\:n20 VSS) capacitor c=6.64112e-17
C135 (\14\:n20 VSS) capacitor c=7.04559e-17
C136 (\2\:CK VSS) capacitor c=3.40667e-17
C137 (\2\:CKb VSS) capacitor c=2.77704e-17
C138 (\3\:CKb VSS) capacitor c=5.55381e-17
C139 (\6\:CKb VSS) capacitor c=1.10229e-16
C140 (\2\:n35g VSS) capacitor c=3.34308e-17
C141 (ExtVDD VSS) capacitor c=3.93674e-17
C142 (\4\:RT VSS) capacitor c=7.44104e-17
C143 (\2\:qbint VSS) capacitor c=4.11428e-17
C144 (\5\:CKbb VSS) capacitor c=1.36991e-16
C145 (\6\:CKbb VSS) capacitor c=7.71037e-17
C146 (\4\:SN VSS) capacitor c=3.37826e-16
C147 (\5\:RNb VSS) capacitor c=5.20565e-16
C148 (\6\:RNb VSS) capacitor c=1.20397e-16
C149 (\12\:CKbb VSS) capacitor c=6.37884e-17
C150 (\13\:CKbb VSS) capacitor c=7.44131e-17
C151 (\8\:qbint VSS) capacitor c=1.06688e-16
C152 (\10\:n20 VSS) capacitor c=2.90055e-17
C153 (\11\:n20 VSS) capacitor c=6.97291e-17
C154 (\18\:n20 VSS) capacitor c=3.09122e-17
C155 (\17\:CKbb VSS) capacitor c=7.3919e-17
C156 (\10\:SN VSS) capacitor c=4.03939e-17
C157 (\11\:SN VSS) capacitor c=4.60272e-17
C158 (\5\:CK VSS) capacitor c=4.79538e-17
C159 (\6\:CK VSS) capacitor c=3.77231e-17
C160 (\15\:CKb VSS) capacitor c=7.15848e-17
C161 (\16\:CKb VSS) capacitor c=5.06653e-17
C162 (\19\:n20 VSS) capacitor c=8.13077e-17
C163 (\20\:n20 VSS) capacitor c=8.10401e-17
C164 (\12\:RNb VSS) capacitor c=5.88315e-17
C165 (\15\:RNb VSS) capacitor c=7.18462e-17
C166 (\16\:RNb VSS) capacitor c=8.34723e-17
C167 (\7\:mout VSS) capacitor c=1.56815e-16
C168 (\8\:mout VSS) capacitor c=5.3069e-17
C169 (\9\:mout VSS) capacitor c=1.06011e-16
C170 (\10\:mout VSS) capacitor c=8.55468e-17
C171 (\15\:mout VSS) capacitor c=6.20018e-17
C172 (\18\:mout VSS) capacitor c=7.39983e-17
C173 (\6\:n35 VSS) capacitor c=1.07161e-16
C174 (\19\:CKb VSS) capacitor c=3.8856e-17
C175 (\20\:CKb VSS) capacitor c=4.15834e-17
C176 (\8\:n35g VSS) capacitor c=3.19653e-17
C177 (\11\:n35 VSS) capacitor c=7.57391e-17
C178 (\12\:qbint VSS) capacitor c=8.82391e-17
C179 (\13\:qbint VSS) capacitor c=1.08749e-16
C180 (\13\:n35g VSS) capacitor c=9.96775e-17
C181 (\14\:n35g VSS) capacitor c=1.16145e-16
C182 (\5\:RTb VSS) capacitor c=4.94027e-17
C183 (\8\:RTb VSS) capacitor c=1.00867e-16
C184 (\9\:RTb VSS) capacitor c=9.21104e-17
C185 (\9\:RT VSS) capacitor c=1.10852e-16
C186 (\10\:RT VSS) capacitor c=1.18364e-16
C187 (\11\:RT VSS) capacitor c=3.85833e-17
C188 (\12\:SN VSS) capacitor c=8.28873e-17
C189 (\13\:SN VSS) capacitor c=8.06e-17
C190 (\20\:CKbb VSS) capacitor c=1.31776e-16
C191 (\21\:CKbb VSS) capacitor c=1.34217e-16
C192 (\18\:qbint VSS) capacitor c=1.95455e-17
C193 (\19\:qbint VSS) capacitor c=3.01215e-17
C194 (\16\:n35 VSS) capacitor c=5.0763e-17
C195 (\3\:VDD VSS) capacitor c=3.24499e-17
C196 (\4\:VDD VSS) capacitor c=2.62949e-17
C197 (\6\:VDD VSS) capacitor c=2.22593e-16
C198 (\7\:VDD VSS) capacitor c=1.92685e-16
C199 (\8\:VDD VSS) capacitor c=2.35077e-17
C200 (\10\:VDD VSS) capacitor c=2.59166e-17
C201 (\11\:VDD VSS) capacitor c=1.78868e-17
C202 (\12\:VDD VSS) capacitor c=2.60631e-17
C203 (\13\:VDD VSS) capacitor c=2.74726e-17
Rk19 (\5\:RN RN) resistor r=0.04968 c=0
Rk57 (RT \9\:RT) resistor r=0.182 c=0
Rk58 (\9\:RT \10\:RT) resistor r=0.6461 c=0
Rk59 (RT \11\:RT) resistor r=0.0166 c=0
Rk11 (SN \10\:SN) resistor r=0.01265 c=0
Rk12 (\10\:SN \11\:SN) resistor r=0.3244 c=0
Rk60 (\12\:SN \13\:SN) resistor r=0.5357 c=0
Rk2 (\4\:D D) resistor r=0.006097 c=0
Rk80 (\2\:VDD \3\:VDD) resistor r=0.3366 c=0
Rk81 (\3\:VDD \4\:VDD) resistor r=0.2178 c=0
Rk82 (\4\:VDD \6\:VDD) resistor r=0.06676 c=0
Rk83 (\6\:VDD \7\:VDD) resistor r=1.6934 c=0
Rk84 (\7\:VDD \8\:VDD) resistor r=0.08888 c=0
Rk85 (\8\:VDD \10\:VDD) resistor r=0.1312 c=0
Rk86 (\10\:VDD \11\:VDD) resistor r=0.08907 c=0
Rk88 (\12\:VDD VDD) resistor r=0.1955 c=0
Rk87 (\11\:VDD \12\:VDD) resistor r=0.08144 c=0
Rk89 (VDD \13\:VDD) resistor r=0.1464 c=0
Rk90 (\13\:VDD VDD) resistor r=0.08883 c=0
Rk91 (\3\:VDD \15\:VDD) resistor r=0.3564 c=0
Rk92 (\4\:VDD \17\:VDD) resistor r=0.2927 c=0
Rk93 (\7\:VDD \19\:VDD) resistor r=0.2015 c=0
Rk94 (\8\:VDD \21\:VDD) resistor r=0.359 c=0
Rk95 (\11\:VDD \23\:VDD) resistor r=0.3797 c=0
Rk96 (\12\:VDD \25\:VDD) resistor r=0.2069 c=0
Rk97 (\13\:VDD \27\:VDD) resistor r=0.3585 c=0
Rk66 (\2\:Q Q) resistor r=0.1703 c=0
Rk67 (Q \4\:Q) resistor r=0.2987 c=0
Rk44 (ExtVDD ExtVDD) resistor r=0.002061 c=0
Rk42 (\2\:ExtVDD ExtVDD) resistor r=0.02215 c=0
Rk45 (ExtVDD \5\:ExtVDD) resistor r=0.02014 c=0
Rk46 (ExtVDD \6\:ExtVDD) resistor r=0.1056 c=0
Rk13 (CK \5\:CK) resistor r=0.004352 c=0
Rk15 (\5\:CK \6\:CK) resistor r=0.01406 c=0
Rk14 (\6\:CK \7\:CK) resistor r=0.004534 c=0
Rk70 (\2\:VSS \3\:VSS) resistor r=0.03204 c=0
Rk71 (\3\:VSS \4\:VSS) resistor r=0.5131 c=0
Rk72 (\4\:VSS \5\:VSS) resistor r=0.5159 c=0
Rk74 (\6\:VSS VSS) resistor r=0.04935 c=0
Rk73 (\5\:VSS \6\:VSS) resistor r=0.3271 c=0
Rk76 (\7\:VSS VSS) resistor r=0.1213 c=0
Rk75 (VSS \7\:VSS) resistor r=0.8929 c=0
Rk77 (\3\:VSS \9\:VSS) resistor r=0.2485 c=0
Rk78 (\5\:VSS \11\:VSS) resistor r=0.2434 c=0
Rk79 (VSS \13\:VSS) resistor r=0.3081 c=0
Rk98 (\15\:VSS \17\:VSS) resistor r=0.3613 c=0
Rk99 (\17\:VSS \18\:VSS) resistor r=0.8431 c=0
Rk100 (\18\:VSS \19\:VSS) resistor r=0.06676 c=0
Rk102 (\20\:VSS VSS) resistor r=0.1211 c=0
Rk101 (\19\:VSS \20\:VSS) resistor r=0.2079 c=0
Rk103 (VSS \21\:VSS) resistor r=0.7291 c=0
Rk105 (\22\:VSS VSS) resistor r=0.1188 c=0
Rk104 (\21\:VSS \22\:VSS) resistor r=0.06428 c=0
Rk106 (VSS \23\:VSS) resistor r=0.03725 c=0
Rk107 (\23\:VSS \24\:VSS) resistor r=0.4236 c=0
Rk108 (\24\:VSS \25\:VSS) resistor r=0.06428 c=0
Rk109 (\19\:VSS \27\:VSS) resistor r=0.1891 c=0
Rk110 (\20\:VSS \29\:VSS) resistor r=0.1942 c=0
Rk111 (\21\:VSS \31\:VSS) resistor r=0.2359 c=0
Rk112 (\23\:VSS \33\:VSS) resistor r=0.2364 c=0
Rk113 (\24\:VSS \35\:VSS) resistor r=0.2282 c=0
Rk1 (\12\:CKbb \13\:CKbb) resistor r=0.6841 c=0
Rk8 (\15\:CKbb \16\:CKbb) resistor r=0.3494 c=0
Rk9 (\16\:CKbb \17\:CKbb) resistor r=0.01514 c=0
Rk10 (\16\:CKbb \19\:CKbb) resistor r=0.2035 c=0
Rk61 (\20\:CKbb \21\:CKbb) resistor r=0.8245 c=0
Rk25 (\6\:mout \7\:mout) resistor r=0.7619 c=0
Rk26 (\7\:mout \8\:mout) resistor r=0.3523 c=0
Rk27 (\8\:mout \9\:mout) resistor r=0.1709 c=0
Rk28 (\9\:mout \10\:mout) resistor r=0.3404 c=0
Rk29 (\7\:mout \12\:mout) resistor r=0.1231 c=0
Rk30 (\8\:mout \14\:mout) resistor r=0.09956 c=0
Rk31 (\9\:mout \15\:mout) resistor r=0.5241 c=0
Rk32 (\15\:mout \17\:mout) resistor r=0.04481 c=0
Rk33 (\10\:mout \18\:mout) resistor r=0.425 c=0
Rk34 (\15\:mout \20\:mout) resistor r=0.03462 c=0
Rk3 (\9\:n20 \10\:n20) resistor r=0.2067 c=0
Rk4 (\9\:n20 \11\:n20) resistor r=0.2104 c=0
Rk5 (\11\:n20 \13\:n20) resistor r=0.4456 c=0
Rk6 (\15\:n20 \17\:n20) resistor r=0.4887 c=0
Rk7 (\17\:n20 \18\:n20) resistor r=0.1577 c=0
Rk20 (\19\:n20 \20\:n20) resistor r=0.4615 c=0
Rk22 (\11\:RNb \12\:RNb) resistor r=0.3432 c=0
Rk23 (\12\:RNb \14\:RNb) resistor r=0.1482 c=0
Rk24 (\15\:RNb \16\:RNb) resistor r=0.3465 c=0
Rk16 (\14\:CKb \15\:CKb) resistor r=0.3583 c=0
Rk17 (\15\:CKb \16\:CKb) resistor r=0.1632 c=0
Rk18 (\15\:CKb \18\:CKb) resistor r=0.2066 c=0
Rk37 (\19\:CKb \20\:CKb) resistor r=0.3681 c=0
Rk38 (\7\:n35g \8\:n35g) resistor r=0.2407 c=0
Rk39 (\7\:n35g \10\:n35g) resistor r=0.6914 c=0
Rk50 (\12\:n35g \13\:n35g) resistor r=0.2429 c=0
Rk51 (\13\:n35g \14\:n35g) resistor r=0.5654 c=0
Rk52 (\13\:n35g \16\:n35g) resistor r=0.4319 c=0
Rk47 (\12\:qbint \13\:qbint) resistor r=0.4944 c=0
Rk48 (\13\:qbint \15\:qbint) resistor r=0.567 c=0
Rk49 (\13\:qbint \17\:qbint) resistor r=0.1463 c=0
Rk62 (\18\:qbint \19\:qbint) resistor r=0.2118 c=0
Rk53 (\5\:RTb \7\:RTb) resistor r=0.2162 c=0
Rk54 (\7\:RTb \8\:RTb) resistor r=0.4165 c=0
Rk55 (\8\:RTb \9\:RTb) resistor r=0.6885 c=0
Rk56 (\8\:RTb \11\:RTb) resistor r=0.3065 c=0
Rk35 (\5\:n35 \6\:n35) resistor r=0.4289 c=0
Rk36 (\6\:n35 \8\:n35) resistor r=0.3027 c=0
Rk40 (\10\:n35 \11\:n35) resistor r=0.4009 c=0
Rk41 (\11\:n35 \13\:n35) resistor r=0.3298 c=0
Rk63 (\15\:n35 \16\:n35) resistor r=0.3037 c=0
Rk64 (\16\:n35 \18\:n35) resistor r=0.2874 c=0
Rk68 (\2\:n41 \4\:n41) resistor r=0.7136 c=0
Rk69 (\2\:n42 \4\:n42) resistor r=0.5301 c=0
Rk65 (\2\:n40 \4\:n40) resistor r=0.6255 c=0
Rk21 (\2\:net426 \4\:net426) resistor r=0.5521 c=0
Rl16 (\2\:RN \4\:RN) resistor r=62.3411 c=0
Rl14 (\1\:RN \2\:RN) resistor r=152.726 c=0
Rl15 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl47 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl34 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl37 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl36 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl35 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl66 (\7\:SN \8\:SN) resistor r=237.735 c=0
Rl67 (\8\:SN \9\:SN) resistor r=491.014 c=0
Rl8 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl50 (\4\:SN \6\:SN) resistor r=95.229 c=0
Rl48 (\3\:SN \4\:SN) resistor r=1129.61 c=0
Rl49 (\4\:SN \5\:SN) resistor r=14.5488 c=0
Rl2 (\2\:D \3\:D) resistor r=108.118 c=0
Rl1 (\1\:D \2\:D) resistor r=70.6183 c=0
Rl11 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl9 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl10 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl4 (CKbb \2\:CKbb) resistor r=167.403 c=0
Rl53 (\10\:CKbb \11\:CKbb) resistor r=166.412 c=0
Rl5 (\2\:CKbb \3\:CKbb) resistor r=349.426 c=0
Rl42 (\4\:CKbb \5\:CKbb) resistor r=66.1349 c=0
Rl45 (\5\:CKbb \8\:CKbb) resistor r=762.322 c=0
Rl46 (\6\:CKbb \9\:CKbb) resistor r=66.8717 c=0
Rl44 (\6\:CKbb \7\:CKbb) resistor r=132.647 c=0
Rl43 (\5\:CKbb \6\:CKbb) resistor r=465.929 c=0
Rl6 (mout \2\:mout) resistor r=24.2328 c=0
Rl7 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl17 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl12 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl13 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl3 (n20 \2\:n20) resistor r=205.495 c=0
Rl55 (\3\:RNb \4\:RNb) resistor r=234.8 c=0
Rl18 (RNb \2\:RNb) resistor r=62.7075 c=0
Rl56 (\4\:RNb \5\:RNb) resistor r=1125.6 c=0
Rl59 (\5\:RNb \8\:RNb) resistor r=775.703 c=0
Rl58 (\6\:RNb \7\:RNb) resistor r=142.538 c=0
Rl60 (\6\:RNb \9\:RNb) resistor r=2.7666 c=0
Rl57 (\5\:RNb \6\:RNb) resistor r=283.029 c=0
Rl27 (\9\:CKb \10\:CKb) resistor r=163.736 c=0
Rl54 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl19 (CKb \2\:CKb) resistor r=1.2334 c=0
Rl22 (\2\:CKb \5\:CKb) resistor r=60.4181 c=0
Rl25 (\3\:CKb \8\:CKb) resistor r=67.2828 c=0
Rl21 (\3\:CKb \4\:CKb) resistor r=234.553 c=0
Rl20 (\2\:CKb \3\:CKb) resistor r=77.7008 c=0
Rl26 (\6\:CKb \9\:CKb) resistor r=506.359 c=0
Rl23 (\5\:CKb \6\:CKb) resistor r=86.9066 c=0
Rl24 (\6\:CKb \7\:CKb) resistor r=234.725 c=0
Rl30 (\3\:n35g \4\:n35g) resistor r=250.512 c=0
Rl28 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl29 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl31 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl61 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl65 (\10\:qbint \11\:qbint) resistor r=237.758 c=0
Rl41 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl38 (qbint \2\:qbint) resistor r=112.732 c=0
Rl40 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl39 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl62 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl64 (\8\:qbint \10\:qbint) resistor r=180.657 c=0
Rl63 (\8\:qbint \9\:qbint) resistor r=494.685 c=0
Rl32 (RTb \2\:RTb) resistor r=112.412 c=0
Rl33 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl51 (n35 \2\:n35) resistor r=508.667 c=0
Rl52 (\2\:n35 \3\:n35) resistor r=334.803 c=0
Rz20 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz23 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz24 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz25 (\12\:VSS \13\:VSS) resistor r=37.5 c=0
Rz28 (\14\:VSS \15\:VSS) resistor r=37.5 c=0
Rz29 (\26\:VSS \27\:VSS) resistor r=75 c=0
Rz30 (\28\:VSS \29\:VSS) resistor r=75 c=0
Rz31 (\30\:VSS \31\:VSS) resistor r=75 c=0
Rz32 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz33 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz3 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz8 (\11\:mout \12\:mout) resistor r=75 c=0
Rz9 (\13\:mout \14\:mout) resistor r=75 c=0
Rz1 (\12\:n20 \13\:n20) resistor r=75 c=0
Rz2 (\14\:n20 \15\:n20) resistor r=75 c=0
Rz7 (\10\:RNb \11\:RNb) resistor r=75 c=0
Rz4 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz11 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\16\:qbint \17\:qbint) resistor r=75 c=0
Rz16 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz10 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz12 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz17 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz21 (n42 \2\:n42) resistor r=75 c=0
Rz22 (\3\:n42 \4\:n42) resistor r=75 c=0
Rz18 (n40 \2\:n40) resistor r=75 c=0
Rz19 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz5 (net426 \2\:net426) resistor r=75 c=0
Rz6 (\3\:net426 \4\:net426) resistor r=75 c=0
Ry26 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry27 (\14\:VDD \15\:VDD) resistor r=20.6667 c=0
Ry28 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry29 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry30 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry31 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry32 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry33 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry19 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry12 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry14 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry22 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry23 (\1\:VSS \4\:VSS) resistor r=6.2 c=0
Ry24 (\1\:VSS \6\:VSS) resistor r=8.8571 c=0
Ry25 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry34 (\16\:VSS \17\:VSS) resistor r=12.4 c=0
Ry35 (\16\:VSS \18\:VSS) resistor r=5.1667 c=0
Ry36 (\16\:VSS \22\:VSS) resistor r=5.1667 c=0
Ry37 (\16\:VSS \25\:VSS) resistor r=62 c=0
Ry3 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry6 (\5\:mout \6\:mout) resistor r=62 c=0
Ry7 (\16\:mout \17\:mout) resistor r=62 c=0
Ry8 (\19\:mout \20\:mout) resistor r=62 c=0
Ry1 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry2 (\16\:n20 \17\:n20) resistor r=62 c=0
Ry5 (\13\:RNb \14\:RNb) resistor r=62 c=0
Ry4 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry10 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry16 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry15 (\14\:qbint \15\:qbint) resistor r=62 c=0
Ry17 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry9 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry11 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry18 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry20 (n41 \2\:n41) resistor r=62 c=0
Ry21 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx12 (\3\:RN \5\:RN) resistor r=45 c=0
Rx29 (\3\:RT \9\:RT) resistor r=45 c=0
Rx30 (\1\:RT \10\:RT) resistor r=45 c=0
Rx31 (\7\:RT \11\:RT) resistor r=45 c=0
Rx8 (\5\:SN \10\:SN) resistor r=45 c=0
Rx9 (\2\:SN \11\:SN) resistor r=45 c=0
Rx32 (\3\:SN \12\:SN) resistor r=45 c=0
Rx33 (\9\:SN \13\:SN) resistor r=45 c=0
Rx3 (\2\:D \4\:D) resistor r=45 c=0
Rx10 (\3\:CK \7\:CK) resistor r=45 c=0
Rx1 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx2 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx7 (CKbb \17\:CKbb) resistor r=45 c=0
Rx34 (\11\:CKbb \20\:CKbb) resistor r=45 c=0
Rx35 (\8\:CKbb \21\:CKbb) resistor r=45 c=0
Rx18 (\4\:mout \10\:mout) resistor r=45 c=0
Rx19 (\2\:mout \18\:mout) resistor r=45 c=0
Rx4 (\2\:n20 \10\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \11\:n20) resistor r=45 c=0
Rx6 (n20 \18\:n20) resistor r=45 c=0
Rx13 (\7\:n20 \19\:n20) resistor r=45 c=0
Rx14 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx15 (\8\:RNb \12\:RNb) resistor r=45 c=0
Rx16 (\9\:RNb \15\:RNb) resistor r=45 c=0
Rx17 (\2\:RNb \16\:RNb) resistor r=45 c=0
Rx11 (CKb \16\:CKb) resistor r=45 c=0
Rx21 (\10\:CKb \19\:CKb) resistor r=45 c=0
Rx22 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx23 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx26 (n35g \14\:n35g) resistor r=45 c=0
Rx25 (\3\:qbint \12\:qbint) resistor r=45 c=0
Rx36 (\9\:qbint \18\:qbint) resistor r=45 c=0
Rx37 (qbint \19\:qbint) resistor r=45 c=0
Rx27 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx28 (RTb \9\:RTb) resistor r=45 c=0
Rx20 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx24 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx38 (n35 \16\:n35) resistor r=45 c=0
mn25 (n21 \1\:D \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\14\:n20 \4\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\12\:n20 \9\:CKbb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (n30 \3\:mout \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\14\:CKbb \8\:CKb \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn20 (\13\:CKb \1\:CK \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (\3\:net426 \6\:SN \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=4.858e-14 ps=6.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 \3\:net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn22 (\10\:RNb \1\:RN \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn31 (\11\:mout RNb net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn40 (\7\:n35 \4\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM1 (\16\:qbint \5\:n35g \28\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0121 \5\:qbint \26\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \2\:RT \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb \3\:n40 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn51 (n40 \3\:RNb \3\:n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n40 \11\:qbint n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn50 (n42 \8\:SN \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp26 (\16\:n20 \2\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3011 \
        scb=0.0111155 scc=0.000221731 m=(1)
mp36 (\8\:n20 \7\:CKb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp35 (n31 mout \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=5.49382 \
        scb=0.00128253 scc=2.5304e-06 m=(1)
mp21 (\18\:CKbb \5\:CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp30 (\16\:mout \1\:SN \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp20 (\17\:CKb \4\:CK \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp32 (\19\:mout \3\:n20 net402 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp31 (net402 \7\:RNb \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.44121 \
        scb=0.00199344 scc=3.60278e-06 m=(1)
mp22 (\13\:RNb \4\:RN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.1952 \
        scb=0.00791337 scc=0.000154249 m=(1)
mp40 (\4\:n35 \9\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
PM1 (\14\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \10\:CKbb \3\:n41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp51 (n43 \4\:RNb \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp52 (n41 \10\:qbint n43 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=9.25529 \
        scb=0.00523543 scc=3.33014e-05 m=(1)
mp55 (\3\:Q \7\:qbint \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
mp50 (n41 \7\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=12.4549 \
        scb=0.0114313 scc=0.00019992 m=(1)
ends RDFFSRQX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:52:18 2012 )
// Library name: gsclib045
// Cell name: RDFFSRX1
// View name: extracted

simulator lang=spectre

subckt RDFFSRX1 CK D ExtVDD Q QN RN RT SN VDD VSS
mp22 (\11\:RNb \1\:RN \27\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=17.4481 \
        scb=0.0196885 scc=0.000695801 m=(1)
C1 (Q VSS) capacitor c=4.97632e-17
C2 (ExtVDD VSS) capacitor c=3.41735e-16
C3 (CK VSS) capacitor c=3.80732e-17
C4 (RN VSS) capacitor c=8.79545e-17
C5 (RT VSS) capacitor c=7.61948e-17
C6 (QN VSS) capacitor c=1.98965e-17
C7 (VDD VSS) capacitor c=7.42854e-16
C8 (SN VSS) capacitor c=3.73045e-17
C9 (D VSS) capacitor c=2.76271e-17
C10 (n20 VSS) capacitor c=5.58767e-17
C11 (CKbb VSS) capacitor c=6.53867e-17
C12 (mout VSS) capacitor c=4.81917e-17
C13 (RNb VSS) capacitor c=3.83103e-17
C14 (RTb VSS) capacitor c=5.50626e-17
C15 (CKb VSS) capacitor c=6.30399e-17
C16 (n35g VSS) capacitor c=1.61508e-17
C17 (qbint VSS) capacitor c=4.41826e-17
C18 (n35 VSS) capacitor c=4.77117e-17
C19 (qint VSS) capacitor c=2.23971e-17
C20 (n41 VSS) capacitor c=8.42008e-17
C21 (net426 VSS) capacitor c=8.68145e-17
C22 (n40 VSS) capacitor c=8.44192e-17
C23 (n42 VSS) capacitor c=7.9367e-17
C24 (\9\:SN VSS) capacitor c=7.05332e-17
C25 (\7\:qbint VSS) capacitor c=3.28494e-17
C26 (\11\:qbint VSS) capacitor c=1.40691e-16
C27 (\9\:RNb VSS) capacitor c=1.3033e-16
C28 (\13\:qbint VSS) capacitor c=4.52853e-17
C29 (\3\:qint VSS) capacitor c=6.11474e-17
C30 (\10\:CKbb VSS) capacitor c=5.86944e-17
C31 (\4\:RTb VSS) capacitor c=1.20506e-16
C32 (\6\:RT VSS) capacitor c=5.10042e-17
C33 (\4\:qbint VSS) capacitor c=6.71074e-17
C34 (\3\:n35g VSS) capacitor c=9.19416e-17
C35 (\3\:RT VSS) capacitor c=9.7108e-17
C36 (\8\:CKb VSS) capacitor c=4.02998e-17
C37 (\7\:RNb VSS) capacitor c=5.58168e-17
C38 (\3\:n20 VSS) capacitor c=4.79458e-17
C39 (\4\:CK VSS) capacitor c=6.28877e-17
C40 (\1\:SN VSS) capacitor c=2.60411e-17
C41 (\4\:CKb VSS) capacitor c=2.93581e-17
C42 (\9\:CKb VSS) capacitor c=1.16108e-16
C43 (\2\:CKbb VSS) capacitor c=1.51528e-16
C44 (\4\:D VSS) capacitor c=8.80674e-17
C45 (\1\:RN VSS) capacitor c=4.24263e-17
C46 (\10\:SN VSS) capacitor c=1.32177e-16
C47 (\6\:qbint VSS) capacitor c=3.71675e-17
C48 (\12\:qbint VSS) capacitor c=8.05994e-17
C49 (\8\:RNb VSS) capacitor c=6.59234e-17
C50 (\14\:qbint VSS) capacitor c=4.68281e-17
C51 (\4\:qint VSS) capacitor c=3.79512e-17
C52 (\12\:CKb VSS) capacitor c=5.20225e-17
C53 (\4\:RT VSS) capacitor c=1.54884e-16
C54 (\5\:RT VSS) capacitor c=6.62977e-17
C55 (\5\:qbint VSS) capacitor c=3.89239e-17
C56 (\4\:n35g VSS) capacitor c=2.69017e-17
C57 (\4\:CKbb VSS) capacitor c=3.37068e-17
C58 (\6\:n20 VSS) capacitor c=6.14389e-17
C59 (\1\:CK VSS) capacitor c=2.95118e-17
C60 (\3\:SN VSS) capacitor c=4.67477e-17
C61 (\11\:CKb VSS) capacitor c=2.57631e-17
C62 (\3\:mout VSS) capacitor c=4.57969e-17
C63 (\9\:CKbb VSS) capacitor c=4.92242e-17
C64 (\7\:CKb VSS) capacitor c=8.73787e-17
C65 (\1\:D VSS) capacitor c=5.17816e-17
C66 (\4\:RN VSS) capacitor c=3.69343e-17
C67 (\10\:RNb VSS) capacitor c=5.66128e-17
C68 (\13\:CKb VSS) capacitor c=4.25347e-17
C69 (\3\:n35 VSS) capacitor c=8.33805e-17
C70 (\10\:qbint VSS) capacitor c=8.39378e-17
C71 (\8\:SN VSS) capacitor c=6.27505e-17
C72 (\11\:SN VSS) capacitor c=9.51363e-17
C73 (\11\:CKbb VSS) capacitor c=6.01641e-17
C74 (\1\:RT VSS) capacitor c=1.78573e-16
C75 (\8\:CKbb VSS) capacitor c=1.40379e-16
C76 (\3\:RTb VSS) capacitor c=9.90162e-17
C77 (\7\:SN VSS) capacitor c=5.86024e-17
C78 (\4\:n35 VSS) capacitor c=6.90242e-17
C79 (\3\:qbint VSS) capacitor c=4.77478e-17
C80 (\6\:SN VSS) capacitor c=1.6739e-16
C81 (\1\:ExtVDD VSS) capacitor c=7.98494e-17
C82 (\2\:ExtVDD VSS) capacitor c=8.02791e-17
C83 (\2\:RTb VSS) capacitor c=5.41432e-17
C84 (\5\:n35g VSS) capacitor c=1.02007e-16
C85 (\2\:n35 VSS) capacitor c=5.56521e-17
C86 (\3\:RNb VSS) capacitor c=4.02966e-17
C87 (\2\:RNb VSS) capacitor c=4.32741e-17
C88 (\4\:RNb VSS) capacitor c=4.85635e-17
C89 (\7\:n20 VSS) capacitor c=5.32732e-17
C90 (\4\:n20 VSS) capacitor c=1.25118e-16
C91 (\3\:CK VSS) capacitor c=2.58563e-17
C92 (\10\:CKb VSS) capacitor c=2.16688e-17
C93 (\2\:SN VSS) capacitor c=4.94256e-17
C94 (\5\:SN VSS) capacitor c=2.63449e-17
C95 (\2\:mout VSS) capacitor c=4.31228e-17
C96 (\4\:mout VSS) capacitor c=3.16656e-17
C97 (\5\:n20 VSS) capacitor c=1.11516e-16
C98 (\3\:CKbb VSS) capacitor c=7.57749e-17
C99 (\7\:CKbb VSS) capacitor c=2.68879e-17
C100 (\3\:D VSS) capacitor c=1.52134e-17
C101 (\6\:RNb VSS) capacitor c=1.36482e-16
C102 (\2\:n20 VSS) capacitor c=6.96147e-17
C103 (\3\:RN VSS) capacitor c=4.67795e-17
C104 (\1\:VDD VSS) capacitor c=3.0029e-17
C105 (\11\:VDD VSS) capacitor c=4.49493e-17
C106 (\3\:Q VSS) capacitor c=8.425e-17
C107 (\13\:VDD VSS) capacitor c=5.0336e-17
C108 (\9\:qint VSS) capacitor c=5.46386e-17
C109 (\15\:VDD VSS) capacitor c=7.86472e-17
C110 (\3\:n41 VSS) capacitor c=9.77578e-17
C111 (\4\:QN VSS) capacitor c=6.24323e-17
C112 (\17\:n35 VSS) capacitor c=1.07272e-16
C113 (\15\:n35g VSS) capacitor c=5.66689e-17
C114 (\9\:RTb VSS) capacitor c=3.94824e-17
C115 (\11\:ExtVDD VSS) capacitor c=3.21729e-17
C116 (\3\:ExtVDD VSS) capacitor c=1.00913e-16
C117 (\7\:n35g VSS) capacitor c=6.85037e-17
C118 (\17\:qbint VSS) capacitor c=6.54125e-17
C119 (\5\:n35 VSS) capacitor c=5.94996e-17
C120 (\13\:n35 VSS) capacitor c=1.03593e-16
C121 (\5\:mout VSS) capacitor c=1.31817e-16
C122 (\17\:VDD VSS) capacitor c=4.42334e-17
C123 (\16\:CKb VSS) capacitor c=4.51257e-17
C124 (\15\:mout VSS) capacitor c=1.11308e-16
C125 (\22\:VDD VSS) capacitor c=5.74215e-17
C126 (\20\:VDD VSS) capacitor c=6.65173e-17
C127 (\18\:CKbb VSS) capacitor c=4.95554e-17
C128 (\18\:n20 VSS) capacitor c=3.23402e-17
C129 (\8\:n20 VSS) capacitor c=6.26379e-17
C130 (\29\:VDD VSS) capacitor c=3.6783e-17
C131 (\11\:RNb VSS) capacitor c=5.05803e-17
C132 (\27\:VDD VSS) capacitor c=4.68941e-17
C133 (\1\:Q VSS) capacitor c=5.44448e-17
C134 (\5\:qint VSS) capacitor c=4.69424e-17
C135 (\3\:n42 VSS) capacitor c=8.07711e-17
C136 (\3\:n40 VSS) capacitor c=8.13656e-17
C137 (\1\:QN VSS) capacitor c=4.7192e-17
C138 (\19\:n35 VSS) capacitor c=9.33561e-17
C139 (\11\:n35g VSS) capacitor c=2.94181e-17
C140 (\6\:RTb VSS) capacitor c=1.62462e-16
C141 (\9\:n35g VSS) capacitor c=8.13154e-17
C142 (\19\:qbint VSS) capacitor c=2.27182e-17
C143 (\11\:n35 VSS) capacitor c=2.56314e-17
C144 (\9\:n35 VSS) capacitor c=2.61597e-17
C145 (\11\:mout VSS) capacitor c=3.71471e-17
C146 (\13\:mout VSS) capacitor c=3.82409e-17
C147 (\18\:CKb VSS) capacitor c=5.81728e-17
C148 (\3\:net426 VSS) capacitor c=1.00173e-16
C149 (\14\:CKbb VSS) capacitor c=4.93952e-17
C150 (\14\:n20 VSS) capacitor c=5.7206e-17
C151 (\12\:n20 VSS) capacitor c=8.58402e-17
C152 (\14\:RNb VSS) capacitor c=7.34902e-17
C153 (VDD VSS) capacitor c=5.24716e-17
C154 (\2\:D VSS) capacitor c=5.34492e-17
C155 (\2\:CK VSS) capacitor c=4.12928e-17
C156 (\5\:RNb VSS) capacitor c=1.78447e-16
C157 (\2\:CKb VSS) capacitor c=8.58536e-17
C158 (\3\:CKb VSS) capacitor c=6.90482e-17
C159 (\5\:CKb VSS) capacitor c=3.29392e-17
C160 (\6\:CKb VSS) capacitor c=6.1961e-17
C161 (\2\:n35g VSS) capacitor c=3.44751e-17
C162 (\4\:SN VSS) capacitor c=2.11916e-16
C163 (\2\:qbint VSS) capacitor c=4.30878e-17
C164 (\5\:CKbb VSS) capacitor c=1.28817e-16
C165 (\6\:CKbb VSS) capacitor c=7.32144e-17
C166 (\2\:RT VSS) capacitor c=1.21201e-16
C167 (\2\:qint VSS) capacitor c=1.59387e-17
C168 (\13\:RNb VSS) capacitor c=1.20166e-16
C169 (\7\:D VSS) capacitor c=3.82395e-17
C170 (\12\:CKbb VSS) capacitor c=1.55623e-16
C171 (\13\:CKbb VSS) capacitor c=1.37959e-16
C172 (\8\:qbint VSS) capacitor c=5.09791e-17
C173 (\9\:qbint VSS) capacitor c=7.80552e-17
C174 (\10\:n20 VSS) capacitor c=7.77649e-17
C175 (\11\:n20 VSS) capacitor c=9.26184e-17
C176 (\16\:n20 VSS) capacitor c=6.53716e-17
C177 (\17\:n20 VSS) capacitor c=4.09224e-17
C178 (\17\:CKbb VSS) capacitor c=7.78565e-17
C179 (\12\:SN VSS) capacitor c=3.46687e-17
C180 (\13\:SN VSS) capacitor c=4.70007e-17
C181 (\7\:CK VSS) capacitor c=4.21288e-17
C182 (\14\:CKb VSS) capacitor c=4.61834e-17
C183 (\15\:CKb VSS) capacitor c=4.18548e-17
C184 (\20\:n20 VSS) capacitor c=7.68941e-17
C185 (\21\:n20 VSS) capacitor c=7.95904e-17
C186 (\16\:RNb VSS) capacitor c=7.12857e-17
C187 (\17\:RNb VSS) capacitor c=8.15912e-17
C188 (\7\:mout VSS) capacitor c=1.55721e-16
C189 (\8\:mout VSS) capacitor c=5.32172e-17
C190 (\9\:mout VSS) capacitor c=9.99444e-17
C191 (\10\:mout VSS) capacitor c=8.63714e-17
C192 (\17\:mout VSS) capacitor c=6.966e-17
C193 (\7\:n35 VSS) capacitor c=7.79277e-17
C194 (\8\:n35 VSS) capacitor c=1.20587e-16
C195 (\6\:n35g VSS) capacitor c=3.78131e-17
C196 (\13\:ExtVDD VSS) capacitor c=4.09478e-17
C197 (\15\:qbint VSS) capacitor c=9.02634e-17
C198 (\16\:qbint VSS) capacitor c=1.09415e-16
C199 (\13\:n35g VSS) capacitor c=1.04812e-16
C200 (\14\:n35g VSS) capacitor c=1.17203e-16
C201 (\14\:SN VSS) capacitor c=3.62102e-17
C202 (\15\:SN VSS) capacitor c=5.31263e-17
C203 (\15\:n35 VSS) capacitor c=5.86461e-17
C204 (\16\:n35 VSS) capacitor c=8.453e-17
C205 (\5\:RTb VSS) capacitor c=7.44742e-17
C206 (\8\:RTb VSS) capacitor c=1.06383e-16
C207 (\16\:SN VSS) capacitor c=8.83138e-17
C208 (\17\:SN VSS) capacitor c=8.45231e-17
C209 (\20\:CKbb VSS) capacitor c=1.27389e-16
C210 (\21\:CKbb VSS) capacitor c=1.17669e-16
C211 (\21\:qbint VSS) capacitor c=2.36714e-17
C212 (\22\:qbint VSS) capacitor c=2.97137e-17
C213 (\7\:RT VSS) capacitor c=8.0908e-17
C214 (\20\:CKb VSS) capacitor c=3.40814e-16
C215 (\21\:CKb VSS) capacitor c=4.07365e-16
C216 (\18\:RNb VSS) capacitor c=3.79856e-16
C217 (\19\:RNb VSS) capacitor c=3.25706e-16
C218 (\3\:QN VSS) capacitor c=3.15395e-17
C219 (\21\:n35 VSS) capacitor c=4.37774e-17
C220 (\7\:qint VSS) capacitor c=5.3604e-17
C221 (\8\:qint VSS) capacitor c=3.60733e-17
C222 (\3\:VDD VSS) capacitor c=3.02064e-17
C223 (\4\:VDD VSS) capacitor c=3.26173e-17
C224 (\6\:VDD VSS) capacitor c=1.00014e-17
C225 (\7\:VDD VSS) capacitor c=2.89735e-16
C226 (\8\:VDD VSS) capacitor c=2.3899e-16
C227 (\10\:VDD VSS) capacitor c=4.1172e-17
C228 (\19\:VDD VSS) capacitor c=1.22057e-17
C229 (\24\:VDD VSS) capacitor c=2.31419e-17
C230 (\26\:VDD VSS) capacitor c=3.30385e-17
Rk76 (\2\:Q Q) resistor r=0.1675 c=0
Rk77 (Q \4\:Q) resistor r=0.336 c=0
Rk46 (ExtVDD ExtVDD) resistor r=0.002123 c=0
Rk43 (\4\:ExtVDD \5\:ExtVDD) resistor r=0.02229 c=0
Rk44 (\5\:ExtVDD \7\:ExtVDD) resistor r=0.02229 c=0
Rk47 (\8\:ExtVDD ExtVDD) resistor r=0.01337 c=0
Rk45 (\5\:ExtVDD \8\:ExtVDD) resistor r=0.02006 c=0
Rk49 (\12\:ExtVDD \13\:ExtVDD) resistor r=0.08224 c=0
Rk19 (\5\:CK CK) resistor r=0.004354 c=0
Rk21 (\5\:CK \7\:CK) resistor r=0.01392 c=0
Rk20 (\6\:CK \7\:CK) resistor r=0.004187 c=0
Rk1 (\5\:RN RN) resistor r=0.007658 c=0
Rk64 (\7\:RT RT) resistor r=0.01288 c=0
Rk68 (\3\:QN QN) resistor r=0.04336 c=0
Rk67 (\2\:QN \3\:QN) resistor r=0.3244 c=0
Rk69 (\3\:QN \5\:QN) resistor r=0.2331 c=0
Rk92 (\2\:VDD \3\:VDD) resistor r=0.3391 c=0
Rk93 (\3\:VDD \4\:VDD) resistor r=0.2189 c=0
Rk94 (\4\:VDD \6\:VDD) resistor r=0.06709 c=0
Rk95 (\6\:VDD \7\:VDD) resistor r=0.05214 c=0
Rk96 (\7\:VDD \8\:VDD) resistor r=1.6493 c=0
Rk97 (\8\:VDD \10\:VDD) resistor r=0.2216 c=0
Rk98 (\3\:VDD \12\:VDD) resistor r=0.3594 c=0
Rk99 (\4\:VDD \14\:VDD) resistor r=0.2953 c=0
Rk100 (\7\:VDD \16\:VDD) resistor r=0.3642 c=0
Rk101 (\8\:VDD \18\:VDD) resistor r=0.2033 c=0
Rk102 (\10\:VDD \19\:VDD) resistor r=0.09511 c=0
Rk103 (\19\:VDD \21\:VDD) resistor r=0.2308 c=0
Rk104 (\10\:VDD \23\:VDD) resistor r=0.3458 c=0
Rk107 (\24\:VDD VDD) resistor r=0.1964 c=0
Rk105 (\19\:VDD \24\:VDD) resistor r=0.07686 c=0
Rk106 (\24\:VDD \25\:VDD) resistor r=0.2207 c=0
Rk108 (VDD \26\:VDD) resistor r=0.06983 c=0
Rk109 (\26\:VDD VDD) resistor r=0.1671 c=0
Rk110 (VDD \28\:VDD) resistor r=0.3808 c=0
Rk111 (\26\:VDD \30\:VDD) resistor r=0.2828 c=0
Rk17 (\12\:SN SN) resistor r=0.03613 c=0
Rk18 (SN \13\:SN) resistor r=0.2361 c=0
Rk56 (\14\:SN \15\:SN) resistor r=0.2157 c=0
Rk61 (\16\:SN \17\:SN) resistor r=0.4639 c=0
Rk4 (\5\:D D) resistor r=0.00603 c=0
Rk6 (\5\:D \7\:D) resistor r=0.03636 c=0
Rk5 (\6\:D \7\:D) resistor r=0.00603 c=0
Rk85 (VSS VSS) resistor r=0.8423 c=0
Rk80 (\2\:VSS \3\:VSS) resistor r=0.02971 c=0
Rk81 (\3\:VSS \4\:VSS) resistor r=0.2689 c=0
Rk82 (\4\:VSS \5\:VSS) resistor r=0.7852 c=0
Rk84 (\6\:VSS VSS) resistor r=0.2988 c=0
Rk83 (\5\:VSS \6\:VSS) resistor r=0.06211 c=0
Rk86 (VSS \7\:VSS) resistor r=0.05507 c=0
Rk87 (\7\:VSS \8\:VSS) resistor r=0.1369 c=0
Rk88 (\8\:VSS \10\:VSS) resistor r=0.6667 c=0
Rk89 (\3\:VSS \12\:VSS) resistor r=0.2507 c=0
Rk90 (\5\:VSS \14\:VSS) resistor r=0.1674 c=0
Rk91 (\8\:VSS \16\:VSS) resistor r=0.2532 c=0
Rk112 (\18\:VSS \20\:VSS) resistor r=0.3664 c=0
Rk113 (\20\:VSS \21\:VSS) resistor r=0.2365 c=0
Rk114 (\21\:VSS \22\:VSS) resistor r=0.3611 c=0
Rk115 (\22\:VSS \23\:VSS) resistor r=0.3138 c=0
Rk117 (\24\:VSS VSS) resistor r=0.1242 c=0
Rk116 (\23\:VSS \24\:VSS) resistor r=0.2089 c=0
Rk119 (\25\:VSS VSS) resistor r=0.543 c=0
Rk118 (VSS \25\:VSS) resistor r=0.2993 c=0
Rk120 (VSS \26\:VSS) resistor r=0.03743 c=0
Rk121 (\26\:VSS \27\:VSS) resistor r=0.2166 c=0
Rk122 (\27\:VSS \28\:VSS) resistor r=0.2042 c=0
Rk123 (\28\:VSS \29\:VSS) resistor r=0.0945 c=0
Rk124 (\21\:VSS \31\:VSS) resistor r=0.2657 c=0
Rk125 (\23\:VSS \33\:VSS) resistor r=0.1908 c=0
Rk126 (\24\:VSS \35\:VSS) resistor r=0.1959 c=0
Rk127 (\26\:VSS \37\:VSS) resistor r=0.2425 c=0
Rk128 (\28\:VSS \39\:VSS) resistor r=0.2302 c=0
Rk8 (\9\:n20 \10\:n20) resistor r=0.3483 c=0
Rk9 (\9\:n20 \11\:n20) resistor r=0.2313 c=0
Rk10 (\11\:n20 \13\:n20) resistor r=0.5005 c=0
Rk11 (\15\:n20 \16\:n20) resistor r=0.4311 c=0
Rk12 (\16\:n20 \17\:n20) resistor r=0.314 c=0
Rk13 (\16\:n20 \19\:n20) resistor r=0.1617 c=0
Rk25 (\20\:n20 \21\:n20) resistor r=0.4665 c=0
Rk7 (\12\:CKbb \13\:CKbb) resistor r=0.8559 c=0
Rk14 (\15\:CKbb \16\:CKbb) resistor r=0.3312 c=0
Rk15 (\16\:CKbb \17\:CKbb) resistor r=0.01521 c=0
Rk16 (\16\:CKbb \19\:CKbb) resistor r=0.3111 c=0
Rk62 (\20\:CKbb \21\:CKbb) resistor r=0.7149 c=0
Rk28 (\6\:mout \7\:mout) resistor r=0.7682 c=0
Rk29 (\7\:mout \8\:mout) resistor r=0.3554 c=0
Rk30 (\8\:mout \9\:mout) resistor r=0.1724 c=0
Rk31 (\9\:mout \10\:mout) resistor r=0.3428 c=0
Rk32 (\7\:mout \12\:mout) resistor r=0.124 c=0
Rk33 (\8\:mout \14\:mout) resistor r=0.1005 c=0
Rk34 (\9\:mout \16\:mout) resistor r=0.5127 c=0
Rk35 (\10\:mout \17\:mout) resistor r=0.4285 c=0
Rk2 (\12\:RNb \13\:RNb) resistor r=0.1647 c=0
Rk3 (\13\:RNb \15\:RNb) resistor r=0.3836 c=0
Rk27 (\16\:RNb \17\:RNb) resistor r=0.3493 c=0
Rk66 (\18\:RNb \19\:RNb) resistor r=2.3522 c=0
Rk58 (\5\:RTb \7\:RTb) resistor r=0.5298 c=0
Rk59 (\7\:RTb \8\:RTb) resistor r=0.7289 c=0
Rk60 (\8\:RTb \10\:RTb) resistor r=0.1191 c=0
Rk22 (\14\:CKb \15\:CKb) resistor r=0.1998 c=0
Rk23 (\15\:CKb \17\:CKb) resistor r=0.2314 c=0
Rk24 (\15\:CKb \19\:CKb) resistor r=0.3608 c=0
Rk65 (\20\:CKb \21\:CKb) resistor r=2.3652 c=0
Rk41 (\6\:n35g \8\:n35g) resistor r=0.1274 c=0
Rk42 (\8\:n35g \10\:n35g) resistor r=0.5913 c=0
Rk53 (\12\:n35g \13\:n35g) resistor r=0.245 c=0
Rk54 (\13\:n35g \14\:n35g) resistor r=0.5703 c=0
Rk55 (\13\:n35g \16\:n35g) resistor r=0.4355 c=0
Rk50 (\15\:qbint \16\:qbint) resistor r=0.4987 c=0
Rk51 (\16\:qbint \18\:qbint) resistor r=0.5718 c=0
Rk52 (\16\:qbint \20\:qbint) resistor r=0.1475 c=0
Rk63 (\21\:qbint \22\:qbint) resistor r=0.2135 c=0
Rk36 (\6\:n35 \7\:n35) resistor r=0.4146 c=0
Rk37 (\7\:n35 \8\:n35) resistor r=0.5509 c=0
Rk38 (\8\:n35 \10\:n35) resistor r=0.1724 c=0
Rk39 (\7\:n35 \12\:n35) resistor r=0.1502 c=0
Rk40 (\8\:n35 \14\:n35) resistor r=0.5954 c=0
Rk57 (\15\:n35 \16\:n35) resistor r=0.4149 c=0
Rk70 (\18\:n35 \20\:n35) resistor r=0.6643 c=0
Rk71 (\20\:n35 \21\:n35) resistor r=0.1231 c=0
Rk72 (\6\:qint \7\:qint) resistor r=0.2558 c=0
Rk73 (\7\:qint \8\:qint) resistor r=0.1622 c=0
Rk74 (\7\:qint \10\:qint) resistor r=0.2863 c=0
Rk78 (\2\:n41 \4\:n41) resistor r=0.7195 c=0
Rk26 (\2\:net426 \4\:net426) resistor r=0.5568 c=0
Rk75 (\2\:n40 \4\:n40) resistor r=0.6308 c=0
Rk79 (\2\:n42 \4\:n42) resistor r=0.5345 c=0
Rl40 (\1\:ExtVDD \2\:ExtVDD) resistor r=149.73 c=0
Rl15 (\2\:CK \4\:CK) resistor r=193.945 c=0
Rl13 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl14 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl1 (\1\:RN \2\:RN) resistor r=62.3411 c=0
Rl3 (\2\:RN \4\:RN) resistor r=152.726 c=0
Rl2 (\2\:RN \3\:RN) resistor r=0.6051 c=0
Rl56 (\1\:RT \4\:RT) resistor r=752.514 c=0
Rl58 (\2\:RT \6\:RT) resistor r=35.9829 c=0
Rl55 (\2\:RT \3\:RT) resistor r=273.346 c=0
Rl57 (\2\:RT \5\:RT) resistor r=195.631 c=0
Rl54 (\1\:RT \2\:RT) resistor r=176.551 c=0
Rl76 (\9\:SN \10\:SN) resistor r=237.735 c=0
Rl77 (\10\:SN \11\:SN) resistor r=491.014 c=0
Rl59 (\7\:SN \8\:SN) resistor r=131.297 c=0
Rl12 (\1\:SN \2\:SN) resistor r=37.2721 c=0
Rl41 (\3\:SN \4\:SN) resistor r=95.229 c=0
Rl43 (\4\:SN \6\:SN) resistor r=842.68 c=0
Rl42 (\4\:SN \5\:SN) resistor r=12.5751 c=0
Rl7 (\2\:D \4\:D) resistor r=161.253 c=0
Rl5 (\1\:D \2\:D) resistor r=95.868 c=0
Rl6 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl18 (\6\:n20 \7\:n20) resistor r=136.213 c=0
Rl16 (\3\:n20 \4\:n20) resistor r=30.6172 c=0
Rl17 (\4\:n20 \5\:n20) resistor r=279.747 c=0
Rl4 (n20 \2\:n20) resistor r=283.74 c=0
Rl10 (CKbb \2\:CKbb) resistor r=216.835 c=0
Rl61 (\10\:CKbb \11\:CKbb) resistor r=195.656 c=0
Rl11 (\2\:CKbb \3\:CKbb) resistor r=306.38 c=0
Rl49 (\4\:CKbb \5\:CKbb) resistor r=66.1349 c=0
Rl52 (\5\:CKbb \8\:CKbb) resistor r=762.322 c=0
Rl53 (\6\:CKbb \9\:CKbb) resistor r=60.7265 c=0
Rl51 (\6\:CKbb \7\:CKbb) resistor r=81.3209 c=0
Rl50 (\5\:CKbb \6\:CKbb) resistor r=462.851 c=0
Rl8 (mout \2\:mout) resistor r=24.2328 c=0
Rl9 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl66 (\8\:RNb \9\:RNb) resistor r=234.8 c=0
Rl67 (\9\:RNb \10\:RNb) resistor r=259.682 c=0
Rl19 (RNb \2\:RNb) resistor r=62.7075 c=0
Rl20 (\3\:RNb \4\:RNb) resistor r=180.578 c=0
Rl23 (\5\:RNb \7\:RNb) resistor r=63.8867 c=0
Rl21 (\4\:RNb \5\:RNb) resistor r=55.666 c=0
Rl22 (\5\:RNb \6\:RNb) resistor r=470.821 c=0
Rl44 (\3\:RTb \4\:RTb) resistor r=343.967 c=0
Rl38 (RTb \2\:RTb) resistor r=115.333 c=0
Rl62 (\12\:CKb \13\:CKb) resistor r=134.339 c=0
Rl24 (CKb \2\:CKb) resistor r=337.866 c=0
Rl30 (\2\:CKb \8\:CKb) resistor r=127.816 c=0
Rl26 (\3\:CKb \4\:CKb) resistor r=63.043 c=0
Rl31 (\3\:CKb \9\:CKb) resistor r=268.816 c=0
Rl25 (\2\:CKb \3\:CKb) resistor r=310.443 c=0
Rl27 (\4\:CKb \5\:CKb) resistor r=93.1104 c=0
Rl32 (\5\:CKb \10\:CKb) resistor r=1.2301 c=0
Rl33 (\6\:CKb \11\:CKb) resistor r=73.052 c=0
Rl29 (\6\:CKb \7\:CKb) resistor r=236.258 c=0
Rl28 (\5\:CKb \6\:CKb) resistor r=85.3931 c=0
Rl37 (\3\:n35g \5\:n35g) resistor r=332.357 c=0
Rl34 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl35 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl36 (\2\:n35g \4\:n35g) resistor r=92.0109 c=0
Rl68 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl73 (\11\:qbint \12\:qbint) resistor r=237.758 c=0
Rl75 (\13\:qbint \14\:qbint) resistor r=199.018 c=0
Rl48 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl45 (qbint \2\:qbint) resistor r=112.732 c=0
Rl47 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl46 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl69 (\7\:qbint \8\:qbint) resistor r=99.804 c=0
Rl72 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl74 (\9\:qbint \13\:qbint) resistor r=89.4853 c=0
Rl71 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl70 (\8\:qbint \9\:qbint) resistor r=104.193 c=0
Rl60 (\3\:n35 \4\:n35) resistor r=238.77 c=0
Rl39 (n35 \2\:n35) resistor r=149.925 c=0
Rl63 (qint \2\:qint) resistor r=3.1216 c=0
Rl64 (\2\:qint \3\:qint) resistor r=66.0494 c=0
Rl65 (\2\:qint \4\:qint) resistor r=75.4463 c=0
Rz22 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz17 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz25 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz26 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz27 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz28 (\15\:VSS \16\:VSS) resistor r=37.5 c=0
Rz31 (\17\:VSS \18\:VSS) resistor r=37.5 c=0
Rz32 (\30\:VSS \31\:VSS) resistor r=37.5 c=0
Rz33 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz34 (\34\:VSS \35\:VSS) resistor r=75 c=0
Rz35 (\36\:VSS \37\:VSS) resistor r=75 c=0
Rz36 (\38\:VSS \39\:VSS) resistor r=75 c=0
Rz2 (\12\:n20 \13\:n20) resistor r=75 c=0
Rz3 (\14\:n20 \15\:n20) resistor r=75 c=0
Rz4 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz8 (\11\:mout \12\:mout) resistor r=75 c=0
Rz9 (\13\:mout \14\:mout) resistor r=75 c=0
Rz1 (\14\:RNb \15\:RNb) resistor r=75 c=0
Rz16 (\6\:RTb \7\:RTb) resistor r=75 c=0
Rz5 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz12 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz15 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz14 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz10 (\9\:n35 \10\:n35) resistor r=75 c=0
Rz11 (\11\:n35 \12\:n35) resistor r=75 c=0
Rz18 (\19\:n35 \20\:n35) resistor r=75 c=0
Rz19 (\5\:qint \6\:qint) resistor r=75 c=0
Rz6 (net426 \2\:net426) resistor r=75 c=0
Rz7 (\3\:net426 \4\:net426) resistor r=75 c=0
Rz20 (n40 \2\:n40) resistor r=75 c=0
Rz21 (\3\:n40 \4\:n40) resistor r=75 c=0
Rz23 (n42 \2\:n42) resistor r=75 c=0
Rz24 (\3\:n42 \4\:n42) resistor r=75 c=0
Ry20 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry11 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry12 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry13 (\11\:ExtVDD \12\:ExtVDD) resistor r=62 c=0
Ry17 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry27 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry28 (\11\:VDD \12\:VDD) resistor r=20.6667 c=0
Ry29 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry30 (\15\:VDD \16\:VDD) resistor r=20.6667 c=0
Ry31 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry32 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry33 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry34 (\20\:VDD \25\:VDD) resistor r=62 c=0
Ry35 (\27\:VDD \28\:VDD) resistor r=62 c=0
Ry36 (\29\:VDD \30\:VDD) resistor r=62 c=0
Ry23 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry24 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry25 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry26 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry37 (\19\:VSS \20\:VSS) resistor r=12.4 c=0
Ry38 (\19\:VSS \22\:VSS) resistor r=8.8571 c=0
Ry39 (\19\:VSS \25\:VSS) resistor r=5.1667 c=0
Ry40 (\19\:VSS \27\:VSS) resistor r=15.5 c=0
Ry41 (\19\:VSS \29\:VSS) resistor r=31 c=0
Ry2 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry3 (\18\:n20 \19\:n20) resistor r=62 c=0
Ry4 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry6 (\5\:mout \6\:mout) resistor r=62 c=0
Ry7 (\15\:mout \16\:mout) resistor r=31 c=0
Ry1 (\11\:RNb \12\:RNb) resistor r=62 c=0
Ry16 (\9\:RTb \10\:RTb) resistor r=62 c=0
Ry5 (\16\:CKb \17\:CKb) resistor r=62 c=0
Ry10 (\7\:n35g \8\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry8 (\5\:n35 \6\:n35) resistor r=62 c=0
Ry9 (\13\:n35 \14\:n35) resistor r=62 c=0
Ry18 (\17\:n35 \18\:n35) resistor r=62 c=0
Ry19 (\9\:qint \10\:qint) resistor r=62 c=0
Ry21 (n41 \2\:n41) resistor r=62 c=0
Ry22 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx22 (\2\:ExtVDD \8\:ExtVDD) resistor r=15 c=0
Rx23 (\1\:ExtVDD \13\:ExtVDD) resistor r=45 c=0
Rx12 (\3\:CK \6\:CK) resistor r=45 c=0
Rx1 (\3\:RN \5\:RN) resistor r=45 c=0
Rx38 (\1\:RT \7\:RT) resistor r=45 c=0
Rx10 (\5\:SN \12\:SN) resistor r=45 c=0
Rx11 (\2\:SN \13\:SN) resistor r=45 c=0
Rx26 (\6\:SN \14\:SN) resistor r=45 c=0
Rx27 (\7\:SN \15\:SN) resistor r=45 c=0
Rx32 (\8\:SN \16\:SN) resistor r=45 c=0
Rx33 (\11\:SN \17\:SN) resistor r=45 c=0
Rx3 (\3\:D \6\:D) resistor r=45 c=0
Rx6 (\2\:n20 \10\:n20) resistor r=45 c=0
Rx7 (\5\:n20 \11\:n20) resistor r=45 c=0
Rx8 (n20 \17\:n20) resistor r=45 c=0
Rx14 (\4\:n20 \20\:n20) resistor r=45 c=0
Rx15 (\7\:n20 \21\:n20) resistor r=45 c=0
Rx4 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx5 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx9 (CKbb \17\:CKbb) resistor r=45 c=0
Rx34 (\11\:CKbb \20\:CKbb) resistor r=45 c=0
Rx35 (\8\:CKbb \21\:CKbb) resistor r=45 c=0
Rx18 (\4\:mout \10\:mout) resistor r=45 c=0
Rx19 (\2\:mout \17\:mout) resistor r=45 c=0
Rx2 (\6\:RNb \13\:RNb) resistor r=45 c=0
Rx16 (\4\:RNb \16\:RNb) resistor r=45 c=0
Rx17 (\2\:RNb \17\:RNb) resistor r=45 c=0
Rx41 (\10\:RNb \18\:RNb) resistor r=45 c=0
Rx42 (\3\:RNb \19\:RNb) resistor r=45 c=0
Rx30 (\2\:RTb \5\:RTb) resistor r=45 c=0
Rx31 (\3\:RTb \8\:RTb) resistor r=45 c=0
Rx13 (\10\:CKb \14\:CKb) resistor r=45 c=0
Rx39 (CKb \20\:CKb) resistor r=45 c=0
Rx40 (\13\:CKb \21\:CKb) resistor r=45 c=0
Rx21 (\5\:n35g \6\:n35g) resistor r=45 c=0
Rx25 (n35g \14\:n35g) resistor r=45 c=0
Rx24 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx36 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx37 (qbint \22\:qbint) resistor r=45 c=0
Rx20 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx28 (n35 \15\:n35) resistor r=45 c=0
Rx29 (\4\:n35 \16\:n35) resistor r=45 c=0
Rx43 (\3\:n35 \21\:n35) resistor r=45 c=0
Rx44 (qint \8\:qint) resistor r=45 c=0
mn22 (\14\:RNb \4\:RN \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn25 (n21 \1\:D \38\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\14\:n20 \7\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\12\:n20 \9\:CKbb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (n30 \3\:mout \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=7.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\14\:CKbb \11\:CKb \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (\3\:net426 \3\:SN \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=4.858e-14 ps=6.1e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\18\:CKb \1\:CK \36\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\13\:mout \6\:n20 \3\:net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn31 (\11\:mout RNb net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn40 (\9\:n35 \4\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
NM0 (\9\:n35g RTb \11\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM1 (\19\:qbint \4\:n35g \34\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0121 \5\:qbint \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\6\:RTb \5\:RT \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=3.81e-14 ps=5.7e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \4\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\19\:n35 \12\:CKb \3\:n40 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:qint \30\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.71058e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn56 (\5\:qint \14\:qbint \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn51 (n40 \8\:RNb \3\:n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.5e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn52 (n40 \12\:qbint n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn50 (n42 \10\:SN \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp25 (n22 \4\:D \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=8.07243 \
        scb=0.00427526 scc=2.63824e-05 m=(1)
mp26 (\18\:n20 \2\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=7.39501 \
        scb=0.00357259 scc=2.44217e-05 m=(1)
mp36 (\8\:n20 \9\:CKb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.035e-06 sd=160n sca=5.57121 \
        scb=0.00131629 scc=2.54339e-06 m=(1)
mp35 (n31 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=1.29e-14 ps=1.06e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=9.3e-07 sd=160n sca=5.28562 \
        scb=0.00121296 scc=2.51356e-06 m=(1)
mp21 (\18\:CKbb \4\:CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=6.48645 \
        scb=0.00312433 scc=2.40957e-05 m=(1)
mp30 (\15\:mout \1\:SN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.773e-14 ad=6.02e-14 ps=1.06e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=5.7e-07 sd=160n sca=5.15121 \
        scb=0.00118334 scc=2.51019e-06 m=(1)
mp20 (\16\:CKb \4\:CK \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=6.65589 \
        scb=0.00316356 scc=2.41007e-05 m=(1)
mp32 (\15\:mout \3\:n20 net402 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.02e-14 ps=5.5e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.3e-07 sb=2.45e-07 sd=160n sca=5.87142 \
        scb=0.00148933 scc=2.66395e-06 m=(1)
mp31 (net402 \7\:RNb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.035e-06 sb=1.4e-07 sd=160n sca=6.44121 \
        scb=0.00199344 scc=3.60278e-06 m=(1)
mp40 (\13\:n35 \8\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.6024 \
        scb=0.0252111 scc=0.00264936 m=(1)
PM0 (\7\:n35g \3\:RT \5\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.1589 \
        scb=0.0273077 scc=0.0026732 m=(1)
PM1 (\17\:qbint \3\:n35g \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\9\:RTb \6\:RT \11\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.4484 \
        scb=0.0260103 scc=0.00229228 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\17\:n35 \10\:CKbb \3\:n41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:qint \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=28.6983 \
        scb=0.0316799 scc=0.00295254 m=(1)
mp56 (\9\:qint \13\:qbint \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.5823 \
        scb=0.0110312 scc=0.000167593 m=(1)
mp51 (n43 \9\:RNb \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=9.47524 \
        scb=0.00528697 scc=3.19779e-05 m=(1)
mp52 (n41 \11\:qbint n43 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=10.003 \
        scb=0.00635741 scc=4.31501e-05 m=(1)
mp55 (\3\:Q \7\:qbint \11\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.9109 \
        scb=0.0151829 scc=0.000449446 m=(1)
mp50 (n41 \9\:SN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=15.4344 \
        scb=0.0162184 scc=0.000550454 m=(1)
ends RDFFSRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:53:08 2012 )
// Library name: gsclib045
// Cell name: RDFFSX1
// View name: extracted

simulator lang=spectre

subckt RDFFSX1 CK D ExtVDD Q QN RT SN VDD VSS
mp25 (n22 \3\:D \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.765 scb=0.015442 \
        scc=0.000354192 m=(1)
C1 (Q VSS) capacitor c=4.65747e-17
C2 (QN VSS) capacitor c=1.96672e-17
C3 (VDD VSS) capacitor c=6.01519e-16
C4 (ExtVDD VSS) capacitor c=1.98008e-16
C5 (SN VSS) capacitor c=3.45894e-17
C6 (D VSS) capacitor c=4.59943e-17
C7 (RT VSS) capacitor c=4.03153e-17
C8 (CKbb VSS) capacitor c=5.61608e-17
C9 (mout VSS) capacitor c=5.78803e-17
C10 (n20 VSS) capacitor c=9.49518e-17
C11 (CKb VSS) capacitor c=2.30701e-17
C12 (n35g VSS) capacitor c=1.77631e-17
C13 (qbint VSS) capacitor c=4.57835e-17
C14 (RTb VSS) capacitor c=5.17974e-17
C15 (qint VSS) capacitor c=2.23822e-17
C16 (n35 VSS) capacitor c=1.71459e-16
C17 (n41 VSS) capacitor c=8.43054e-17
C18 (net095 VSS) capacitor c=3.64524e-17
C19 (\7\:qbint VSS) capacitor c=4.57272e-17
C20 (\7\:SN VSS) capacitor c=6.7652e-17
C21 (\11\:qbint VSS) capacitor c=7.51396e-17
C22 (\13\:qbint VSS) capacitor c=4.73126e-17
C23 (\3\:qint VSS) capacitor c=5.98274e-17
C24 (\10\:CKbb VSS) capacitor c=4.51951e-17
C25 (\4\:RTb VSS) capacitor c=9.93379e-17
C26 (\6\:RT VSS) capacitor c=2.22322e-17
C27 (\4\:qbint VSS) capacitor c=5.36719e-17
C28 (\3\:n35g VSS) capacitor c=5.78469e-17
C29 (\5\:RT VSS) capacitor c=6.34884e-17
C30 (\9\:CKb VSS) capacitor c=1.07528e-16
C31 (\3\:n20 VSS) capacitor c=3.33207e-17
C32 (\4\:CK VSS) capacitor c=5.08947e-17
C33 (\5\:CKb VSS) capacitor c=5.01249e-17
C34 (\1\:SN VSS) capacitor c=3.80174e-17
C35 (\7\:CKb VSS) capacitor c=7.5352e-17
C36 (\2\:CKbb VSS) capacitor c=1.69781e-16
C37 (\3\:D VSS) capacitor c=7.32178e-17
C38 (\6\:qbint VSS) capacitor c=3.73527e-17
C39 (\8\:SN VSS) capacitor c=1.32068e-16
C40 (\12\:qbint VSS) capacitor c=1.03084e-16
C41 (\14\:qbint VSS) capacitor c=4.409e-17
C42 (\4\:qint VSS) capacitor c=3.97103e-17
C43 (\11\:CKb VSS) capacitor c=2.23087e-16
C44 (\8\:RT VSS) capacitor c=1.21584e-16
C45 (\2\:RT VSS) capacitor c=6.21796e-17
C46 (\5\:qbint VSS) capacitor c=3.89434e-17
C47 (\5\:n35g VSS) capacitor c=2.77014e-17
C48 (\2\:RTb VSS) capacitor c=4.64723e-17
C49 (\4\:CKbb VSS) capacitor c=2.68763e-17
C50 (\1\:CK VSS) capacitor c=2.9896e-17
C51 (\6\:n20 VSS) capacitor c=6.25701e-17
C52 (\6\:SN VSS) capacitor c=6.49368e-17
C53 (\8\:CKb VSS) capacitor c=2.55841e-17
C54 (\3\:mout VSS) capacitor c=4.54723e-17
C55 (\9\:CKbb VSS) capacitor c=5.02123e-17
C56 (\4\:CKb VSS) capacitor c=8.54588e-17
C57 (\1\:D VSS) capacitor c=4.8936e-17
C58 (\10\:qbint VSS) capacitor c=8.46667e-17
C59 (\11\:CKbb VSS) capacitor c=5.21898e-17
C60 (\3\:SN VSS) capacitor c=2.91746e-16
C61 (\9\:SN VSS) capacitor c=8.5775e-17
C62 (\7\:RT VSS) capacitor c=1.44822e-16
C63 (\8\:CKbb VSS) capacitor c=1.77344e-16
C64 (\3\:RT VSS) capacitor c=3.93687e-17
C65 (\1\:RT VSS) capacitor c=5.27398e-17
C66 (\3\:RTb VSS) capacitor c=7.62516e-17
C67 (\3\:qbint VSS) capacitor c=4.43966e-17
C68 (\2\:n35 VSS) capacitor c=2.61705e-16
C69 (\4\:n35g VSS) capacitor c=4.92289e-17
C70 (\10\:CKb VSS) capacitor c=5.81809e-17
C71 (\12\:CKb VSS) capacitor c=2.18386e-16
C72 (\3\:n35 VSS) capacitor c=1.21659e-16
C73 (\4\:n20 VSS) capacitor c=1.00822e-16
C74 (\7\:n20 VSS) capacitor c=5.45979e-17
C75 (\3\:CK VSS) capacitor c=2.3752e-17
C76 (\2\:SN VSS) capacitor c=4.32409e-17
C77 (\5\:SN VSS) capacitor c=2.7214e-17
C78 (\2\:mout VSS) capacitor c=4.87271e-17
C79 (\4\:mout VSS) capacitor c=3.16028e-17
C80 (\5\:n20 VSS) capacitor c=8.48635e-17
C81 (\2\:n20 VSS) capacitor c=6.50432e-17
C82 (\2\:D VSS) capacitor c=5.3898e-17
C83 (\3\:CKbb VSS) capacitor c=7.92929e-17
C84 (\7\:CKbb VSS) capacitor c=3.11267e-17
C85 (\1\:VDD VSS) capacitor c=4.34306e-17
C86 (\7\:VDD VSS) capacitor c=2.91304e-17
C87 (\3\:Q VSS) capacitor c=8.19964e-17
C88 (\9\:VDD VSS) capacitor c=5.32936e-17
C89 (\9\:qint VSS) capacitor c=5.21032e-17
C90 (\16\:VDD VSS) capacitor c=8.00185e-17
C91 (\3\:n41 VSS) capacitor c=8.40625e-17
C92 (\4\:QN VSS) capacitor c=6.13352e-17
C93 (\14\:n35 VSS) capacitor c=5.51304e-17
C94 (\15\:n35g VSS) capacitor c=5.61339e-17
C95 (\6\:RTb VSS) capacitor c=7.28405e-17
C96 (\1\:ExtVDD VSS) capacitor c=2.76866e-16
C97 (\9\:n35 VSS) capacitor c=6.2545e-17
C98 (\17\:qbint VSS) capacitor c=6.63155e-17
C99 (\6\:n35g VSS) capacitor c=8.96816e-17
C100 (\4\:n35 VSS) capacitor c=4.98817e-17
C101 (\5\:mout VSS) capacitor c=7.97773e-17
C102 (\14\:VDD VSS) capacitor c=4.70573e-17
C103 (\17\:CKb VSS) capacitor c=2.944e-17
C104 (\19\:mout VSS) capacitor c=4.30544e-17
C105 (\22\:VDD VSS) capacitor c=6.18264e-17
C106 (\16\:mout VSS) capacitor c=4.68513e-17
C107 (\18\:CKbb VSS) capacitor c=4.0758e-17
C108 (\20\:VDD VSS) capacitor c=5.39817e-17
C109 (\16\:n20 VSS) capacitor c=5.46513e-17
C110 (\8\:n20 VSS) capacitor c=2.50886e-17
C111 (\25\:VDD VSS) capacitor c=3.3432e-17
C112 (\1\:Q VSS) capacitor c=5.48952e-17
C113 (\5\:qint VSS) capacitor c=5.02519e-17
C114 (\3\:net095 VSS) capacitor c=4.63057e-17
C115 (\1\:QN VSS) capacitor c=4.97003e-17
C116 (\17\:n35 VSS) capacitor c=4.64399e-17
C117 (\11\:n35g VSS) capacitor c=2.98389e-17
C118 (\10\:RTb VSS) capacitor c=5.8314e-17
C119 (\12\:n35 VSS) capacitor c=6.36732e-17
C120 (\19\:qbint VSS) capacitor c=2.27954e-17
C121 (\9\:n35g VSS) capacitor c=8.03039e-17
C122 (\7\:n35 VSS) capacitor c=4.06032e-17
C123 (\11\:VDD VSS) capacitor c=2.02231e-16
C124 (\11\:mout VSS) capacitor c=2.1882e-17
C125 (\13\:CKb VSS) capacitor c=4.66382e-17
C126 (\13\:mout VSS) capacitor c=1.72205e-17
C127 (\14\:CKbb VSS) capacitor c=5.06922e-17
C128 (\14\:n20 VSS) capacitor c=7.12151e-17
C129 (\12\:n20 VSS) capacitor c=5.94694e-17
C130 (VDD VSS) capacitor c=6.81515e-18
C131 (\2\:CK VSS) capacitor c=3.3905e-17
C132 (\2\:CKb VSS) capacitor c=2.78157e-17
C133 (\3\:CKb VSS) capacitor c=5.65252e-17
C134 (\6\:CKb VSS) capacitor c=1.28996e-16
C135 (\2\:n35g VSS) capacitor c=3.38232e-17
C136 (ExtVDD VSS) capacitor c=3.93674e-17
C137 (\4\:RT VSS) capacitor c=4.60848e-17
C138 (\2\:qbint VSS) capacitor c=4.12181e-17
C139 (\5\:CKbb VSS) capacitor c=1.15856e-16
C140 (\6\:CKbb VSS) capacitor c=8.13517e-17
C141 (\4\:SN VSS) capacitor c=3.13305e-16
C142 (\2\:qint VSS) capacitor c=1.74642e-17
C143 (\12\:CKbb VSS) capacitor c=5.3132e-17
C144 (\13\:CKbb VSS) capacitor c=6.96089e-17
C145 (\8\:qbint VSS) capacitor c=3.96385e-17
C146 (\9\:qbint VSS) capacitor c=6.40376e-17
C147 (\10\:n20 VSS) capacitor c=4.04322e-17
C148 (\11\:n20 VSS) capacitor c=6.26569e-17
C149 (\18\:n20 VSS) capacitor c=3.51348e-17
C150 (\17\:CKbb VSS) capacitor c=7.2514e-17
C151 (\10\:SN VSS) capacitor c=2.92929e-17
C152 (\11\:SN VSS) capacitor c=4.45444e-17
C153 (\5\:CK VSS) capacitor c=4.57027e-17
C154 (\6\:CK VSS) capacitor c=3.44482e-17
C155 (\15\:CKb VSS) capacitor c=4.82739e-17
C156 (\16\:CKb VSS) capacitor c=4.97003e-17
C157 (\19\:n20 VSS) capacitor c=5.19461e-17
C158 (\20\:n20 VSS) capacitor c=6.01353e-17
C159 (\7\:mout VSS) capacitor c=7.2852e-17
C160 (\8\:mout VSS) capacitor c=3.59356e-17
C161 (\9\:mout VSS) capacitor c=7.07298e-17
C162 (\10\:mout VSS) capacitor c=7.54819e-17
C163 (\15\:mout VSS) capacitor c=6.90564e-17
C164 (\18\:mout VSS) capacitor c=6.69458e-17
C165 (\6\:n35 VSS) capacitor c=6.55097e-17
C166 (\19\:CKb VSS) capacitor c=2.96864e-17
C167 (\20\:CKb VSS) capacitor c=3.2633e-17
C168 (\8\:n35g VSS) capacitor c=2.94004e-17
C169 (\11\:n35 VSS) capacitor c=7.53835e-17
C170 (\15\:qbint VSS) capacitor c=8.81276e-17
C171 (\16\:qbint VSS) capacitor c=1.09674e-16
C172 (\13\:n35g VSS) capacitor c=1.02088e-16
C173 (\14\:n35g VSS) capacitor c=1.16145e-16
C174 (\5\:RTb VSS) capacitor c=4.97134e-17
C175 (\8\:RTb VSS) capacitor c=9.95416e-17
C176 (\9\:RTb VSS) capacitor c=9.15552e-17
C177 (\12\:SN VSS) capacitor c=8.3139e-17
C178 (\13\:SN VSS) capacitor c=7.95586e-17
C179 (\20\:CKbb VSS) capacitor c=1.32993e-16
C180 (\21\:CKbb VSS) capacitor c=1.3649e-16
C181 (\21\:qbint VSS) capacitor c=2.38824e-17
C182 (\22\:qbint VSS) capacitor c=3.00681e-17
C183 (\9\:RT VSS) capacitor c=1.10054e-16
C184 (\10\:RT VSS) capacitor c=1.18375e-16
C185 (\11\:RT VSS) capacitor c=5.90308e-17
C186 (\3\:QN VSS) capacitor c=3.1398e-17
C187 (\16\:n35 VSS) capacitor c=4.37128e-17
C188 (\7\:qint VSS) capacitor c=4.81071e-17
C189 (\8\:qint VSS) capacitor c=3.73536e-17
C190 (\3\:VDD VSS) capacitor c=2.37673e-17
C191 (\4\:VDD VSS) capacitor c=2.95816e-17
C192 (\6\:VDD VSS) capacitor c=2.38089e-16
C193 (\13\:VDD VSS) capacitor c=1.71403e-17
C194 (\19\:VDD VSS) capacitor c=3.58549e-17
C195 (\24\:VDD VSS) capacitor c=3.48674e-17
Rk68 (\2\:Q Q) resistor r=0.1661 c=0
Rk69 (Q \4\:Q) resistor r=0.3331 c=0
Rk59 (\3\:QN QN) resistor r=0.04076 c=0
Rk58 (\2\:QN \3\:QN) resistor r=0.3192 c=0
Rk60 (\3\:QN \5\:QN) resistor r=0.231 c=0
Rk86 (\2\:VDD \3\:VDD) resistor r=0.3801 c=0
Rk87 (\3\:VDD \4\:VDD) resistor r=0.1956 c=0
Rk88 (\4\:VDD \6\:VDD) resistor r=0.1088 c=0
Rk89 (\3\:VDD \8\:VDD) resistor r=0.3184 c=0
Rk90 (\4\:VDD \10\:VDD) resistor r=0.301 c=0
Rk91 (\6\:VDD \12\:VDD) resistor r=1.6233 c=0
Rk92 (\12\:VDD \13\:VDD) resistor r=0.07661 c=0
Rk93 (\13\:VDD \15\:VDD) resistor r=0.2736 c=0
Rk94 (\6\:VDD \17\:VDD) resistor r=0.4059 c=0
Rk95 (\13\:VDD \18\:VDD) resistor r=0.1612 c=0
Rk99 (\19\:VDD VDD) resistor r=0.1011 c=0
Rk96 (\18\:VDD \19\:VDD) resistor r=0.176 c=0
Rk97 (\19\:VDD \21\:VDD) resistor r=0.275 c=0
Rk98 (\18\:VDD \23\:VDD) resistor r=0.4248 c=0
Rk100 (VDD \24\:VDD) resistor r=0.1462 c=0
Rk101 (\24\:VDD VDD) resistor r=0.08875 c=0
Rk102 (\24\:VDD \26\:VDD) resistor r=0.3582 c=0
Rk39 (ExtVDD ExtVDD) resistor r=0.00206 c=0
Rk37 (\2\:ExtVDD ExtVDD) resistor r=0.02213 c=0
Rk40 (ExtVDD \5\:ExtVDD) resistor r=0.02012 c=0
Rk41 (ExtVDD \6\:ExtVDD) resistor r=0.1017 c=0
Rk11 (\10\:SN SN) resistor r=0.02815 c=0
Rk12 (SN \11\:SN) resistor r=0.04821 c=0
Rk52 (\12\:SN \13\:SN) resistor r=0.5353 c=0
Rk70 (\2\:VSS \4\:VSS) resistor r=0.361 c=0
Rk71 (\4\:VSS \5\:VSS) resistor r=0.2377 c=0
Rk72 (\5\:VSS \6\:VSS) resistor r=0.5548 c=0
Rk73 (\6\:VSS \7\:VSS) resistor r=0.1163 c=0
Rk75 (\8\:VSS VSS) resistor r=0.07141 c=0
Rk74 (\7\:VSS \8\:VSS) resistor r=0.2077 c=0
Rk77 (\9\:VSS VSS) resistor r=0.1187 c=0
Rk76 (VSS \9\:VSS) resistor r=0.7435 c=0
Rk78 (VSS \10\:VSS) resistor r=0.03722 c=0
Rk79 (\10\:VSS \11\:VSS) resistor r=0.4233 c=0
Rk80 (\11\:VSS \12\:VSS) resistor r=0.06422 c=0
Rk81 (\5\:VSS \14\:VSS) resistor r=0.2634 c=0
Rk82 (\7\:VSS \16\:VSS) resistor r=0.189 c=0
Rk83 (\8\:VSS \18\:VSS) resistor r=0.194 c=0
Rk84 (\10\:VSS \20\:VSS) resistor r=0.2362 c=0
Rk85 (\11\:VSS \22\:VSS) resistor r=0.228 c=0
Rk103 (\24\:VSS \26\:VSS) resistor r=0.6173 c=0
Rk104 (\26\:VSS \27\:VSS) resistor r=0.5651 c=0
Rk106 (\28\:VSS VSS) resistor r=0.0493 c=0
Rk105 (\27\:VSS \28\:VSS) resistor r=0.2773 c=0
Rk108 (\29\:VSS VSS) resistor r=0.1212 c=0
Rk107 (VSS \29\:VSS) resistor r=0.8426 c=0
Rk109 (VSS \31\:VSS) resistor r=0.3938 c=0
Rk110 (\27\:VSS \33\:VSS) resistor r=0.2432 c=0
Rk13 (CK \5\:CK) resistor r=0.004349 c=0
Rk15 (\5\:CK \6\:CK) resistor r=0.01544 c=0
Rk14 (\6\:CK \7\:CK) resistor r=0.004531 c=0
Rk2 (\4\:D D) resistor r=0.006851 c=0
Rk55 (RT \9\:RT) resistor r=0.1921 c=0
Rk56 (\9\:RT \10\:RT) resistor r=0.6456 c=0
Rk57 (RT \11\:RT) resistor r=0.007548 c=0
Rk1 (\12\:CKbb \13\:CKbb) resistor r=0.6152 c=0
Rk8 (\15\:CKbb \16\:CKbb) resistor r=0.3458 c=0
Rk9 (\16\:CKbb \17\:CKbb) resistor r=0.01512 c=0
Rk10 (\16\:CKbb \19\:CKbb) resistor r=0.2066 c=0
Rk53 (\20\:CKbb \21\:CKbb) resistor r=0.8256 c=0
Rk20 (\6\:mout \7\:mout) resistor r=0.5286 c=0
Rk21 (\7\:mout \8\:mout) resistor r=0.296 c=0
Rk22 (\8\:mout \9\:mout) resistor r=0.1024 c=0
Rk23 (\9\:mout \10\:mout) resistor r=0.3332 c=0
Rk24 (\7\:mout \12\:mout) resistor r=0.1277 c=0
Rk25 (\8\:mout \14\:mout) resistor r=0.09184 c=0
Rk26 (\9\:mout \15\:mout) resistor r=0.4802 c=0
Rk27 (\15\:mout \17\:mout) resistor r=0.04478 c=0
Rk28 (\10\:mout \18\:mout) resistor r=0.3474 c=0
Rk29 (\15\:mout \20\:mout) resistor r=0.0346 c=0
Rk3 (\9\:n20 \10\:n20) resistor r=0.192 c=0
Rk4 (\9\:n20 \11\:n20) resistor r=0.2102 c=0
Rk5 (\11\:n20 \13\:n20) resistor r=0.3758 c=0
Rk6 (\15\:n20 \17\:n20) resistor r=0.4882 c=0
Rk7 (\17\:n20 \18\:n20) resistor r=0.144 c=0
Rk19 (\19\:n20 \20\:n20) resistor r=0.2684 c=0
Rk16 (\14\:CKb \15\:CKb) resistor r=0.336 c=0
Rk17 (\15\:CKb \16\:CKb) resistor r=0.1631 c=0
Rk18 (\15\:CKb \18\:CKb) resistor r=0.2008 c=0
Rk32 (\19\:CKb \20\:CKb) resistor r=0.2995 c=0
Rk33 (\7\:n35g \8\:n35g) resistor r=0.2405 c=0
Rk34 (\7\:n35g \10\:n35g) resistor r=0.6908 c=0
Rk45 (\12\:n35g \13\:n35g) resistor r=0.2427 c=0
Rk46 (\13\:n35g \14\:n35g) resistor r=0.5649 c=0
Rk47 (\13\:n35g \16\:n35g) resistor r=0.4315 c=0
Rk42 (\15\:qbint \16\:qbint) resistor r=0.494 c=0
Rk43 (\16\:qbint \18\:qbint) resistor r=0.5666 c=0
Rk44 (\16\:qbint \20\:qbint) resistor r=0.1462 c=0
Rk54 (\21\:qbint \22\:qbint) resistor r=0.2116 c=0
Rk48 (\5\:RTb \7\:RTb) resistor r=0.216 c=0
Rk49 (\7\:RTb \8\:RTb) resistor r=0.4161 c=0
Rk50 (\8\:RTb \9\:RTb) resistor r=0.6878 c=0
Rk51 (\8\:RTb \11\:RTb) resistor r=0.3063 c=0
Rk63 (\6\:qint \7\:qint) resistor r=0.2809 c=0
Rk64 (\7\:qint \8\:qint) resistor r=0.1613 c=0
Rk65 (\7\:qint \10\:qint) resistor r=0.2563 c=0
Rk30 (\5\:n35 \6\:n35) resistor r=0.3334 c=0
Rk31 (\6\:n35 \8\:n35) resistor r=0.29 c=0
Rk35 (\10\:n35 \11\:n35) resistor r=0.4005 c=0
Rk36 (\11\:n35 \13\:n35) resistor r=0.3296 c=0
Rk61 (\15\:n35 \16\:n35) resistor r=0.3034 c=0
Rk62 (\16\:n35 \18\:n35) resistor r=0.2745 c=0
Rk67 (\2\:n41 \4\:n41) resistor r=0.6522 c=0
Rk66 (\2\:net095 \4\:net095) resistor r=0.2045 c=0
Rl54 (\7\:SN \8\:SN) resistor r=234.813 c=0
Rl55 (\8\:SN \9\:SN) resistor r=434.764 c=0
Rl8 (\1\:SN \2\:SN) resistor r=24.2328 c=0
Rl46 (\4\:SN \6\:SN) resistor r=95.229 c=0
Rl44 (\3\:SN \4\:SN) resistor r=1126.2 c=0
Rl45 (\4\:SN \5\:SN) resistor r=14.5488 c=0
Rl11 (\2\:CK \4\:CK) resistor r=147.791 c=0
Rl9 (\1\:CK \2\:CK) resistor r=63.1757 c=0
Rl10 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl2 (\2\:D \3\:D) resistor r=108.118 c=0
Rl1 (\1\:D \2\:D) resistor r=70.6183 c=0
Rl43 (\7\:RT \8\:RT) resistor r=651.902 c=0
Rl30 (\1\:RT \2\:RT) resistor r=169.515 c=0
Rl33 (\4\:RT \6\:RT) resistor r=21.372 c=0
Rl32 (\4\:RT \5\:RT) resistor r=264.027 c=0
Rl31 (\3\:RT \4\:RT) resistor r=96.114 c=0
Rl6 (CKbb \2\:CKbb) resistor r=169.108 c=0
Rl49 (\10\:CKbb \11\:CKbb) resistor r=166.412 c=0
Rl7 (\2\:CKbb \3\:CKbb) resistor r=446.586 c=0
Rl38 (\4\:CKbb \5\:CKbb) resistor r=66.1349 c=0
Rl41 (\5\:CKbb \8\:CKbb) resistor r=794.708 c=0
Rl42 (\6\:CKbb \9\:CKbb) resistor r=66.8717 c=0
Rl40 (\6\:CKbb \7\:CKbb) resistor r=129.238 c=0
Rl39 (\5\:CKbb \6\:CKbb) resistor r=430.133 c=0
Rl4 (mout \2\:mout) resistor r=24.2328 c=0
Rl5 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl12 (\3\:n20 \4\:n20) resistor r=24.848 c=0
Rl14 (\6\:n20 \7\:n20) resistor r=105.531 c=0
Rl13 (\4\:n20 \5\:n20) resistor r=281.721 c=0
Rl3 (n20 \2\:n20) resistor r=236.609 c=0
Rl23 (\9\:CKb \10\:CKb) resistor r=196.122 c=0
Rl50 (\11\:CKb \12\:CKb) resistor r=870.726 c=0
Rl15 (CKb \2\:CKb) resistor r=1.2334 c=0
Rl18 (\2\:CKb \5\:CKb) resistor r=60.4181 c=0
Rl21 (\3\:CKb \8\:CKb) resistor r=69.2058 c=0
Rl17 (\3\:CKb \4\:CKb) resistor r=236.258 c=0
Rl16 (\2\:CKb \3\:CKb) resistor r=75.7777 c=0
Rl22 (\6\:CKb \9\:CKb) resistor r=422.225 c=0
Rl19 (\5\:CKb \6\:CKb) resistor r=292.264 c=0
Rl20 (\6\:CKb \7\:CKb) resistor r=113.702 c=0
Rl26 (\3\:n35g \4\:n35g) resistor r=250.512 c=0
Rl24 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl25 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl27 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl56 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl61 (\11\:qbint \12\:qbint) resistor r=252.671 c=0
Rl63 (\13\:qbint \14\:qbint) resistor r=199.892 c=0
Rl37 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl34 (qbint \2\:qbint) resistor r=112.732 c=0
Rl36 (\2\:qbint \4\:qbint) resistor r=70.093 c=0
Rl35 (\2\:qbint \3\:qbint) resistor r=152.601 c=0
Rl57 (\7\:qbint \8\:qbint) resistor r=135.6 c=0
Rl60 (\8\:qbint \11\:qbint) resistor r=180.657 c=0
Rl62 (\9\:qbint \13\:qbint) resistor r=90.3157 c=0
Rl59 (\9\:qbint \10\:qbint) resistor r=387.298 c=0
Rl58 (\8\:qbint \9\:qbint) resistor r=68.3971 c=0
Rl28 (RTb \2\:RTb) resistor r=112.412 c=0
Rl29 (\3\:RTb \4\:RTb) resistor r=239.402 c=0
Rl51 (qint \2\:qint) resistor r=3.1216 c=0
Rl52 (\2\:qint \3\:qint) resistor r=56.4891 c=0
Rl53 (\2\:qint \4\:qint) resistor r=85.455 c=0
Rl47 (n35 \2\:n35) resistor r=508.667 c=0
Rl48 (\2\:n35 \3\:n35) resistor r=367.189 c=0
Rz19 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz14 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz27 (\11\:VDD \12\:VDD) resistor r=25 c=0
Rz28 (\11\:VDD \18\:VDD) resistor r=15 c=0
Rz20 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz21 (\13\:VSS \14\:VSS) resistor r=37.5 c=0
Rz22 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz23 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz24 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz25 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz29 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz30 (\30\:VSS \31\:VSS) resistor r=37.5 c=0
Rz31 (\32\:VSS \33\:VSS) resistor r=75 c=0
Rz3 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz5 (\11\:mout \12\:mout) resistor r=75 c=0
Rz6 (\13\:mout \14\:mout) resistor r=75 c=0
Rz1 (\12\:n20 \13\:n20) resistor r=75 c=0
Rz2 (\14\:n20 \15\:n20) resistor r=75 c=0
Rz4 (\13\:CKb \14\:CKb) resistor r=75 c=0
Rz8 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz12 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz11 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz13 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz16 (\5\:qint \6\:qint) resistor r=75 c=0
Rz7 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz9 (\12\:n35 \13\:n35) resistor r=75 c=0
Rz15 (\17\:n35 \18\:n35) resistor r=75 c=0
Rz17 (net095 \2\:net095) resistor r=75 c=0
Rz18 (\3\:net095 \4\:net095) resistor r=75 c=0
Ry22 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry17 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry27 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry28 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry29 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry30 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry31 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry32 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry33 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry34 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry11 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry12 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry23 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry24 (\3\:VSS \6\:VSS) resistor r=5.6364 c=0
Ry25 (\3\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry26 (\3\:VSS \12\:VSS) resistor r=62 c=0
Ry35 (\25\:VSS \26\:VSS) resistor r=5.6364 c=0
Ry36 (\25\:VSS \28\:VSS) resistor r=10.3333 c=0
Ry37 (\25\:VSS \29\:VSS) resistor r=5.1667 c=0
Ry3 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry5 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\16\:mout \17\:mout) resistor r=62 c=0
Ry7 (\19\:mout \20\:mout) resistor r=62 c=0
Ry1 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry2 (\16\:n20 \17\:n20) resistor r=62 c=0
Ry4 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry9 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry16 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry19 (\9\:qint \10\:qint) resistor r=62 c=0
Ry8 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry10 (\9\:n35 \10\:n35) resistor r=62 c=0
Ry18 (\14\:n35 \15\:n35) resistor r=62 c=0
Ry20 (n41 \2\:n41) resistor r=62 c=0
Ry21 (\3\:n41 \4\:n41) resistor r=62 c=0
Rx8 (\5\:SN \10\:SN) resistor r=45 c=0
Rx9 (\2\:SN \11\:SN) resistor r=45 c=0
Rx25 (\3\:SN \12\:SN) resistor r=45 c=0
Rx26 (\9\:SN \13\:SN) resistor r=45 c=0
Rx10 (\3\:CK \7\:CK) resistor r=45 c=0
Rx3 (\2\:D \4\:D) resistor r=45 c=0
Rx31 (\3\:RT \9\:RT) resistor r=45 c=0
Rx32 (\1\:RT \10\:RT) resistor r=45 c=0
Rx33 (\7\:RT \11\:RT) resistor r=45 c=0
Rx1 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx2 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx7 (CKbb \17\:CKbb) resistor r=45 c=0
Rx27 (\11\:CKbb \20\:CKbb) resistor r=45 c=0
Rx28 (\8\:CKbb \21\:CKbb) resistor r=45 c=0
Rx14 (\4\:mout \10\:mout) resistor r=45 c=0
Rx15 (\2\:mout \18\:mout) resistor r=45 c=0
Rx4 (\2\:n20 \10\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \11\:n20) resistor r=45 c=0
Rx6 (n20 \18\:n20) resistor r=45 c=0
Rx12 (\4\:n20 \19\:n20) resistor r=45 c=0
Rx13 (\7\:n20 \20\:n20) resistor r=45 c=0
Rx11 (CKb \16\:CKb) resistor r=45 c=0
Rx17 (\10\:CKb \19\:CKb) resistor r=45 c=0
Rx18 (\12\:CKb \20\:CKb) resistor r=45 c=0
Rx19 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx22 (n35g \14\:n35g) resistor r=45 c=0
Rx21 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx29 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx30 (qbint \22\:qbint) resistor r=45 c=0
Rx23 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx24 (RTb \9\:RTb) resistor r=45 c=0
Rx35 (qint \8\:qint) resistor r=45 c=0
Rx16 (\3\:n35 \6\:n35) resistor r=45 c=0
Rx20 (\2\:n35 \11\:n35) resistor r=45 c=0
Rx34 (n35 \16\:n35) resistor r=45 c=0
mn25 (n21 \1\:D \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\14\:n20 \4\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\12\:n20 \9\:CKbb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.3e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn35 (n30 \3\:mout \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=6.25e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn21 (\14\:CKbb \8\:CKb \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (net426 \6\:SN \30\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.858e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2.45e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn32 (\13\:mout \6\:n20 net426 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn20 (\13\:CKb \1\:CK \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\7\:n35 \4\:CKbb \11\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
NM0 (\9\:n35g \2\:RTb \12\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM1 (\19\:qbint \5\:n35g \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0121 \5\:qbint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \2\:RT \32\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM2 (\11\:n35g \8\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\17\:n35 \11\:CKb \3\:net095 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:qint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.71058e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mn56 (\5\:qint \14\:qbint \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=13.9854 \
        scb=0.014728 scc=0.000819645 m=(1)
mn52 (net095 \12\:qbint n42 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn50 (n42 \8\:SN \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp26 (\16\:n20 \2\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3011 \
        scb=0.0111155 scc=0.000221731 m=(1)
mp36 (\8\:n20 \7\:CKb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=8.20139 \
        scb=0.00436827 scc=2.20651e-05 m=(1)
mp35 (n31 mout \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.45e-07 sd=160n sca=7.36777 \
        scb=0.00335337 scc=1.75985e-05 m=(1)
mp30 (\16\:mout \1\:SN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=6.506 scb=0.00275822 \
        scc=1.68594e-05 m=(1)
mp21 (\18\:CKbb \5\:CKb \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.20941 \
        scb=0.00769844 scc=0.000197343 m=(1)
mp20 (\17\:CKb \4\:CK \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=9.52288 \
        scb=0.00778605 scc=0.000197359 m=(1)
mp32 (\19\:mout \3\:n20 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.97126 \
        scb=0.00301321 scc=1.70301e-05 m=(1)
mp40 (\4\:n35 \9\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.2199 \
        scb=0.0159497 scc=0.000584328 m=(1)
PM0 (\6\:n35g \5\:RT \9\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.9081 \
        scb=0.0254417 scc=0.00265047 m=(1)
PM1 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=1.29e-14 ps=3.6e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.5295 \
        scb=0.0144143 scc=0.000486924 m=(1)
mp45 (\6\:RTb \6\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.5882e-13 ad=3.01e-14 ps=3.6e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=1.4e-07 sd=160n sca=23.1976 \
        scb=0.0241443 scc=0.00226956 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.2796 \
        scb=0.0259458 scc=0.00265434 m=(1)
mp53 (\14\:n35 \10\:CKbb \3\:n41 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:qint \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=28.6983 \
        scb=0.0316799 scc=0.00295254 m=(1)
mp56 (\9\:qint \13\:qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.5253 \
        scb=0.0111823 scc=0.000178214 m=(1)
mp52 (n41 \11\:qbint \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.03004 \
        scb=0.00480371 scc=3.05185e-05 m=(1)
mp50 (n41 \7\:SN \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1714 \
        scb=0.00703773 scc=5.55028e-05 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2477 \
        scb=0.0122427 scc=0.000351334 m=(1)
ends RDFFSX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:53:58 2012 )
// Library name: gsclib045
// Cell name: RDFFX1
// View name: extracted

simulator lang=spectre

subckt RDFFX1 CK D ExtVDD Q QN RT VDD VSS
mp25 (n22 \4\:D \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.9347 \
        scb=0.0157363 scc=0.000368461 m=(1)
C1 (Q VSS) capacitor c=4.96911e-17
C2 (ExtVDD VSS) capacitor c=1.25718e-16
C3 (RT VSS) capacitor c=3.12155e-17
C4 (D VSS) capacitor c=2.91654e-17
C5 (QN VSS) capacitor c=3.03652e-17
C6 (VDD VSS) capacitor c=4.84701e-16
C7 (CKbb VSS) capacitor c=5.07473e-17
C8 (n20 VSS) capacitor c=4.5364e-17
C9 (mout VSS) capacitor c=5.65999e-17
C10 (n35 VSS) capacitor c=1.4616e-16
C11 (CKb VSS) capacitor c=3.42309e-16
C12 (n35g VSS) capacitor c=1.77389e-17
C13 (qbint VSS) capacitor c=4.82587e-17
C14 (RTb VSS) capacitor c=3.93753e-17
C15 (qint VSS) capacitor c=2.24871e-17
C16 (\7\:qbint VSS) capacitor c=4.98703e-17
C17 (\11\:qbint VSS) capacitor c=4.52676e-17
C18 (\13\:qbint VSS) capacitor c=1.41168e-16
C19 (\3\:qint VSS) capacitor c=5.93993e-17
C20 (\10\:CKbb VSS) capacitor c=8.72864e-17
C21 (\4\:RTb VSS) capacitor c=9.84044e-17
C22 (\8\:RT VSS) capacitor c=2.17453e-17
C23 (\4\:qbint VSS) capacitor c=6.83431e-17
C24 (\3\:n35g VSS) capacitor c=4.82887e-17
C25 (\6\:RT VSS) capacitor c=7.62267e-17
C26 (\7\:CKb VSS) capacitor c=2.84412e-17
C27 (\4\:CK VSS) capacitor c=3.38256e-17
C28 (\3\:n20 VSS) capacitor c=5.75688e-17
C29 (\3\:CKb VSS) capacitor c=5.98797e-17
C30 (\10\:CKb VSS) capacitor c=9.54034e-17
C31 (\2\:CKbb VSS) capacitor c=1.22497e-16
C32 (\4\:D VSS) capacitor c=6.42091e-17
C33 (\6\:qbint VSS) capacitor c=3.82813e-17
C34 (\12\:qbint VSS) capacitor c=4.59284e-17
C35 (\14\:qbint VSS) capacitor c=9.13732e-17
C36 (\4\:qint VSS) capacitor c=3.78602e-17
C37 (\7\:RT VSS) capacitor c=1.66265e-16
C38 (\1\:RT VSS) capacitor c=4.42713e-17
C39 (\5\:qbint VSS) capacitor c=3.90657e-17
C40 (\5\:n35g VSS) capacitor c=2.84697e-17
C41 (\8\:CKbb VSS) capacitor c=2.92085e-17
C42 (\1\:CK VSS) capacitor c=3.80188e-17
C43 (\6\:n20 VSS) capacitor c=5.10978e-17
C44 (\8\:CKb VSS) capacitor c=2.41108e-17
C45 (\3\:mout VSS) capacitor c=4.90535e-17
C46 (\9\:CKbb VSS) capacitor c=5.01972e-17
C47 (\5\:CKb VSS) capacitor c=8.54646e-17
C48 (\1\:D VSS) capacitor c=5.16777e-17
C49 (\11\:CKbb VSS) capacitor c=5.64291e-17
C50 (\4\:CKbb VSS) capacitor c=1.27447e-16
C51 (\10\:qbint VSS) capacitor c=5.79977e-17
C52 (\3\:RT VSS) capacitor c=1.67472e-16
C53 (\3\:RTb VSS) capacitor c=7.34091e-17
C54 (\4\:RT VSS) capacitor c=4.32411e-17
C55 (\2\:RT VSS) capacitor c=3.89058e-17
C56 (\3\:qbint VSS) capacitor c=3.52588e-17
C57 (\2\:RTb VSS) capacitor c=4.00519e-17
C58 (\2\:n35 VSS) capacitor c=1.65829e-16
C59 (\4\:n35g VSS) capacitor c=6.81327e-17
C60 (\3\:n35 VSS) capacitor c=4.35542e-17
C61 (\3\:CK VSS) capacitor c=2.6485e-17
C62 (\9\:CKb VSS) capacitor c=8.7458e-17
C63 (\2\:mout VSS) capacitor c=3.86154e-17
C64 (\4\:mout VSS) capacitor c=4.0206e-17
C65 (\5\:n20 VSS) capacitor c=4.33766e-17
C66 (\2\:n20 VSS) capacitor c=4.08892e-17
C67 (\3\:CKbb VSS) capacitor c=6.09962e-17
C68 (\7\:CKbb VSS) capacitor c=3.01016e-17
C69 (\3\:D VSS) capacitor c=1.34087e-17
C70 (\1\:VDD VSS) capacitor c=4.83252e-17
C71 (\3\:Q VSS) capacitor c=8.43461e-17
C72 (\9\:qint VSS) capacitor c=5.46365e-17
C73 (\11\:VDD VSS) capacitor c=2.50873e-17
C74 (\13\:VDD VSS) capacitor c=7.93185e-17
C75 (\4\:QN VSS) capacitor c=5.47187e-17
C76 (\15\:n35 VSS) capacitor c=4.34926e-17
C77 (\15\:n35g VSS) capacitor c=4.65303e-17
C78 (\6\:RTb VSS) capacitor c=5.77496e-17
C79 (\1\:ExtVDD VSS) capacitor c=2.902e-16
C80 (\10\:n35 VSS) capacitor c=5.11249e-17
C81 (\17\:qbint VSS) capacitor c=6.81348e-17
C82 (\6\:n35g VSS) capacitor c=8.75619e-17
C83 (\4\:n35 VSS) capacitor c=4.00017e-17
C84 (\13\:CKb VSS) capacitor c=6.0322e-17
C85 (\5\:mout VSS) capacitor c=5.94436e-17
C86 (\15\:VDD VSS) capacitor c=7.07754e-17
C87 (\17\:VDD VSS) capacitor c=5.98691e-17
C88 (\18\:CKbb VSS) capacitor c=4.70578e-17
C89 (\13\:n20 VSS) capacitor c=4.6032e-17
C90 (\9\:n20 VSS) capacitor c=8.87024e-17
C91 (\20\:VDD VSS) capacitor c=3.50156e-17
C92 (\3\:VDD VSS) capacitor c=2.53057e-16
C93 (\1\:Q VSS) capacitor c=5.493e-17
C94 (\5\:qint VSS) capacitor c=4.69544e-17
C95 (\1\:QN VSS) capacitor c=4.71067e-17
C96 (\18\:n35 VSS) capacitor c=6.04504e-17
C97 (\11\:n35g VSS) capacitor c=2.94918e-17
C98 (\10\:RTb VSS) capacitor c=5.97655e-17
C99 (\13\:n35 VSS) capacitor c=5.58349e-17
C100 (\19\:qbint VSS) capacitor c=2.37261e-17
C101 (\9\:n35g VSS) capacitor c=7.65622e-17
C102 (\7\:n35 VSS) capacitor c=4.4942e-17
C103 (\15\:CKb VSS) capacitor c=3.64522e-17
C104 (\10\:mout VSS) capacitor c=5.24732e-17
C105 (\14\:CKbb VSS) capacitor c=4.85295e-17
C106 (\16\:n20 VSS) capacitor c=4.3754e-17
C107 (\7\:n20 VSS) capacitor c=7.43575e-17
C108 (\2\:D VSS) capacitor c=4.34399e-17
C109 (\4\:n20 VSS) capacitor c=4.72351e-17
C110 (\2\:CK VSS) capacitor c=3.29059e-17
C111 (\2\:n35g VSS) capacitor c=3.01491e-17
C112 (ExtVDD VSS) capacitor c=3.95231e-17
C113 (\2\:qbint VSS) capacitor c=4.00745e-17
C114 (\5\:RT VSS) capacitor c=5.09193e-17
C115 (\5\:CKbb VSS) capacitor c=1.09059e-16
C116 (\6\:CKbb VSS) capacitor c=4.17719e-17
C117 (\2\:CKb VSS) capacitor c=2.5808e-16
C118 (\6\:CKb VSS) capacitor c=4.07593e-17
C119 (\2\:qint VSS) capacitor c=1.77293e-17
C120 (\8\:qbint VSS) capacitor c=5.52645e-17
C121 (\9\:qbint VSS) capacitor c=1.32569e-16
C122 (\12\:CKbb VSS) capacitor c=9.75358e-17
C123 (\13\:CKbb VSS) capacitor c=8.61806e-17
C124 (\6\:D VSS) capacitor c=2.54436e-17
C125 (\11\:n20 VSS) capacitor c=3.77514e-17
C126 (\12\:n20 VSS) capacitor c=5.21768e-17
C127 (\15\:n20 VSS) capacitor c=5.25701e-17
C128 (\17\:CKbb VSS) capacitor c=7.85137e-17
C129 (\7\:mout VSS) capacitor c=4.29254e-17
C130 (\8\:mout VSS) capacitor c=2.73299e-17
C131 (\9\:mout VSS) capacitor c=2.48939e-17
C132 (\12\:mout VSS) capacitor c=2.48691e-17
C133 (\5\:CK VSS) capacitor c=3.73727e-17
C134 (\7\:CK VSS) capacitor c=3.74671e-18
C135 (\8\:CK VSS) capacitor c=4.30026e-17
C136 (\11\:CKb VSS) capacitor c=5.13192e-17
C137 (\12\:CKb VSS) capacitor c=4.42148e-17
C138 (\6\:n35 VSS) capacitor c=6.84178e-17
C139 (\9\:n35 VSS) capacitor c=6.21697e-17
C140 (\8\:n35g VSS) capacitor c=3.19866e-17
C141 (\12\:n35 VSS) capacitor c=6.04519e-17
C142 (\15\:qbint VSS) capacitor c=8.88704e-17
C143 (\16\:qbint VSS) capacitor c=1.10799e-16
C144 (\13\:n35g VSS) capacitor c=1.13129e-16
C145 (\14\:n35g VSS) capacitor c=1.16555e-16
C146 (\9\:RT VSS) capacitor c=6.28792e-17
C147 (\10\:RT VSS) capacitor c=6.14517e-17
C148 (\5\:RTb VSS) capacitor c=3.67772e-17
C149 (\8\:RTb VSS) capacitor c=1.11714e-16
C150 (\9\:RTb VSS) capacitor c=6.96605e-17
C151 (\11\:RT VSS) capacitor c=4.13191e-17
C152 (\21\:qbint VSS) capacitor c=2.90362e-17
C153 (\22\:qbint VSS) capacitor c=3.10729e-17
C154 (\20\:CKbb VSS) capacitor c=1.30164e-16
C155 (\21\:CKbb VSS) capacitor c=9.80016e-17
C156 (\3\:QN VSS) capacitor c=3.33376e-17
C157 (\17\:n35 VSS) capacitor c=6.15631e-17
C158 (\7\:qint VSS) capacitor c=5.19529e-17
C159 (\8\:qint VSS) capacitor c=3.63154e-17
C160 (\5\:VDD VSS) capacitor c=1.5381e-17
C161 (\6\:VDD VSS) capacitor c=9.63787e-18
C162 (\8\:VDD VSS) capacitor c=1.87126e-16
C163 (\10\:VDD VSS) capacitor c=2.9491e-17
C164 (\19\:VDD VSS) capacitor c=3.81401e-17
Rk61 (\2\:Q Q) resistor r=0.1682 c=0
Rk62 (Q \4\:Q) resistor r=0.3377 c=0
Rk35 (ExtVDD ExtVDD) resistor r=0.002057 c=0
Rk33 (\2\:ExtVDD ExtVDD) resistor r=0.0221 c=0
Rk36 (ExtVDD \5\:ExtVDD) resistor r=0.0201 c=0
Rk37 (ExtVDD \6\:ExtVDD) resistor r=0.1054 c=0
Rk38 (\7\:ExtVDD \8\:ExtVDD) resistor r=0.02871 c=0
Rk45 (\9\:RT \10\:RT) resistor r=0.4442 c=0
Rk50 (RT \11\:RT) resistor r=0.01696 c=0
Rk2 (\5\:D \6\:D) resistor r=0.009156 c=0
Rk3 (\7\:D D) resistor r=0.009156 c=0
Rk4 (\6\:D \7\:D) resistor r=0.01888 c=0
Rk54 (\3\:QN QN) resistor r=0.0431 c=0
Rk53 (\2\:QN \3\:QN) resistor r=0.3177 c=0
Rk55 (\3\:QN \5\:QN) resistor r=0.2274 c=0
Rk80 (\2\:VDD \4\:VDD) resistor r=0.4883 c=0
Rk81 (\4\:VDD \5\:VDD) resistor r=0.1507 c=0
Rk82 (\5\:VDD \6\:VDD) resistor r=0.05156 c=0
Rk83 (\6\:VDD \7\:VDD) resistor r=0.03444 c=0
Rk84 (\7\:VDD \8\:VDD) resistor r=1.5581 c=0
Rk90 (\10\:VDD VDD) resistor r=0.1806 c=0
Rk85 (\8\:VDD \10\:VDD) resistor r=0.05483 c=0
Rk86 (\5\:VDD \12\:VDD) resistor r=0.2895 c=0
Rk87 (\6\:VDD \14\:VDD) resistor r=0.3633 c=0
Rk88 (\8\:VDD \16\:VDD) resistor r=0.3788 c=0
Rk89 (\10\:VDD \18\:VDD) resistor r=0.3557 c=0
Rk91 (VDD \19\:VDD) resistor r=0.1509 c=0
Rk92 (\19\:VDD VDD) resistor r=0.08366 c=0
Rk93 (\19\:VDD \21\:VDD) resistor r=0.3577 c=0
Rk18 (\5\:CK \6\:CK) resistor r=0.005021 c=0
Rk19 (CK \7\:CK) resistor r=0.00251 c=0
Rk20 (\5\:CK \7\:CK) resistor r=0.01225 c=0
Rk21 (CK \8\:CK) resistor r=0.005021 c=0
Rk22 (\7\:CK \8\:CK) resistor r=0.01004 c=0
Rk63 (\2\:VSS \4\:VSS) resistor r=0.3605 c=0
Rk64 (\4\:VSS \5\:VSS) resistor r=0.2348 c=0
Rk65 (\5\:VSS \6\:VSS) resistor r=0.2101 c=0
Rk67 (\7\:VSS VSS) resistor r=0.1331 c=0
Rk66 (\6\:VSS \7\:VSS) resistor r=0.4599 c=0
Rk68 (VSS \8\:VSS) resistor r=0.07426 c=0
Rk69 (\8\:VSS \9\:VSS) resistor r=0.1235 c=0
Rk71 (\10\:VSS VSS) resistor r=0.02182 c=0
Rk70 (\9\:VSS \10\:VSS) resistor r=0.591 c=0
Rk72 (VSS \11\:VSS) resistor r=0.1783 c=0
Rk73 (\11\:VSS \12\:VSS) resistor r=0.1853 c=0
Rk74 (\12\:VSS \13\:VSS) resistor r=0.06165 c=0
Rk75 (\5\:VSS \15\:VSS) resistor r=0.2663 c=0
Rk76 (\7\:VSS \17\:VSS) resistor r=0.1887 c=0
Rk77 (\8\:VSS \19\:VSS) resistor r=0.1938 c=0
Rk78 (\10\:VSS \21\:VSS) resistor r=0.2399 c=0
Rk79 (\12\:VSS \23\:VSS) resistor r=0.2277 c=0
Rk94 (\25\:VSS \27\:VSS) resistor r=0.3504 c=0
Rk95 (\27\:VSS \28\:VSS) resistor r=0.5613 c=0
Rk97 (\29\:VSS VSS) resistor r=0.04922 c=0
Rk96 (\28\:VSS \29\:VSS) resistor r=0.1309 c=0
Rk99 (\30\:VSS VSS) resistor r=0.1185 c=0
Rk98 (VSS \30\:VSS) resistor r=0.6928 c=0
Rk100 (VSS \32\:VSS) resistor r=0.3451 c=0
Rk101 (\28\:VSS \34\:VSS) resistor r=0.3469 c=0
Rk1 (\12\:CKbb \13\:CKbb) resistor r=0.8336 c=0
Rk10 (\15\:CKbb \16\:CKbb) resistor r=0.3218 c=0
Rk11 (\16\:CKbb \17\:CKbb) resistor r=0.02343 c=0
Rk12 (\16\:CKbb \19\:CKbb) resistor r=0.2142 c=0
Rk52 (\20\:CKbb \21\:CKbb) resistor r=0.8679 c=0
Rk5 (\8\:n20 \10\:n20) resistor r=0.4919 c=0
Rk6 (\10\:n20 \11\:n20) resistor r=0.3007 c=0
Rk7 (\12\:n20 \14\:n20) resistor r=0.2757 c=0
Rk8 (\14\:n20 \15\:n20) resistor r=0.2392 c=0
Rk9 (\12\:n20 \17\:n20) resistor r=0.2333 c=0
Rk13 (\6\:mout \7\:mout) resistor r=0.3049 c=0
Rk14 (\7\:mout \8\:mout) resistor r=0.1492 c=0
Rk15 (\8\:mout \9\:mout) resistor r=0.1241 c=0
Rk16 (\7\:mout \11\:mout) resistor r=0.2733 c=0
Rk17 (\8\:mout \12\:mout) resistor r=0.1307 c=0
Rk26 (\5\:n35 \6\:n35) resistor r=0.2864 c=0
Rk27 (\6\:n35 \8\:n35) resistor r=0.272 c=0
Rk28 (\6\:n35 \9\:n35) resistor r=0.567 c=0
Rk31 (\11\:n35 \12\:n35) resistor r=0.2719 c=0
Rk32 (\12\:n35 \14\:n35) resistor r=0.3269 c=0
Rk56 (\16\:n35 \17\:n35) resistor r=0.17 c=0
Rk57 (\17\:n35 \19\:n35) resistor r=0.4264 c=0
Rk23 (\11\:CKb \12\:CKb) resistor r=0.2067 c=0
Rk24 (\12\:CKb \14\:CKb) resistor r=0.3154 c=0
Rk25 (\12\:CKb \16\:CKb) resistor r=0.1956 c=0
Rk29 (\7\:n35g \8\:n35g) resistor r=0.2289 c=0
Rk30 (\7\:n35g \10\:n35g) resistor r=0.6049 c=0
Rk42 (\12\:n35g \13\:n35g) resistor r=0.2424 c=0
Rk43 (\13\:n35g \14\:n35g) resistor r=0.5641 c=0
Rk44 (\13\:n35g \16\:n35g) resistor r=0.4309 c=0
Rk39 (\15\:qbint \16\:qbint) resistor r=0.4933 c=0
Rk40 (\16\:qbint \18\:qbint) resistor r=0.5658 c=0
Rk41 (\16\:qbint \20\:qbint) resistor r=0.1459 c=0
Rk51 (\21\:qbint \22\:qbint) resistor r=0.2113 c=0
Rk46 (\5\:RTb \7\:RTb) resistor r=0.226 c=0
Rk47 (\7\:RTb \8\:RTb) resistor r=0.2727 c=0
Rk48 (\8\:RTb \9\:RTb) resistor r=0.669 c=0
Rk49 (\8\:RTb \11\:RTb) resistor r=0.3325 c=0
Rk58 (\6\:qint \7\:qint) resistor r=0.2591 c=0
Rk59 (\7\:qint \8\:qint) resistor r=0.1618 c=0
Rk60 (\7\:qint \10\:qint) resistor r=0.2767 c=0
Rl29 (\3\:RT \7\:RT) resistor r=709.9 c=0
Rl26 (\3\:RT \4\:RT) resistor r=72.2057 c=0
Rl20 (\1\:RT \2\:RT) resistor r=125.877 c=0
Rl30 (\5\:RT \8\:RT) resistor r=30.9873 c=0
Rl28 (\5\:RT \6\:RT) resistor r=273.765 c=0
Rl27 (\4\:RT \5\:RT) resistor r=78.204 c=0
Rl3 (\2\:D \4\:D) resistor r=111.253 c=0
Rl1 (\1\:D \2\:D) resistor r=99.7141 c=0
Rl2 (\2\:D \3\:D) resistor r=5.1123 c=0
Rl14 (\2\:CK \4\:CK) resistor r=70.868 c=0
Rl12 (\1\:CK \2\:CK) resistor r=140.099 c=0
Rl13 (\2\:CK \3\:CK) resistor r=2.0166 c=0
Rl5 (CKbb \2\:CKbb) resistor r=151.246 c=0
Rl38 (\10\:CKbb \11\:CKbb) resistor r=115.79 c=0
Rl6 (\2\:CKbb \3\:CKbb) resistor r=246.721 c=0
Rl34 (\5\:CKbb \8\:CKbb) resistor r=64.1356 c=0
Rl31 (\4\:CKbb \5\:CKbb) resistor r=862.964 c=0
Rl35 (\6\:CKbb \9\:CKbb) resistor r=64.1356 c=0
Rl33 (\6\:CKbb \7\:CKbb) resistor r=113.909 c=0
Rl32 (\5\:CKbb \6\:CKbb) resistor r=172.374 c=0
Rl4 (n20 \2\:n20) resistor r=112.885 c=0
Rl9 (\3\:n20 \4\:n20) resistor r=103.572 c=0
Rl11 (\4\:n20 \6\:n20) resistor r=96.5354 c=0
Rl10 (\4\:n20 \5\:n20) resistor r=121.254 c=0
Rl7 (mout \2\:mout) resistor r=24.2328 c=0
Rl8 (\3\:mout \4\:mout) resistor r=24.2328 c=0
Rl36 (n35 \2\:n35) resistor r=499.328 c=0
Rl37 (\2\:n35 \3\:n35) resistor r=104.689 c=0
Rl39 (CKb \2\:CKb) resistor r=1441.22 c=0
Rl40 (\2\:CKb \3\:CKb) resistor r=213.178 c=0
Rl41 (\3\:CKb \4\:CKb) resistor r=134.462 c=0
Rl45 (\4\:CKb \8\:CKb) resistor r=72.9234 c=0
Rl42 (\4\:CKb \5\:CKb) resistor r=222.576 c=0
Rl46 (\4\:CKb \9\:CKb) resistor r=3.6978 c=0
Rl44 (\6\:CKb \7\:CKb) resistor r=66.684 c=0
Rl47 (\6\:CKb \10\:CKb) resistor r=229.379 c=0
Rl43 (\2\:CKb \6\:CKb) resistor r=112.483 c=0
Rl17 (\3\:n35g \4\:n35g) resistor r=241.174 c=0
Rl15 (n35g \2\:n35g) resistor r=2.4834 c=0
Rl16 (\2\:n35g \3\:n35g) resistor r=181.74 c=0
Rl18 (\2\:n35g \5\:n35g) resistor r=94.1963 c=0
Rl51 (\6\:qbint \7\:qbint) resistor r=149.805 c=0
Rl56 (\11\:qbint \12\:qbint) resistor r=195.609 c=0
Rl58 (\13\:qbint \14\:qbint) resistor r=235.906 c=0
Rl25 (\3\:qbint \5\:qbint) resistor r=35.3072 c=0
Rl22 (qbint \2\:qbint) resistor r=112.732 c=0
Rl24 (\2\:qbint \4\:qbint) resistor r=148.502 c=0
Rl23 (\2\:qbint \3\:qbint) resistor r=74.1915 c=0
Rl52 (\7\:qbint \8\:qbint) resistor r=203.519 c=0
Rl55 (\8\:qbint \11\:qbint) resistor r=92.0202 c=0
Rl57 (\9\:qbint \13\:qbint) resistor r=355.65 c=0
Rl54 (\9\:qbint \10\:qbint) resistor r=244.214 c=0
Rl53 (\8\:qbint \9\:qbint) resistor r=221.574 c=0
Rl21 (\3\:RTb \4\:RTb) resistor r=242.199 c=0
Rl19 (RTb \2\:RTb) resistor r=124.312 c=0
Rl48 (qint \2\:qint) resistor r=3.1216 c=0
Rl49 (\2\:qint \3\:qint) resistor r=64.1263 c=0
Rl50 (\2\:qint \4\:qint) resistor r=73.7417 c=0
Rz16 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz13 (\1\:QN \2\:QN) resistor r=37.5 c=0
Rz23 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz24 (\3\:VDD \7\:VDD) resistor r=37.5 c=0
Rz17 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz18 (\14\:VSS \15\:VSS) resistor r=37.5 c=0
Rz19 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz20 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz21 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz22 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz26 (\24\:VSS \25\:VSS) resistor r=75 c=0
Rz27 (\31\:VSS \32\:VSS) resistor r=75 c=0
Rz28 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz3 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz1 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz2 (\16\:n20 \17\:n20) resistor r=75 c=0
Rz4 (\10\:mout \11\:mout) resistor r=75 c=0
Rz6 (\7\:n35 \8\:n35) resistor r=75 c=0
Rz8 (\13\:n35 \14\:n35) resistor r=75 c=0
Rz14 (\18\:n35 \19\:n35) resistor r=75 c=0
Rz5 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz7 (\9\:n35g \10\:n35g) resistor r=75 c=0
Rz11 (\11\:n35g \12\:n35g) resistor r=75 c=0
Rz10 (\19\:qbint \20\:qbint) resistor r=75 c=0
Rz12 (\10\:RTb \11\:RTb) resistor r=75 c=0
Rz15 (\5\:qint \6\:qint) resistor r=75 c=0
Ry20 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry9 (\1\:ExtVDD \2\:ExtVDD) resistor r=62 c=0
Ry10 (\1\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry11 (\1\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry12 (\1\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:ExtVDD \8\:ExtVDD) resistor r=62 c=0
Ry17 (\4\:QN \5\:QN) resistor r=20.6667 c=0
Ry26 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry27 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry28 (\13\:VDD \14\:VDD) resistor r=20.6667 c=0
Ry29 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry30 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry31 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry21 (\3\:VSS \4\:VSS) resistor r=12.4 c=0
Ry22 (\3\:VSS \6\:VSS) resistor r=15.5 c=0
Ry23 (\3\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry24 (\3\:VSS \11\:VSS) resistor r=15.5 c=0
Ry25 (\3\:VSS \13\:VSS) resistor r=62 c=0
Ry32 (\26\:VSS \27\:VSS) resistor r=5.6364 c=0
Ry33 (\26\:VSS \29\:VSS) resistor r=20.6667 c=0
Ry34 (\26\:VSS \30\:VSS) resistor r=5.1667 c=0
Ry3 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry1 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry2 (\13\:n20 \14\:n20) resistor r=62 c=0
Ry4 (\5\:mout \6\:mout) resistor r=62 c=0
Ry6 (\4\:n35 \5\:n35) resistor r=62 c=0
Ry8 (\10\:n35 \11\:n35) resistor r=62 c=0
Ry18 (\15\:n35 \16\:n35) resistor r=62 c=0
Ry5 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry7 (\6\:n35g \7\:n35g) resistor r=62 c=0
Ry15 (\15\:n35g \16\:n35g) resistor r=62 c=0
Ry14 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry16 (\6\:RTb \7\:RTb) resistor r=62 c=0
Ry19 (\9\:qint \10\:qint) resistor r=62 c=0
Rx17 (\4\:RT \9\:RT) resistor r=45 c=0
Rx18 (\2\:RT \10\:RT) resistor r=45 c=0
Rx21 (\3\:RT \11\:RT) resistor r=45 c=0
Rx3 (\3\:D \5\:D) resistor r=45 c=0
Rx10 (\3\:CK \6\:CK) resistor r=45 c=0
Rx1 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx2 (\7\:CKbb \13\:CKbb) resistor r=45 c=0
Rx7 (CKbb \17\:CKbb) resistor r=45 c=0
Rx24 (\11\:CKbb \20\:CKbb) resistor r=45 c=0
Rx25 (\4\:CKbb \21\:CKbb) resistor r=45 c=0
Rx4 (\2\:n20 \11\:n20) resistor r=45 c=0
Rx5 (\5\:n20 \12\:n20) resistor r=45 c=0
Rx6 (n20 \15\:n20) resistor r=45 c=0
Rx8 (\4\:mout \9\:mout) resistor r=45 c=0
Rx9 (\2\:mout \12\:mout) resistor r=45 c=0
Rx12 (\3\:n35 \9\:n35) resistor r=45 c=0
Rx14 (\2\:n35 \12\:n35) resistor r=45 c=0
Rx26 (n35 \17\:n35) resistor r=45 c=0
Rx11 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx13 (\4\:n35g \8\:n35g) resistor r=45 c=0
Rx16 (n35g \14\:n35g) resistor r=45 c=0
Rx15 (\3\:qbint \15\:qbint) resistor r=45 c=0
Rx22 (\10\:qbint \21\:qbint) resistor r=45 c=0
Rx23 (qbint \22\:qbint) resistor r=45 c=0
Rx19 (\3\:RTb \5\:RTb) resistor r=45 c=0
Rx20 (\2\:RTb \9\:RTb) resistor r=45 c=0
Rx27 (qint \8\:qint) resistor r=45 c=0
mn25 (n21 \1\:D \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn26 (\7\:n20 \5\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\16\:n20 \9\:CKbb n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.55e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn35 (n30 \3\:mout \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.5e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn21 (\14\:CKbb \8\:CKb \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn32 (\10\:mout \6\:n20 \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.45e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn20 (\15\:CKb \1\:CK \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\7\:n35 \8\:CKbb \10\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.4e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
NM0 (\9\:n35g RTb \13\:n35 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
NM1 (\19\:qbint \5\:n35g \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
NM3 (net0121 \5\:qbint \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn45 (\10\:RTb \1\:RT \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.59604 \
        scb=0.00318587 scc=2.16275e-05 m=(1)
NM2 (\11\:n35g \7\:RT net0121 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=9.33388 \
        scb=0.00788941 scc=0.00017958 m=(1)
mn53 (\18\:n35 CKb net095 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn57 (\1\:QN \4\:qint \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.71058e-07 sd=160n sca=16.3874 scb=0.0162972 \
        scc=0.00139495 m=(1)
mn52 (net095 \14\:qbint \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn56 (\5\:qint \12\:qbint \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=4.365e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn55 (\1\:Q \6\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.8438 scb=0.0158162 \
        scc=0.00129108 m=(1)
mp26 (\9\:n20 \2\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.3839 \
        scb=0.011256 scc=0.000224024 m=(1)
mp36 (\13\:n20 \10\:CKb n31 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.55e-07 sd=160n sca=8.43833 \
        scb=0.00456328 scc=4.14083e-05 m=(1)
mp35 (n31 mout \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=5.5e-07 sd=160n sca=8.66197 \
        scb=0.00491317 scc=4.24157e-05 m=(1)
mp21 (\18\:CKbb \3\:CKb \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.3786 \
        scb=0.00949038 scc=0.000203066 m=(1)
mp32 (\5\:mout \3\:n20 \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=3.45e-07 sd=160n sca=10.9141 \
        scb=0.00882323 scc=9.56076e-05 m=(1)
mp20 (\13\:CKb \4\:CK \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=15.4857 \
        scb=0.0166783 scc=0.00041931 m=(1)
mp40 (\4\:n35 \7\:CKb \5\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.4e-07 sd=160n sca=22.4791 \
        scb=0.0247612 scc=0.0018296 m=(1)
PM0 (\6\:n35g \6\:RT \10\:n35 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=35.8476 \
        scb=0.0407387 scc=0.00396292 m=(1)
PM1 (\17\:qbint \3\:n35g \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.3457e-13 ad=3.01e-14 ps=3.53e-06 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=8.7e-07 sd=160n sca=25.3956 \
        scb=0.0259635 scc=0.00265434 m=(1)
PM2 (net205 \4\:qbint \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.3457e-13 ad=1.29e-14 ps=3.53e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=2.45e-07 sd=160n sca=14.6455 \
        scb=0.014432 scc=0.000486925 m=(1)
mp45 (\6\:RTb \8\:RT \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.3457e-13 ad=3.01e-14 ps=3.53e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.1e-07 sb=1.4e-07 sd=160n sca=34.1371 \
        scb=0.0394413 scc=0.00358201 m=(1)
PM3 (\15\:n35g \4\:RTb net205 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=1.4e-07 sd=160n sca=25.3956 \
        scb=0.0259635 scc=0.00265434 m=(1)
mp53 (\15\:n35 \10\:CKbb net084 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=26.0906 \
        scb=0.0274026 scc=0.00267565 m=(1)
mp57 (\4\:QN \3\:qint \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.69551e-07 sd=160n sca=28.893 \
        scb=0.031948 scc=0.00297886 m=(1)
mp52 (net084 \13\:qbint \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=15.0501 \
        scb=0.0157632 scc=0.000508204 m=(1)
mp56 (\9\:qint \11\:qbint \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=6.535e-14 ps=7.1e-07 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.4e-07 sd=160n sca=12.6819 \
        scb=0.0114274 scc=0.000189805 m=(1)
mp55 (\3\:Q \7\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.2615 \
        scb=0.0122477 scc=0.000351335 m=(1)
ends RDFFX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:54:47 2012 )
// Library name: gsclib045
// Cell name: RTLATRX1
// View name: extracted

simulator lang=spectre

subckt RTLATRX1 D ExtVDD G Q QN RN RT VDD VSS
mp2 (\8\:Gbb \4\:Gb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=19.3961 \
        scb=0.0207658 scc=0.000827697 m=(1)
C1 (D VSS) capacitor c=5.29575e-17
C2 (QN VSS) capacitor c=3.84791e-17
C3 (RT VSS) capacitor c=2.55171e-17
C4 (Q VSS) capacitor c=2.73236e-17
C5 (ExtVDD VSS) capacitor c=2.80598e-16
C6 (VDD VSS) capacitor c=3.96254e-16
C7 (RN VSS) capacitor c=3.96667e-17
C8 (G VSS) capacitor c=5.55172e-17
C9 (Gb VSS) capacitor c=7.99722e-17
C10 (Gbb VSS) capacitor c=1.281e-16
C11 (n5 VSS) capacitor c=6.89593e-17
C12 (Qbint VSS) capacitor c=3.01658e-17
C13 (Qint VSS) capacitor c=9.93019e-17
C14 (n5g VSS) capacitor c=4.74304e-17
C15 (RTb VSS) capacitor c=5.20732e-17
C16 (net103 VSS) capacitor c=9.00674e-17
C17 (net171 VSS) capacitor c=3.84734e-17
C18 (\1\:RN VSS) capacitor c=6.53712e-17
C19 (\4\:Qbint VSS) capacitor c=3.65829e-17
C20 (\2\:Qint VSS) capacitor c=9.20791e-17
C21 (\3\:Qint VSS) capacitor c=6.40417e-17
C22 (\4\:Gbb VSS) capacitor c=4.03499e-17
C23 (\10\:Qint VSS) capacitor c=2.34343e-17
C24 (\3\:RTb VSS) capacitor c=9.00987e-17
C25 (\12\:Qint VSS) capacitor c=6.62604e-17
C26 (\5\:RT VSS) capacitor c=5.32068e-17
C27 (\4\:n5g VSS) capacitor c=8.98249e-17
C28 (\7\:RT VSS) capacitor c=3.38591e-17
C29 (\1\:G VSS) capacitor c=4.19344e-17
C30 (\3\:D VSS) capacitor c=7.25947e-17
C31 (\5\:RN VSS) capacitor c=5.18488e-17
C32 (\4\:Gb VSS) capacitor c=5.74345e-17
C33 (\2\:RN VSS) capacitor c=2.56308e-16
C34 (\9\:Qint VSS) capacitor c=2.61589e-17
C35 (\8\:Gb VSS) capacitor c=7.29602e-17
C36 (\11\:Qint VSS) capacitor c=2.49084e-17
C37 (\13\:Qint VSS) capacitor c=5.74219e-17
C38 (\9\:RT VSS) capacitor c=9.24642e-17
C39 (\1\:RT VSS) capacitor c=5.93096e-17
C40 (\3\:n5g VSS) capacitor c=2.34422e-17
C41 (\2\:RTb VSS) capacitor c=5.48848e-17
C42 (\3\:Gbb VSS) capacitor c=4.2823e-17
C43 (\1\:D VSS) capacitor c=7.05368e-17
C44 (\3\:G VSS) capacitor c=7.80587e-17
C45 (\3\:RN VSS) capacitor c=2.16895e-16
C46 (\5\:Gb VSS) capacitor c=6.09497e-17
C47 (\3\:Qbint VSS) capacitor c=2.74714e-17
C48 (\5\:Gbb VSS) capacitor c=3.2757e-17
C49 (\9\:Gb VSS) capacitor c=6.51927e-17
C50 (\8\:RT VSS) capacitor c=6.08119e-17
C51 (\4\:RTb VSS) capacitor c=6.84677e-17
C52 (\5\:RTb VSS) capacitor c=4.82564e-17
C53 (\6\:RT VSS) capacitor c=5.62697e-17
C54 (\3\:n5 VSS) capacitor c=7.61574e-17
C55 (\2\:ExtVDD VSS) capacitor c=5.35292e-17
C56 (\1\:ExtVDD VSS) capacitor c=4.86404e-17
C57 (\5\:n5g VSS) capacitor c=1.01925e-16
C58 (\6\:Gb VSS) capacitor c=1.43017e-16
C59 (\8\:Qint VSS) capacitor c=7.74338e-17
C60 (\4\:n5 VSS) capacitor c=8.06615e-17
C61 (\4\:RT VSS) capacitor c=3.68672e-17
C62 (\2\:n5 VSS) capacitor c=6.31645e-17
C63 (\7\:Gb VSS) capacitor c=7.1473e-17
C64 (\2\:Gbb VSS) capacitor c=1.0203e-16
C65 (\2\:D VSS) capacitor c=5.66229e-17
C66 (\2\:G VSS) capacitor c=6.75501e-17
C67 (\4\:RN VSS) capacitor c=7.68224e-17
C68 (\3\:Gb VSS) capacitor c=3.68271e-17
C69 (\1\:VDD VSS) capacitor c=3.0581e-17
C70 (\3\:Q VSS) capacitor c=6.55238e-17
C71 (\12\:VDD VSS) capacitor c=7.41353e-17
C72 (\14\:VDD VSS) capacitor c=5.31909e-17
C73 (\7\:Qbint VSS) capacitor c=8.17484e-17
C74 (\16\:VDD VSS) capacitor c=8.7373e-17
C75 (\3\:net103 VSS) capacitor c=8.36451e-17
C76 (\21\:n5 VSS) capacitor c=3.68614e-17
C77 (\1\:QN VSS) capacitor c=6.49109e-17
C78 (\11\:n5g VSS) capacitor c=1.18767e-16
C79 (\6\:ExtVDD VSS) capacitor c=5.9034e-17
C80 (\7\:RTb VSS) capacitor c=4.6913e-17
C81 (\3\:ExtVDD VSS) capacitor c=4.33359e-17
C82 (\10\:ExtVDD VSS) capacitor c=6.26925e-17
C83 (\17\:Qint VSS) capacitor c=4.69338e-17
C84 (\7\:n5g VSS) capacitor c=7.97367e-17
C85 (\11\:n5 VSS) capacitor c=8.81159e-17
C86 (\7\:n5 VSS) capacitor c=2.59726e-17
C87 (\18\:Gb VSS) capacitor c=4.52077e-17
C88 (\18\:VDD VSS) capacitor c=6.67623e-17
C89 (\20\:VDD VSS) capacitor c=5.36997e-17
C90 (\13\:Gb VSS) capacitor c=4.71806e-17
C91 (\8\:Gbb VSS) capacitor c=5.2868e-17
C92 (\1\:Q VSS) capacitor c=4.435e-17
C93 (\9\:Qbint VSS) capacitor c=5.57442e-17
C94 (\3\:net171 VSS) capacitor c=4.44412e-17
C95 (\17\:n5 VSS) capacitor c=3.6584e-17
C96 (\3\:QN VSS) capacitor c=4.6588e-17
C97 (\12\:RTb VSS) capacitor c=2.5119e-17
C98 (\15\:n5g VSS) capacitor c=1.89334e-17
C99 (\14\:Qint VSS) capacitor c=3.89791e-17
C100 (\9\:n5g VSS) capacitor c=9.10257e-17
C101 (\15\:n5 VSS) capacitor c=4.11655e-17
C102 (\9\:n5 VSS) capacitor c=6.85463e-17
C103 (\8\:VDD VSS) capacitor c=2.81074e-16
C104 (\16\:Gb VSS) capacitor c=3.7525e-17
C105 (\10\:Gbb VSS) capacitor c=2.54426e-17
C106 (VDD VSS) capacitor c=1.54265e-17
C107 (\2\:Gb VSS) capacitor c=4.8761e-17
C108 (ExtVDD VSS) capacitor c=4.58411e-17
C109 (\2\:n5g VSS) capacitor c=4.73624e-17
C110 (\2\:RT VSS) capacitor c=8.36574e-17
C111 (\3\:RT VSS) capacitor c=7.45754e-17
C112 (\4\:Qint VSS) capacitor c=2.50393e-17
C113 (\5\:Qint VSS) capacitor c=4.58572e-17
C114 (\6\:Qint VSS) capacitor c=6.35249e-17
C115 (\7\:Qint VSS) capacitor c=4.02186e-17
C116 (\2\:Qbint VSS) capacitor c=2.01749e-17
C117 (\6\:Gbb VSS) capacitor c=5.6443e-17
C118 (\7\:Gbb VSS) capacitor c=5.65131e-17
C119 (\10\:Gb VSS) capacitor c=7.75756e-18
C120 (\11\:Gb VSS) capacitor c=4.30943e-17
C121 (\12\:Gb VSS) capacitor c=6.71059e-17
C122 (\15\:Gb VSS) capacitor c=4.96407e-17
C123 (\5\:n5 VSS) capacitor c=1.84247e-17
C124 (\6\:n5 VSS) capacitor c=5.34492e-17
C125 (\12\:RT VSS) capacitor c=2.30256e-17
C126 (\13\:n5 VSS) capacitor c=5.96576e-17
C127 (\14\:n5 VSS) capacitor c=4.91355e-17
C128 (\16\:Qint VSS) capacitor c=6.03261e-17
C129 (\6\:n5g VSS) capacitor c=2.49801e-17
C130 (\5\:ExtVDD VSS) capacitor c=5.58415e-17
C131 (\12\:ExtVDD VSS) capacitor c=3.17137e-17
C132 (\6\:RTb VSS) capacitor c=2.79626e-17
C133 (\9\:RTb VSS) capacitor c=3.78922e-17
C134 (\10\:RTb VSS) capacitor c=5.89529e-17
C135 (\11\:RTb VSS) capacitor c=6.2111e-17
C136 (\13\:n5g VSS) capacitor c=9.79609e-17
C137 (\14\:n5g VSS) capacitor c=2.88664e-17
C138 (\13\:RT VSS) capacitor c=1.29483e-16
C139 (\14\:RT VSS) capacitor c=1.31812e-16
C140 (\20\:Gb VSS) capacitor c=1.38534e-16
C141 (\21\:Gb VSS) capacitor c=1.58298e-16
C142 (\12\:Gbb VSS) capacitor c=1.89977e-16
C143 (\13\:Gbb VSS) capacitor c=2.42047e-16
C144 (\19\:n5 VSS) capacitor c=1.07836e-16
C145 (\20\:n5 VSS) capacitor c=1.81088e-16
C146 (\5\:Qbint VSS) capacitor c=2.79747e-17
C147 (\3\:VDD VSS) capacitor c=3.17796e-17
C148 (\4\:VDD VSS) capacitor c=2.0481e-17
C149 (\6\:VDD VSS) capacitor c=1.19444e-17
C150 (\7\:VDD VSS) capacitor c=2.94468e-16
Rk2 (D \4\:D) resistor r=0.003156 c=0
Rk44 (QN \4\:QN) resistor r=0.0916 c=0
Rk43 (\2\:QN \4\:QN) resistor r=0.5731 c=0
Rk19 (RT \12\:RT) resistor r=0.02095 c=0
Rk18 (\11\:RT \12\:RT) resistor r=0.004258 c=0
Rk40 (\13\:RT \14\:RT) resistor r=1.0387 c=0
Rk53 (Q \2\:Q) resistor r=0.1292 c=0
Rk54 (Q \4\:Q) resistor r=0.2929 c=0
Rk30 (ExtVDD ExtVDD) resistor r=0.003782 c=0
Rk27 (\4\:ExtVDD \5\:ExtVDD) resistor r=0.2263 c=0
Rk28 (\7\:ExtVDD ExtVDD) resistor r=0.1403 c=0
Rk31 (ExtVDD \11\:ExtVDD) resistor r=0.1482 c=0
Rk32 (\11\:ExtVDD \12\:ExtVDD) resistor r=0.2302 c=0
Rk63 (VDD VDD) resistor r=0.131 c=0
Rk55 (\2\:VDD \3\:VDD) resistor r=0.3854 c=0
Rk56 (\3\:VDD \4\:VDD) resistor r=0.09847 c=0
Rk57 (\4\:VDD \6\:VDD) resistor r=0.09125 c=0
Rk58 (\6\:VDD \7\:VDD) resistor r=0.03935 c=0
Rk59 (\7\:VDD \9\:VDD) resistor r=1.7784 c=0
Rk60 (\9\:VDD \10\:VDD) resistor r=0.05322 c=0
Rk62 (\11\:VDD VDD) resistor r=0.04671 c=0
Rk61 (\10\:VDD \11\:VDD) resistor r=0.03169 c=0
Rk64 (\3\:VDD \13\:VDD) resistor r=0.3553 c=0
Rk65 (\4\:VDD \15\:VDD) resistor r=0.2806 c=0
Rk66 (\7\:VDD \17\:VDD) resistor r=0.3729 c=0
Rk67 (\10\:VDD \19\:VDD) resistor r=0.2851 c=0
Rk68 (\11\:VDD \21\:VDD) resistor r=0.3284 c=0
Rk69 (\2\:VSS \4\:VSS) resistor r=0.2896 c=0
Rk71 (\5\:VSS VSS) resistor r=0.5439 c=0
Rk70 (\4\:VSS \5\:VSS) resistor r=0.6426 c=0
Rk73 (\6\:VSS VSS) resistor r=0.1851 c=0
Rk72 (VSS \6\:VSS) resistor r=0.643 c=0
Rk74 (VSS \8\:VSS) resistor r=0.5483 c=0
Rk75 (VSS \10\:VSS) resistor r=0.3042 c=0
Rk76 (\12\:VSS \13\:VSS) resistor r=0.08137 c=0
Rk77 (\13\:VSS \14\:VSS) resistor r=0.116 c=0
Rk78 (\14\:VSS \15\:VSS) resistor r=0.1135 c=0
Rk79 (\15\:VSS \16\:VSS) resistor r=0.331 c=0
Rk81 (\17\:VSS VSS) resistor r=0.2096 c=0
Rk80 (\16\:VSS \17\:VSS) resistor r=0.284 c=0
Rk82 (VSS \18\:VSS) resistor r=0.2719 c=0
Rk84 (\19\:VSS VSS) resistor r=0.5786 c=0
Rk83 (\18\:VSS \19\:VSS) resistor r=0.1728 c=0
Rk85 (VSS \20\:VSS) resistor r=0.114 c=0
Rk86 (\13\:VSS \22\:VSS) resistor r=0.2467 c=0
Rk87 (\15\:VSS \24\:VSS) resistor r=0.2584 c=0
Rk88 (\17\:VSS \26\:VSS) resistor r=0.2763 c=0
Rk89 (\18\:VSS \28\:VSS) resistor r=0.2423 c=0
Rk90 (VSS \30\:VSS) resistor r=0.3039 c=0
Rk3 (G \4\:G) resistor r=0.01004 c=0
Rk7 (\10\:Gb \11\:Gb) resistor r=0.04289 c=0
Rk8 (\11\:Gb \12\:Gb) resistor r=0.2419 c=0
Rk9 (\12\:Gb \14\:Gb) resistor r=0.4577 c=0
Rk10 (\14\:Gb \15\:Gb) resistor r=0.2367 c=0
Rk11 (\11\:Gb \17\:Gb) resistor r=0.3133 c=0
Rk12 (\12\:Gb \19\:Gb) resistor r=0.1902 c=0
Rk41 (\20\:Gb \21\:Gb) resistor r=0.8009 c=0
Rk4 (\6\:Gbb \7\:Gbb) resistor r=0.286 c=0
Rk5 (\7\:Gbb \9\:Gbb) resistor r=0.4403 c=0
Rk6 (\7\:Gbb \11\:Gbb) resistor r=0.1686 c=0
Rk42 (\12\:Gbb \13\:Gbb) resistor r=1.6105 c=0
Rk13 (\5\:n5 \6\:n5) resistor r=0.2054 c=0
Rk14 (\6\:n5 \8\:n5) resistor r=0.1993 c=0
Rk15 (\6\:n5 \10\:n5) resistor r=0.4682 c=0
Rk20 (\12\:n5 \13\:n5) resistor r=0.5935 c=0
Rk21 (\12\:n5 \14\:n5) resistor r=0.2472 c=0
Rk22 (\14\:n5 \16\:n5) resistor r=0.3212 c=0
Rk45 (\18\:n5 \19\:n5) resistor r=0.3432 c=0
Rk46 (\19\:n5 \20\:n5) resistor r=1.0792 c=0
Rk47 (\19\:n5 \22\:n5) resistor r=0.2537 c=0
Rk48 (\5\:Qbint \6\:Qbint) resistor r=0.0234 c=0
Rk49 (\6\:Qbint \8\:Qbint) resistor r=0.3093 c=0
Rk50 (\6\:Qbint \10\:Qbint) resistor r=0.2054 c=0
Rk23 (\15\:Qint \16\:Qint) resistor r=0.2107 c=0
Rk24 (\16\:Qint \18\:Qint) resistor r=0.4302 c=0
Rk25 (\6\:n5g \8\:n5g) resistor r=0.1082 c=0
Rk26 (\8\:n5g \10\:n5g) resistor r=0.5652 c=0
Rk37 (\12\:n5g \13\:n5g) resistor r=0.7341 c=0
Rk38 (\13\:n5g \14\:n5g) resistor r=0.1077 c=0
Rk39 (\13\:n5g \16\:n5g) resistor r=0.08846 c=0
Rk33 (\6\:RTb \8\:RTb) resistor r=0.1321 c=0
Rk34 (\9\:RTb \10\:RTb) resistor r=0.1671 c=0
Rk35 (\10\:RTb \11\:RTb) resistor r=0.3282 c=0
Rk36 (\10\:RTb \13\:RTb) resistor r=0.09342 c=0
Rk52 (\2\:net103 \4\:net103) resistor r=0.6377 c=0
Rk51 (\2\:net171 \4\:net171) resistor r=0.3526 c=0
Rl2 (\2\:D \3\:D) resistor r=87.7202 c=0
Rl1 (\1\:D \2\:D) resistor r=133.743 c=0
Rl28 (\8\:RT \9\:RT) resistor r=350.785 c=0
Rl24 (\5\:RT \6\:RT) resistor r=204.389 c=0
Rl23 (\2\:RT \5\:RT) resistor r=26.665 c=0
Rl20 (\1\:RT \2\:RT) resistor r=182.259 c=0
Rl25 (\3\:RT \7\:RT) resistor r=21.372 c=0
Rl22 (\3\:RT \4\:RT) resistor r=104.717 c=0
Rl21 (\2\:RT \3\:RT) resistor r=218.989 c=0
Rl14 (\1\:ExtVDD \2\:ExtVDD) resistor r=176.713 c=0
Rl46 (\1\:RN \2\:RN) resistor r=215.452 c=0
Rl47 (\2\:RN \3\:RN) resistor r=1636.76 c=0
Rl49 (\4\:RN \5\:RN) resistor r=164.425 c=0
Rl48 (\3\:RN \4\:RN) resistor r=46.604 c=0
Rl3 (\1\:G \2\:G) resistor r=88.3245 c=0
Rl4 (\2\:G \3\:G) resistor r=127.297 c=0
Rl8 (\4\:Gb \5\:Gb) resistor r=249.542 c=0
Rl30 (\8\:Gb \9\:Gb) resistor r=361.066 c=0
Rl12 (\6\:Gb \7\:Gb) resistor r=452.417 c=0
Rl5 (Gb \2\:Gb) resistor r=168.204 c=0
Rl7 (\2\:Gb \4\:Gb) resistor r=64.1356 c=0
Rl6 (\2\:Gb \3\:Gb) resistor r=143.548 c=0
Rl29 (\4\:Gbb \5\:Gbb) resistor r=178.565 c=0
Rl10 (Gbb \2\:Gbb) resistor r=696.861 c=0
Rl11 (\2\:Gbb \3\:Gbb) resistor r=44.0258 c=0
Rl19 (\3\:n5 \4\:n5) resistor r=172.871 c=0
Rl9 (n5 \2\:n5) resistor r=331.394 c=0
Rl43 (Qbint \2\:Qbint) resistor r=60.9354 c=0
Rl45 (\2\:Qbint \4\:Qbint) resistor r=93.3448 c=0
Rl44 (\2\:Qbint \3\:Qbint) resistor r=83.7545 c=0
Rl31 (Qint \2\:Qint) resistor r=232.216 c=0
Rl32 (\2\:Qint \3\:Qint) resistor r=322.396 c=0
Rl33 (\3\:Qint \4\:Qint) resistor r=60.9354 c=0
Rl38 (\4\:Qint \9\:Qint) resistor r=93.3448 c=0
Rl39 (\5\:Qint \10\:Qint) resistor r=59.4143 c=0
Rl40 (\5\:Qint \11\:Qint) resistor r=91.8237 c=0
Rl34 (\4\:Qint \5\:Qint) resistor r=59.826 c=0
Rl41 (\6\:Qint \12\:Qint) resistor r=101.868 c=0
Rl35 (\5\:Qint \6\:Qint) resistor r=412.667 c=0
Rl42 (\7\:Qint \13\:Qint) resistor r=67.7766 c=0
Rl37 (\7\:Qint \8\:Qint) resistor r=192.03 c=0
Rl36 (\6\:Qint \7\:Qint) resistor r=20.6699 c=0
Rl18 (\4\:n5g \5\:n5g) resistor r=317.727 c=0
Rl15 (n5g \2\:n5g) resistor r=109.66 c=0
Rl17 (\2\:n5g \4\:n5g) resistor r=191.281 c=0
Rl16 (\2\:n5g \3\:n5g) resistor r=38.4366 c=0
Rl13 (RTb \2\:RTb) resistor r=124.916 c=0
Rl26 (\3\:RTb \4\:RTb) resistor r=306.661 c=0
Rl27 (\4\:RTb \5\:RTb) resistor r=184.803 c=0
Rz10 (\3\:QN \4\:QN) resistor r=37.5 c=0
Rz15 (\1\:Q \2\:Q) resistor r=37.5 c=0
Rz17 (\8\:VDD \9\:VDD) resistor r=37.5 c=0
Rz18 (\8\:VDD \11\:VDD) resistor r=75 c=0
Rz19 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz20 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz21 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz22 (\21\:VSS \22\:VSS) resistor r=37.5 c=0
Rz23 (\23\:VSS \24\:VSS) resistor r=37.5 c=0
Rz24 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz25 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz26 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz2 (\16\:Gb \17\:Gb) resistor r=75 c=0
Rz1 (\10\:Gbb \11\:Gbb) resistor r=75 c=0
Rz3 (\9\:n5 \10\:n5) resistor r=75 c=0
Rz4 (\15\:n5 \16\:n5) resistor r=75 c=0
Rz11 (\17\:n5 \18\:n5) resistor r=75 c=0
Rz12 (\9\:Qbint \10\:Qbint) resistor r=37.5 c=0
Rz5 (\14\:Qint \15\:Qint) resistor r=75 c=0
Rz6 (\9\:n5g \10\:n5g) resistor r=75 c=0
Rz9 (\15\:n5g \16\:n5g) resistor r=75 c=0
Rz8 (\12\:RTb \13\:RTb) resistor r=75 c=0
Rz13 (net171 \2\:net171) resistor r=75 c=0
Rz14 (\3\:net171 \4\:net171) resistor r=75 c=0
Ry13 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry18 (\3\:Q \4\:Q) resistor r=20.6667 c=0
Ry8 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry9 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry10 (\10\:ExtVDD \11\:ExtVDD) resistor r=62 c=0
Ry19 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry20 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry21 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry22 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry23 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry24 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry25 (\3\:VSS \4\:VSS) resistor r=62 c=0
Ry26 (\3\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry27 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry28 (\11\:VSS \12\:VSS) resistor r=31 c=0
Ry29 (\11\:VSS \14\:VSS) resistor r=31 c=0
Ry30 (\11\:VSS \16\:VSS) resistor r=8.8571 c=0
Ry31 (\11\:VSS \19\:VSS) resistor r=5.1667 c=0
Ry32 (\11\:VSS \20\:VSS) resistor r=31 c=0
Ry2 (\13\:Gb \14\:Gb) resistor r=62 c=0
Ry3 (\18\:Gb \19\:Gb) resistor r=62 c=0
Ry1 (\8\:Gbb \9\:Gbb) resistor r=62 c=0
Ry4 (\7\:n5 \8\:n5) resistor r=62 c=0
Ry5 (\11\:n5 \12\:n5) resistor r=62 c=0
Ry14 (\21\:n5 \22\:n5) resistor r=62 c=0
Ry15 (\7\:Qbint \8\:Qbint) resistor r=20.6667 c=0
Ry6 (\17\:Qint \18\:Qint) resistor r=62 c=0
Ry7 (\7\:n5g \8\:n5g) resistor r=62 c=0
Ry12 (\11\:n5g \12\:n5g) resistor r=62 c=0
Ry11 (\7\:RTb \8\:RTb) resistor r=62 c=0
Ry16 (net103 \2\:net103) resistor r=62 c=0
Ry17 (\3\:net103 \4\:net103) resistor r=62 c=0
Rx2 (\2\:D \4\:D) resistor r=45 c=0
Rx8 (\4\:RT \11\:RT) resistor r=45 c=0
Rx19 (\8\:RT \13\:RT) resistor r=45 c=0
Rx20 (\6\:RT \14\:RT) resistor r=45 c=0
Rx13 (\2\:ExtVDD \5\:ExtVDD) resistor r=45 c=0
Rx14 (\1\:ExtVDD \12\:ExtVDD) resistor r=45 c=0
Rx1 (\4\:RN RN) resistor r=45 c=0
Rx3 (\2\:G \4\:G) resistor r=45 c=0
Rx5 (\7\:Gb \10\:Gb) resistor r=45 c=0
Rx6 (\3\:Gb \15\:Gb) resistor r=45 c=0
Rx21 (\9\:Gb \20\:Gb) resistor r=45 c=0
Rx22 (\6\:Gb \21\:Gb) resistor r=45 c=0
Rx4 (\2\:Gbb \6\:Gbb) resistor r=45 c=0
Rx23 (\5\:Gbb \12\:Gbb) resistor r=45 c=0
Rx24 (Gbb \13\:Gbb) resistor r=45 c=0
Rx7 (n5 \5\:n5) resistor r=45 c=0
Rx9 (\2\:n5 \13\:n5) resistor r=45 c=0
Rx10 (\4\:n5 \14\:n5) resistor r=45 c=0
Rx25 (\3\:n5 \20\:n5) resistor r=45 c=0
Rx26 (\3\:Qbint \5\:Qbint) resistor r=45 c=0
Rx11 (\8\:Qint \16\:Qint) resistor r=45 c=0
Rx12 (\5\:n5g \6\:n5g) resistor r=45 c=0
Rx18 (n5g \14\:n5g) resistor r=45 c=0
Rx15 (\4\:RTb \6\:RTb) resistor r=45 c=0
Rx16 (\5\:RTb \9\:RTb) resistor r=45 c=0
Rx17 (RTb \11\:RTb) resistor r=45 c=0
mn2 (\10\:Gbb \5\:Gb \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn0 (net159 \3\:RN \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (\16\:Gb \3\:G net159 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn5 (net191 \1\:D \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn6 (\9\:n5 \3\:Gbb net191 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
NM0 (\9\:n5g \2\:RTb \15\:n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn11 (\14\:Qint \3\:n5g \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\12\:RTb \1\:RT \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
NM2 (\15\:n5g \9\:RT net094 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
NM3 (net094 \13\:Qint \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn22 (\3\:QN \11\:Qint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(1)
mn17 (\17\:n5 \8\:Gb \3\:net171 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn20 (\9\:Qbint \9\:Qint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(1)
mn16 (net171 Qint net167 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn21 (\1\:Q Qbint \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
mn15 (net167 \2\:RN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp0 (\13\:Gb \5\:RN \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=17.9195 \
        scb=0.0189757 scc=0.000406591 m=(1)
mp5 (net142 \3\:D \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=17.8355 \
        scb=0.0186759 scc=0.000523731 m=(1)
mp1 (\18\:Gb \1\:G \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=22.2251 \
        scb=0.0245336 scc=0.00126258 m=(1)
mp6 (\7\:n5 Gb net142 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=27.621 scb=0.0284013 \
        scc=0.00267219 m=(1)
PM0 (\7\:n5g \7\:RT \11\:n5 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=29.0164 \
        scb=0.0322998 scc=0.00288094 m=(1)
mp11 (\17\:Qint \4\:n5g \10\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.1365 \
        scb=0.0108856 scc=0.000154611 m=(1)
mp45 (\7\:RTb \5\:RT \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.3254 \
        scb=0.0107248 scc=0.000244923 m=(1)
PM2 (net94 \12\:Qint \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=15.9786 \
        scb=0.0173297 scc=0.000549121 m=(1)
PM3 (\11\:n5g \3\:RTb net94 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=27.0191 \
        scb=0.0289692 scc=0.00271657 m=(1)
mp22 (\1\:QN \10\:Qint \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=20.1 scb=0.0231569 \
        scc=0.00111653 m=(1)
mp17 (\21\:n5 \4\:Gbb \3\:net103 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.7175 \
        scb=0.0182062 scc=0.00060472 m=(1)
mp20 (\7\:Qbint \3\:Qint \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=14.2883 \
        scb=0.0127505 scc=0.000516711 m=(1)
mp16 (net103 \2\:Qint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2005 \
        scb=0.010123 scc=0.000128822 m=(1)
mp21 (\3\:Q \4\:Qbint \12\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.3123 \
        scb=0.0284082 scc=0.00190571 m=(1)
mp15 (net103 \1\:RN \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=22.1035 \
        scb=0.0249499 scc=0.00160735 m=(1)
ends RTLATRX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:55:36 2012 )
// Library name: gsclib045
// Cell name: RTLATSRX1
// View name: extracted

simulator lang=spectre

subckt RTLATSRX1 D ExtVDD G Q QN RN RT SN VDD VSS
mp2 (\8\:Gbb \4\:Gb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=19.3961 \
        scb=0.0207658 scc=0.000827697 m=(1)
C1 (D VSS) capacitor c=6.06336e-17
C2 (RT VSS) capacitor c=2.75905e-17
C3 (ExtVDD VSS) capacitor c=2.91122e-16
C4 (QN VSS) capacitor c=3.834e-17
C5 (RN VSS) capacitor c=4.46512e-17
C6 (Q VSS) capacitor c=2.24983e-17
C7 (G VSS) capacitor c=6.90666e-17
C8 (VDD VSS) capacitor c=3.90897e-16
C9 (Gb VSS) capacitor c=8.17772e-17
C10 (Gbb VSS) capacitor c=1.29013e-16
C11 (n5 VSS) capacitor c=6.946e-17
C12 (Qbint VSS) capacitor c=2.99278e-17
C13 (Qint VSS) capacitor c=9.93019e-17
C14 (n5g VSS) capacitor c=4.78625e-17
C15 (RTb VSS) capacitor c=5.20732e-17
C16 (net103 VSS) capacitor c=9.00674e-17
C17 (net171 VSS) capacitor c=3.84734e-17
C18 (\1\:RN VSS) capacitor c=6.53712e-17
C19 (\4\:Qbint VSS) capacitor c=3.62557e-17
C20 (\2\:Qint VSS) capacitor c=9.20791e-17
C21 (\3\:Qint VSS) capacitor c=6.39908e-17
C22 (\4\:Gbb VSS) capacitor c=4.03495e-17
C23 (\10\:Qint VSS) capacitor c=2.34012e-17
C24 (\3\:RTb VSS) capacitor c=8.97947e-17
C25 (\12\:Qint VSS) capacitor c=6.57794e-17
C26 (\5\:RT VSS) capacitor c=5.32068e-17
C27 (\4\:n5g VSS) capacitor c=1.0874e-16
C28 (\4\:SN VSS) capacitor c=5.52974e-17
C29 (\7\:RT VSS) capacitor c=3.19382e-17
C30 (\1\:G VSS) capacitor c=4.17482e-17
C31 (\3\:D VSS) capacitor c=7.27055e-17
C32 (\6\:RN VSS) capacitor c=5.21474e-17
C33 (\4\:Gb VSS) capacitor c=5.75313e-17
C34 (\2\:RN VSS) capacitor c=2.56308e-16
C35 (\9\:Qint VSS) capacitor c=2.60833e-17
C36 (\8\:Gb VSS) capacitor c=7.29602e-17
C37 (\11\:Qint VSS) capacitor c=2.49079e-17
C38 (\13\:Qint VSS) capacitor c=5.71866e-17
C39 (\9\:RT VSS) capacitor c=9.38305e-17
C40 (\1\:RT VSS) capacitor c=5.93098e-17
C41 (\3\:n5g VSS) capacitor c=3.95098e-17
C42 (\1\:SN VSS) capacitor c=3.91996e-17
C43 (\2\:RTb VSS) capacitor c=5.45794e-17
C44 (\3\:Gbb VSS) capacitor c=3.99005e-17
C45 (\1\:D VSS) capacitor c=7.06097e-17
C46 (\3\:G VSS) capacitor c=7.77994e-17
C47 (\3\:RN VSS) capacitor c=2.14606e-16
C48 (\5\:Gb VSS) capacitor c=6.09852e-17
C49 (\3\:Qbint VSS) capacitor c=2.74714e-17
C50 (\5\:Gbb VSS) capacitor c=3.27568e-17
C51 (\9\:Gb VSS) capacitor c=6.51927e-17
C52 (\8\:RT VSS) capacitor c=6.07721e-17
C53 (\4\:RTb VSS) capacitor c=6.84677e-17
C54 (\5\:RTb VSS) capacitor c=4.82564e-17
C55 (\6\:RT VSS) capacitor c=5.61807e-17
C56 (\3\:n5 VSS) capacitor c=7.61574e-17
C57 (\2\:ExtVDD VSS) capacitor c=5.33843e-17
C58 (\1\:ExtVDD VSS) capacitor c=4.85138e-17
C59 (\5\:n5g VSS) capacitor c=1.02118e-16
C60 (\8\:Qint VSS) capacitor c=7.43543e-17
C61 (\6\:Gb VSS) capacitor c=1.38815e-16
C62 (\3\:SN VSS) capacitor c=6.30637e-17
C63 (\4\:n5 VSS) capacitor c=8.0763e-17
C64 (\4\:RT VSS) capacitor c=3.68861e-17
C65 (\2\:n5 VSS) capacitor c=6.35584e-17
C66 (\7\:Gb VSS) capacitor c=7.2093e-17
C67 (\2\:Gbb VSS) capacitor c=1.05925e-16
C68 (\2\:D VSS) capacitor c=5.66906e-17
C69 (\2\:G VSS) capacitor c=6.71337e-17
C70 (\5\:RN VSS) capacitor c=7.68894e-17
C71 (\3\:Gb VSS) capacitor c=3.68271e-17
C72 (\1\:VDD VSS) capacitor c=3.0581e-17
C73 (\2\:Q VSS) capacitor c=4.84547e-17
C74 (\12\:VDD VSS) capacitor c=7.41353e-17
C75 (\14\:VDD VSS) capacitor c=5.31909e-17
C76 (\7\:Qbint VSS) capacitor c=8.17189e-17
C77 (\16\:VDD VSS) capacitor c=8.7373e-17
C78 (\3\:net103 VSS) capacitor c=8.36451e-17
C79 (\21\:n5 VSS) capacitor c=3.68614e-17
C80 (\1\:QN VSS) capacitor c=6.49088e-17
C81 (\11\:n5g VSS) capacitor c=1.1939e-16
C82 (\6\:ExtVDD VSS) capacitor c=6.44446e-17
C83 (\7\:RTb VSS) capacitor c=4.6913e-17
C84 (\3\:ExtVDD VSS) capacitor c=4.33237e-17
C85 (\10\:ExtVDD VSS) capacitor c=7.57832e-17
C86 (\18\:Qint VSS) capacitor c=8.03274e-17
C87 (\7\:n5g VSS) capacitor c=7.97367e-17
C88 (\13\:ExtVDD VSS) capacitor c=5.46988e-17
C89 (\11\:n5 VSS) capacitor c=8.80991e-17
C90 (\7\:n5 VSS) capacitor c=2.66033e-17
C91 (\18\:Gb VSS) capacitor c=3.8191e-17
C92 (\18\:VDD VSS) capacitor c=6.71755e-17
C93 (\20\:VDD VSS) capacitor c=5.41404e-17
C94 (\13\:Gb VSS) capacitor c=4.4018e-17
C95 (\8\:Gbb VSS) capacitor c=5.2868e-17
C96 (\4\:Q VSS) capacitor c=3.48755e-17
C97 (\9\:Qbint VSS) capacitor c=5.57262e-17
C98 (\3\:net171 VSS) capacitor c=4.44412e-17
C99 (\17\:n5 VSS) capacitor c=3.6584e-17
C100 (\3\:QN VSS) capacitor c=4.6734e-17
C101 (\12\:RTb VSS) capacitor c=2.5119e-17
C102 (\15\:n5g VSS) capacitor c=1.98547e-17
C103 (\16\:Qint VSS) capacitor c=3.79946e-17
C104 (\9\:n5g VSS) capacitor c=9.10183e-17
C105 (\15\:n5 VSS) capacitor c=4.10533e-17
C106 (\9\:n5 VSS) capacitor c=6.75234e-17
C107 (\8\:VDD VSS) capacitor c=2.93324e-16
C108 (\16\:Gb VSS) capacitor c=4.13463e-17
C109 (\10\:Gbb VSS) capacitor c=2.54426e-17
C110 (VDD VSS) capacitor c=1.54265e-17
C111 (\2\:Gb VSS) capacitor c=4.87889e-17
C112 (ExtVDD VSS) capacitor c=3.82923e-17
C113 (\2\:n5g VSS) capacitor c=7.11964e-17
C114 (\2\:RT VSS) capacitor c=8.36392e-17
C115 (\3\:RT VSS) capacitor c=7.46195e-17
C116 (\4\:Qint VSS) capacitor c=2.48672e-17
C117 (\5\:Qint VSS) capacitor c=4.5845e-17
C118 (\6\:Qint VSS) capacitor c=6.35672e-17
C119 (\7\:Qint VSS) capacitor c=3.999e-17
C120 (\2\:Qbint VSS) capacitor c=1.95501e-17
C121 (\6\:Gbb VSS) capacitor c=5.63382e-17
C122 (\7\:Gbb VSS) capacitor c=5.84832e-17
C123 (\10\:Gb VSS) capacitor c=9.6479e-18
C124 (\11\:Gb VSS) capacitor c=5.03085e-17
C125 (\12\:Gb VSS) capacitor c=7.28718e-17
C126 (\15\:Gb VSS) capacitor c=4.96406e-17
C127 (\5\:n5 VSS) capacitor c=1.9319e-17
C128 (\6\:n5 VSS) capacitor c=5.39319e-17
C129 (\13\:RT VSS) capacitor c=2.35311e-17
C130 (\13\:n5 VSS) capacitor c=6.07697e-17
C131 (\14\:n5 VSS) capacitor c=4.98936e-17
C132 (\5\:SN VSS) capacitor c=1.70746e-17
C133 (\6\:SN VSS) capacitor c=1.33468e-17
C134 (\7\:SN VSS) capacitor c=3.40392e-17
C135 (\14\:Qint VSS) capacitor c=2.1198e-17
C136 (\15\:Qint VSS) capacitor c=5.52527e-17
C137 (\6\:n5g VSS) capacitor c=2.49801e-17
C138 (\5\:ExtVDD VSS) capacitor c=5.58395e-17
C139 (\12\:ExtVDD VSS) capacitor c=4.53017e-17
C140 (\15\:ExtVDD VSS) capacitor c=1.69896e-17
C141 (\6\:RTb VSS) capacitor c=2.79626e-17
C142 (\9\:RTb VSS) capacitor c=3.78922e-17
C143 (\10\:RTb VSS) capacitor c=5.89529e-17
C144 (\11\:RTb VSS) capacitor c=6.2111e-17
C145 (\13\:n5g VSS) capacitor c=9.80116e-17
C146 (\14\:n5g VSS) capacitor c=2.74754e-17
C147 (\14\:RT VSS) capacitor c=1.29474e-16
C148 (\15\:RT VSS) capacitor c=1.3129e-16
C149 (\20\:Gb VSS) capacitor c=1.38534e-16
C150 (\21\:Gb VSS) capacitor c=1.58298e-16
C151 (\12\:Gbb VSS) capacitor c=1.89977e-16
C152 (\13\:Gbb VSS) capacitor c=2.41215e-16
C153 (\19\:n5 VSS) capacitor c=1.07836e-16
C154 (\20\:n5 VSS) capacitor c=1.81088e-16
C155 (\5\:Qbint VSS) capacitor c=2.8e-17
C156 (\1\:Q VSS) capacitor c=2.52192e-17
C157 (\3\:VDD VSS) capacitor c=3.20792e-17
C158 (\4\:VDD VSS) capacitor c=2.0481e-17
C159 (\6\:VDD VSS) capacitor c=1.19444e-17
C160 (\7\:VDD VSS) capacitor c=2.94475e-16
Rk3 (\4\:D D) resistor r=0.003195 c=0
Rk79 (\2\:VSS \4\:VSS) resistor r=0.2898 c=0
Rk81 (\5\:VSS VSS) resistor r=0.5443 c=0
Rk80 (\4\:VSS \5\:VSS) resistor r=0.6431 c=0
Rk83 (\6\:VSS VSS) resistor r=0.1853 c=0
Rk82 (VSS \6\:VSS) resistor r=0.6436 c=0
Rk84 (VSS \8\:VSS) resistor r=0.5487 c=0
Rk85 (VSS \10\:VSS) resistor r=0.3045 c=0
Rk86 (\12\:VSS \13\:VSS) resistor r=0.08143 c=0
Rk87 (\13\:VSS \14\:VSS) resistor r=0.1161 c=0
Rk88 (\14\:VSS \15\:VSS) resistor r=0.1136 c=0
Rk89 (\15\:VSS \16\:VSS) resistor r=0.3313 c=0
Rk91 (\17\:VSS VSS) resistor r=0.2098 c=0
Rk90 (\16\:VSS \17\:VSS) resistor r=0.2843 c=0
Rk92 (VSS \18\:VSS) resistor r=0.3241 c=0
Rk94 (\19\:VSS VSS) resistor r=0.5791 c=0
Rk93 (\18\:VSS \19\:VSS) resistor r=0.121 c=0
Rk95 (VSS \20\:VSS) resistor r=0.1141 c=0
Rk96 (\13\:VSS \22\:VSS) resistor r=0.2468 c=0
Rk97 (\15\:VSS \24\:VSS) resistor r=0.2586 c=0
Rk98 (\17\:VSS \26\:VSS) resistor r=0.2765 c=0
Rk99 (\18\:VSS \28\:VSS) resistor r=0.2375 c=0
Rk100 (VSS \30\:VSS) resistor r=0.3041 c=0
Rk16 (\10\:RT RT) resistor r=0.003262 c=0
Rk17 (\11\:RT RT) resistor r=0.001957 c=0
Rk18 (\10\:RT \11\:RT) resistor r=0.01271 c=0
Rk20 (\11\:RT \13\:RT) resistor r=0.0252 c=0
Rk19 (\12\:RT \13\:RT) resistor r=0.003262 c=0
Rk49 (\14\:RT \15\:RT) resistor r=1.0394 c=0
Rk24 (SN \5\:SN) resistor r=0.004303 c=0
Rk25 (SN \6\:SN) resistor r=0.003346 c=0
Rk26 (\5\:SN \6\:SN) resistor r=0.04235 c=0
Rk28 (\6\:SN \7\:SN) resistor r=0.03579 c=0
Rk27 (\7\:SN \8\:SN) resistor r=0.004303 c=0
Rk37 (ExtVDD ExtVDD) resistor r=0.003843 c=0
Rk34 (\4\:ExtVDD \5\:ExtVDD) resistor r=0.2265 c=0
Rk35 (\7\:ExtVDD ExtVDD) resistor r=0.1378 c=0
Rk38 (ExtVDD \11\:ExtVDD) resistor r=0.154 c=0
Rk39 (\11\:ExtVDD \12\:ExtVDD) resistor r=0.1776 c=0
Rk40 (\12\:ExtVDD \14\:ExtVDD) resistor r=0.4993 c=0
Rk41 (\12\:ExtVDD \15\:ExtVDD) resistor r=0.0553 c=0
Rk53 (QN \4\:QN) resistor r=0.09339 c=0
Rk52 (\2\:QN \4\:QN) resistor r=0.5735 c=0
Rk62 (Q \1\:Q) resistor r=0.005928 c=0
Rk63 (\1\:Q \3\:Q) resistor r=0.3105 c=0
Rk64 (\1\:Q \5\:Q) resistor r=0.2975 c=0
Rk2 (G \4\:G) resistor r=0.009292 c=0
Rk73 (VDD VDD) resistor r=0.1311 c=0
Rk65 (\2\:VDD \3\:VDD) resistor r=0.3857 c=0
Rk66 (\3\:VDD \4\:VDD) resistor r=0.09855 c=0
Rk67 (\4\:VDD \6\:VDD) resistor r=0.09133 c=0
Rk68 (\6\:VDD \7\:VDD) resistor r=0.03938 c=0
Rk69 (\7\:VDD \9\:VDD) resistor r=1.7798 c=0
Rk70 (\9\:VDD \10\:VDD) resistor r=0.05326 c=0
Rk72 (\11\:VDD VDD) resistor r=0.04675 c=0
Rk71 (\10\:VDD \11\:VDD) resistor r=0.03171 c=0
Rk74 (\3\:VDD \13\:VDD) resistor r=0.3556 c=0
Rk75 (\4\:VDD \15\:VDD) resistor r=0.2808 c=0
Rk76 (\7\:VDD \17\:VDD) resistor r=0.3732 c=0
Rk77 (\10\:VDD \19\:VDD) resistor r=0.2853 c=0
Rk78 (\11\:VDD \21\:VDD) resistor r=0.3287 c=0
Rk7 (\10\:Gb \11\:Gb) resistor r=0.1047 c=0
Rk8 (\11\:Gb \12\:Gb) resistor r=0.2421 c=0
Rk9 (\12\:Gb \14\:Gb) resistor r=0.4247 c=0
Rk10 (\14\:Gb \15\:Gb) resistor r=0.2369 c=0
Rk11 (\11\:Gb \17\:Gb) resistor r=0.2508 c=0
Rk12 (\12\:Gb \19\:Gb) resistor r=0.1542 c=0
Rk50 (\20\:Gb \21\:Gb) resistor r=0.8015 c=0
Rk4 (\6\:Gbb \7\:Gbb) resistor r=0.2892 c=0
Rk5 (\7\:Gbb \9\:Gbb) resistor r=0.4421 c=0
Rk6 (\7\:Gbb \11\:Gbb) resistor r=0.1687 c=0
Rk51 (\12\:Gbb \13\:Gbb) resistor r=1.6116 c=0
Rk13 (\5\:n5 \6\:n5) resistor r=0.2055 c=0
Rk14 (\6\:n5 \8\:n5) resistor r=0.1994 c=0
Rk15 (\6\:n5 \10\:n5) resistor r=0.4735 c=0
Rk21 (\12\:n5 \13\:n5) resistor r=0.5951 c=0
Rk22 (\12\:n5 \14\:n5) resistor r=0.2474 c=0
Rk23 (\14\:n5 \16\:n5) resistor r=0.3214 c=0
Rk54 (\18\:n5 \19\:n5) resistor r=0.3435 c=0
Rk55 (\19\:n5 \20\:n5) resistor r=1.0799 c=0
Rk56 (\19\:n5 \22\:n5) resistor r=0.2538 c=0
Rk57 (\5\:Qbint \6\:Qbint) resistor r=0.02343 c=0
Rk58 (\6\:Qbint \8\:Qbint) resistor r=0.3096 c=0
Rk59 (\6\:Qbint \10\:Qbint) resistor r=0.2055 c=0
Rk29 (\14\:Qint \15\:Qint) resistor r=0.05628 c=0
Rk30 (\15\:Qint \17\:Qint) resistor r=0.2215 c=0
Rk31 (\15\:Qint \19\:Qint) resistor r=0.3712 c=0
Rk32 (\6\:n5g \8\:n5g) resistor r=0.1083 c=0
Rk33 (\8\:n5g \10\:n5g) resistor r=0.5656 c=0
Rk46 (\12\:n5g \13\:n5g) resistor r=0.7354 c=0
Rk47 (\13\:n5g \14\:n5g) resistor r=0.1062 c=0
Rk48 (\13\:n5g \16\:n5g) resistor r=0.08852 c=0
Rk42 (\6\:RTb \8\:RTb) resistor r=0.1322 c=0
Rk43 (\9\:RTb \10\:RTb) resistor r=0.1673 c=0
Rk44 (\10\:RTb \11\:RTb) resistor r=0.3284 c=0
Rk45 (\10\:RTb \13\:RTb) resistor r=0.09349 c=0
Rk61 (\2\:net103 \4\:net103) resistor r=0.6382 c=0
Rk60 (\2\:net171 \4\:net171) resistor r=0.3528 c=0
Rl2 (\2\:D \3\:D) resistor r=87.7202 c=0
Rl1 (\1\:D \2\:D) resistor r=133.743 c=0
Rl31 (\8\:RT \9\:RT) resistor r=350.785 c=0
Rl27 (\5\:RT \6\:RT) resistor r=204.389 c=0
Rl26 (\2\:RT \5\:RT) resistor r=26.665 c=0
Rl23 (\1\:RT \2\:RT) resistor r=182.259 c=0
Rl28 (\3\:RT \7\:RT) resistor r=21.372 c=0
Rl25 (\3\:RT \4\:RT) resistor r=104.717 c=0
Rl24 (\2\:RT \3\:RT) resistor r=218.989 c=0
Rl14 (\2\:SN \4\:SN) resistor r=159.702 c=0
Rl12 (\1\:SN \2\:SN) resistor r=53.5603 c=0
Rl13 (\2\:SN \3\:SN) resistor r=2.0644 c=0
Rl17 (\1\:ExtVDD \2\:ExtVDD) resistor r=176.713 c=0
Rl49 (\1\:RN \2\:RN) resistor r=215.452 c=0
Rl50 (\2\:RN \3\:RN) resistor r=1636.76 c=0
Rl53 (\4\:RN \6\:RN) resistor r=178.055 c=0
Rl51 (\3\:RN \4\:RN) resistor r=56.5719 c=0
Rl52 (\4\:RN \5\:RN) resistor r=0.6051 c=0
Rl3 (\1\:G \2\:G) resistor r=88.3245 c=0
Rl4 (\2\:G \3\:G) resistor r=127.297 c=0
Rl8 (\4\:Gb \5\:Gb) resistor r=249.542 c=0
Rl33 (\8\:Gb \9\:Gb) resistor r=361.066 c=0
Rl15 (\6\:Gb \7\:Gb) resistor r=435.371 c=0
Rl5 (Gb \2\:Gb) resistor r=168.204 c=0
Rl7 (\2\:Gb \4\:Gb) resistor r=64.1356 c=0
Rl6 (\2\:Gb \3\:Gb) resistor r=143.548 c=0
Rl32 (\4\:Gbb \5\:Gbb) resistor r=178.565 c=0
Rl10 (Gbb \2\:Gbb) resistor r=696.861 c=0
Rl11 (\2\:Gbb \3\:Gbb) resistor r=44.0258 c=0
Rl22 (\3\:n5 \4\:n5) resistor r=172.871 c=0
Rl9 (n5 \2\:n5) resistor r=331.394 c=0
Rl46 (Qbint \2\:Qbint) resistor r=60.9354 c=0
Rl48 (\2\:Qbint \4\:Qbint) resistor r=93.3448 c=0
Rl47 (\2\:Qbint \3\:Qbint) resistor r=83.7545 c=0
Rl34 (Qint \2\:Qint) resistor r=232.216 c=0
Rl35 (\2\:Qint \3\:Qint) resistor r=322.396 c=0
Rl36 (\3\:Qint \4\:Qint) resistor r=60.9354 c=0
Rl41 (\4\:Qint \9\:Qint) resistor r=93.3448 c=0
Rl42 (\5\:Qint \10\:Qint) resistor r=59.4143 c=0
Rl43 (\5\:Qint \11\:Qint) resistor r=91.8237 c=0
Rl37 (\4\:Qint \5\:Qint) resistor r=59.826 c=0
Rl44 (\6\:Qint \12\:Qint) resistor r=101.868 c=0
Rl38 (\5\:Qint \6\:Qint) resistor r=412.667 c=0
Rl45 (\7\:Qint \13\:Qint) resistor r=67.7766 c=0
Rl40 (\7\:Qint \8\:Qint) resistor r=186.916 c=0
Rl39 (\6\:Qint \7\:Qint) resistor r=20.6699 c=0
Rl21 (\4\:n5g \5\:n5g) resistor r=317.727 c=0
Rl18 (n5g \2\:n5g) resistor r=109.66 c=0
Rl20 (\2\:n5g \4\:n5g) resistor r=191.281 c=0
Rl19 (\2\:n5g \3\:n5g) resistor r=38.4366 c=0
Rl16 (RTb \2\:RTb) resistor r=124.916 c=0
Rl29 (\3\:RTb \4\:RTb) resistor r=306.661 c=0
Rl30 (\4\:RTb \5\:RTb) resistor r=184.803 c=0
Rz19 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz20 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz21 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz22 (\21\:VSS \22\:VSS) resistor r=37.5 c=0
Rz23 (\23\:VSS \24\:VSS) resistor r=37.5 c=0
Rz24 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz25 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz26 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz10 (\3\:QN \4\:QN) resistor r=37.5 c=0
Rz15 (\4\:Q \5\:Q) resistor r=37.5 c=0
Rz17 (\8\:VDD \9\:VDD) resistor r=37.5 c=0
Rz18 (\8\:VDD \11\:VDD) resistor r=75 c=0
Rz2 (\16\:Gb \17\:Gb) resistor r=75 c=0
Rz1 (\10\:Gbb \11\:Gbb) resistor r=75 c=0
Rz3 (\9\:n5 \10\:n5) resistor r=75 c=0
Rz4 (\15\:n5 \16\:n5) resistor r=75 c=0
Rz11 (\17\:n5 \18\:n5) resistor r=75 c=0
Rz12 (\9\:Qbint \10\:Qbint) resistor r=37.5 c=0
Rz5 (\16\:Qint \17\:Qint) resistor r=75 c=0
Rz6 (\9\:n5g \10\:n5g) resistor r=75 c=0
Rz9 (\15\:n5g \16\:n5g) resistor r=75 c=0
Rz8 (\12\:RTb \13\:RTb) resistor r=75 c=0
Rz13 (net171 \2\:net171) resistor r=75 c=0
Rz14 (\3\:net171 \4\:net171) resistor r=75 c=0
Ry26 (\3\:VSS \4\:VSS) resistor r=62 c=0
Ry27 (\3\:VSS \5\:VSS) resistor r=5.1667 c=0
Ry28 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry29 (\11\:VSS \12\:VSS) resistor r=31 c=0
Ry30 (\11\:VSS \14\:VSS) resistor r=31 c=0
Ry31 (\11\:VSS \16\:VSS) resistor r=8.8571 c=0
Ry32 (\11\:VSS \19\:VSS) resistor r=5.1667 c=0
Ry33 (\11\:VSS \20\:VSS) resistor r=31 c=0
Ry8 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry9 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry10 (\10\:ExtVDD \11\:ExtVDD) resistor r=62 c=0
Ry11 (\13\:ExtVDD \14\:ExtVDD) resistor r=62 c=0
Ry14 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry19 (\2\:Q \3\:Q) resistor r=20.6667 c=0
Ry20 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry21 (\12\:VDD \13\:VDD) resistor r=20.6667 c=0
Ry22 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry23 (\16\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry24 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry25 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry2 (\13\:Gb \14\:Gb) resistor r=62 c=0
Ry3 (\18\:Gb \19\:Gb) resistor r=62 c=0
Ry1 (\8\:Gbb \9\:Gbb) resistor r=62 c=0
Ry4 (\7\:n5 \8\:n5) resistor r=62 c=0
Ry5 (\11\:n5 \12\:n5) resistor r=62 c=0
Ry15 (\21\:n5 \22\:n5) resistor r=62 c=0
Ry16 (\7\:Qbint \8\:Qbint) resistor r=20.6667 c=0
Ry6 (\18\:Qint \19\:Qint) resistor r=62 c=0
Ry7 (\7\:n5g \8\:n5g) resistor r=62 c=0
Ry13 (\11\:n5g \12\:n5g) resistor r=62 c=0
Ry12 (\7\:RTb \8\:RTb) resistor r=62 c=0
Ry17 (net103 \2\:net103) resistor r=62 c=0
Ry18 (\3\:net103 \4\:net103) resistor r=62 c=0
Rx3 (\2\:D \4\:D) resistor r=45 c=0
Rx8 (\4\:RT \12\:RT) resistor r=45 c=0
Rx20 (\8\:RT \14\:RT) resistor r=45 c=0
Rx21 (\6\:RT \15\:RT) resistor r=45 c=0
Rx11 (\3\:SN \8\:SN) resistor r=45 c=0
Rx14 (\2\:ExtVDD \5\:ExtVDD) resistor r=45 c=0
Rx15 (\1\:ExtVDD \15\:ExtVDD) resistor r=45 c=0
Rx1 (\5\:RN RN) resistor r=45 c=0
Rx2 (\2\:G \4\:G) resistor r=45 c=0
Rx5 (\7\:Gb \10\:Gb) resistor r=45 c=0
Rx6 (\3\:Gb \15\:Gb) resistor r=45 c=0
Rx22 (\9\:Gb \20\:Gb) resistor r=45 c=0
Rx23 (\6\:Gb \21\:Gb) resistor r=45 c=0
Rx4 (\2\:Gbb \6\:Gbb) resistor r=45 c=0
Rx24 (\5\:Gbb \12\:Gbb) resistor r=45 c=0
Rx25 (Gbb \13\:Gbb) resistor r=45 c=0
Rx7 (n5 \5\:n5) resistor r=45 c=0
Rx9 (\2\:n5 \13\:n5) resistor r=45 c=0
Rx10 (\4\:n5 \14\:n5) resistor r=45 c=0
Rx26 (\3\:n5 \20\:n5) resistor r=45 c=0
Rx27 (\3\:Qbint \5\:Qbint) resistor r=45 c=0
Rx12 (\8\:Qint \14\:Qint) resistor r=45 c=0
Rx13 (\5\:n5g \6\:n5g) resistor r=45 c=0
Rx19 (n5g \14\:n5g) resistor r=45 c=0
Rx16 (\4\:RTb \6\:RTb) resistor r=45 c=0
Rx17 (\5\:RTb \9\:RTb) resistor r=45 c=0
Rx18 (RTb \11\:RTb) resistor r=45 c=0
mn2 (\10\:Gbb \5\:Gb \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn0 (net159 \3\:RN \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (\16\:Gb \3\:G net159 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn5 (net191 \1\:D \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn6 (\9\:n5 \3\:Gbb net191 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
NM0 (\9\:n5g \2\:RTb \15\:n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.2779 \
        scb=0.00944477 scc=0.000275883 m=(1)
mn10 (net183 \1\:SN \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn11 (\16\:Qint \3\:n5g net183 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn45 (\12\:RTb \1\:RT \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
NM2 (\15\:n5g \9\:RT net094 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
NM3 (net094 \13\:Qint \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=18.4982 \
        scb=0.0194884 scc=0.00168796 m=(1)
mn22 (\3\:QN \11\:Qint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(1)
mn17 (\17\:n5 \8\:Gb \3\:net171 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn20 (\9\:Qbint \9\:Qint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(1)
mn16 (net171 Qint net167 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn21 (\4\:Q Qbint \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
mn15 (net167 \2\:RN \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mp0 (\13\:Gb \6\:RN \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=17.9195 \
        scb=0.0189757 scc=0.000406591 m=(1)
mp5 (net142 \3\:D \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=17.8355 \
        scb=0.0186759 scc=0.000523731 m=(1)
mp1 (\18\:Gb \1\:G \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=22.2251 \
        scb=0.0245336 scc=0.00126258 m=(1)
mp6 (\7\:n5 Gb net142 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=27.621 scb=0.0284013 \
        scc=0.00267219 m=(1)
PM0 (\7\:n5g \7\:RT \11\:n5 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=29.0164 \
        scb=0.0322998 scc=0.00288094 m=(1)
mp10 (\18\:Qint \4\:SN \13\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 \
