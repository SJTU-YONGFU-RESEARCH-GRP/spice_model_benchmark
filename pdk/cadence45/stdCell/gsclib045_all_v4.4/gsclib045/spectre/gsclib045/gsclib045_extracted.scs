C39 (\3\:mout VSS) capacitor c=5.35654e-17
C40 (\8\:qbint VSS) capacitor c=4.03019e-17
C41 (\2\:n30 VSS) capacitor c=4.42263e-17
C42 (\3\:CK VSS) capacitor c=4.00712e-17
C43 (\3\:qbint VSS) capacitor c=2.87055e-17
C44 (\6\:SE VSS) capacitor c=5.17167e-17
C45 (\2\:SI VSS) capacitor c=8.31628e-17
C46 (\4\:SE VSS) capacitor c=5.02569e-17
C47 (\2\:SEb VSS) capacitor c=9.64593e-17
C48 (\2\:SE VSS) capacitor c=4.27332e-17
C49 (\2\:D VSS) capacitor c=7.42594e-17
C50 (\7\:CKbb VSS) capacitor c=4.71639e-17
C51 (\11\:CKb VSS) capacitor c=3.18404e-17
C52 (\5\:CKbb VSS) capacitor c=2.7388e-17
C53 (\2\:mout VSS) capacitor c=5.42434e-17
C54 (\2\:n20 VSS) capacitor c=4.52239e-17
C55 (\4\:CKb VSS) capacitor c=2.48597e-17
C56 (\2\:CKbb VSS) capacitor c=5.25662e-17
C57 (\2\:CKb VSS) capacitor c=3.24401e-17
C58 (\7\:qbint VSS) capacitor c=4.62852e-17
C59 (\3\:n30 VSS) capacitor c=2.20292e-17
C60 (\2\:CK VSS) capacitor c=2.79671e-17
C61 (\4\:SEb VSS) capacitor c=1.247e-17
C62 (\12\:VDD VSS) capacitor c=3.31738e-17
C63 (\8\:Db VSS) capacitor c=4.49039e-17
C64 (\14\:VDD VSS) capacitor c=4.25979e-17
C65 (\8\:CKbb VSS) capacitor c=7.95031e-17
C66 (\4\:Db VSS) capacitor c=1.01831e-16
C67 (\4\:n20 VSS) capacitor c=3.49199e-17
C68 (\16\:VDD VSS) capacitor c=1.44373e-17
C69 (\6\:mout VSS) capacitor c=4.04857e-17
C70 (\4\:n30 VSS) capacitor c=7.43487e-17
C71 (\18\:VDD VSS) capacitor c=1.41146e-17
C72 (\13\:qbint VSS) capacitor c=4.53581e-17
C73 (\15\:CKb VSS) capacitor c=9.84968e-17
C74 (\20\:VDD VSS) capacitor c=4.66819e-17
C75 (\1\:Q VSS) capacitor c=5.56474e-17
C76 (\1\:VDD VSS) capacitor c=1.49427e-16
C77 (\8\:SEb VSS) capacitor c=7.8466e-17
C78 (\14\:CKbb VSS) capacitor c=4.23951e-17
C79 (\6\:Db VSS) capacitor c=7.10544e-17
C80 (\8\:n20 VSS) capacitor c=4.73883e-17
C81 (\8\:mout VSS) capacitor c=3.30023e-17
C82 (\6\:n30 VSS) capacitor c=1.07465e-16
C83 (\11\:qbint VSS) capacitor c=8.12278e-17
C84 (\17\:CKb VSS) capacitor c=6.69829e-17
C85 (\3\:Q VSS) capacitor c=5.17128e-17
C86 (\2\:qbint VSS) capacitor c=1.57041e-17
C87 (\6\:CKb VSS) capacitor c=7.0217e-17
C88 (\7\:CKb VSS) capacitor c=6.43131e-17
C89 (\4\:CK VSS) capacitor c=5.66149e-17
C90 (\9\:qbint VSS) capacitor c=3.05521e-17
C91 (\10\:qbint VSS) capacitor c=3.31212e-17
C92 (\15\:qbint VSS) capacitor c=1.38135e-16
C93 (\8\:n30 VSS) capacitor c=6.60595e-17
C94 (\4\:mout VSS) capacitor c=5.07879e-17
C95 (\5\:mout VSS) capacitor c=5.05844e-17
C96 (\12\:CKb VSS) capacitor c=5.59331e-17
C97 (\13\:CKb VSS) capacitor c=8.03931e-17
C98 (\14\:CKb VSS) capacitor c=9.95334e-17
C99 (\20\:CKb VSS) capacitor c=5.21024e-17
C100 (\6\:n20 VSS) capacitor c=5.51071e-17
C101 (\7\:n20 VSS) capacitor c=5.35473e-17
C102 (\10\:CKbb VSS) capacitor c=1.37168e-16
C103 (\11\:CKbb VSS) capacitor c=5.2489e-17
C104 (\12\:CKbb VSS) capacitor c=8.6684e-17
C105 (\13\:CKbb VSS) capacitor c=1.16585e-16
C106 (\16\:CKbb VSS) capacitor c=1.70274e-17
C107 (\4\:D VSS) capacitor c=6.34051e-17
C108 (\3\:Db VSS) capacitor c=1.56639e-16
C109 (\8\:SE VSS) capacitor c=3.76191e-17
C110 (\9\:SE VSS) capacitor c=7.97426e-17
C111 (\10\:SE VSS) capacitor c=6.22457e-17
C112 (\6\:SEb VSS) capacitor c=1.00571e-16
C113 (\7\:SEb VSS) capacitor c=8.76413e-17
C114 (\3\:VDD VSS) capacitor c=1.15593e-18
C115 (\5\:VDD VSS) capacitor c=1.0388e-18
C116 (\7\:VDD VSS) capacitor c=9.81269e-18
C117 (\9\:VDD VSS) capacitor c=1.94394e-17
C118 (\11\:VDD VSS) capacitor c=4.42447e-18
Rk28 (\4\:D D) resistor r=0.09047 c=0
Rk1 (\2\:Q Q) resistor r=0.3595 c=0
Rk2 (Q \4\:Q) resistor r=0.0595 c=0
Rk3 (\4\:CK CK) resistor r=0.194 c=0
Rk33 (SE \8\:SE) resistor r=0.03328 c=0
Rk34 (\8\:SE \9\:SE) resistor r=0.1953 c=0
Rk35 (\9\:SE \10\:SE) resistor r=0.3246 c=0
Rk40 (\2\:VDD \3\:VDD) resistor r=0.1151 c=0
Rk41 (\3\:VDD \4\:VDD) resistor r=0.1853 c=0
Rk42 (\4\:VDD \5\:VDD) resistor r=0.1878 c=0
Rk43 (\5\:VDD \6\:VDD) resistor r=0.263 c=0
Rk44 (\6\:VDD \7\:VDD) resistor r=0.2856 c=0
Rk45 (\7\:VDD \8\:VDD) resistor r=0.2154 c=0
Rk46 (\8\:VDD \9\:VDD) resistor r=0.2931 c=0
Rk47 (\9\:VDD \10\:VDD) resistor r=0.258 c=0
Rk49 (\11\:VDD VDD) resistor r=0.1074 c=0
Rk48 (\10\:VDD \11\:VDD) resistor r=0.1427 c=0
Rk50 (\3\:VDD \13\:VDD) resistor r=0.2336 c=0
Rk51 (\5\:VDD \15\:VDD) resistor r=0.2336 c=0
Rk52 (\7\:VDD \17\:VDD) resistor r=0.07369 c=0
Rk53 (\9\:VDD \19\:VDD) resistor r=0.1024 c=0
Rk54 (\11\:VDD \21\:VDD) resistor r=0.2714 c=0
Rk36 (\4\:SI SI) resistor r=0.001381 c=0
Rk55 (\2\:VSS \3\:VSS) resistor r=0.1151 c=0
Rk56 (\3\:VSS \4\:VSS) resistor r=0.1853 c=0
Rk57 (\4\:VSS \5\:VSS) resistor r=0.1878 c=0
Rk58 (\5\:VSS \6\:VSS) resistor r=0.2129 c=0
Rk59 (\6\:VSS \7\:VSS) resistor r=0.3448 c=0
Rk60 (\7\:VSS \8\:VSS) resistor r=0.4551 c=0
Rk61 (\3\:VSS \10\:VSS) resistor r=0.2662 c=0
Rk62 (\5\:VSS \12\:VSS) resistor r=0.268 c=0
Rk63 (\7\:VSS \14\:VSS) resistor r=0.04329 c=0
Rk65 (\15\:VSS VSS) resistor r=0.1074 c=0
Rk64 (\8\:VSS \15\:VSS) resistor r=0.4447 c=0
Rk66 (\8\:VSS \17\:VSS) resistor r=0.07145 c=0
Rk67 (\15\:VSS \19\:VSS) resistor r=0.2929 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.1677 c=0
Rk5 (\10\:qbint \12\:qbint) resistor r=0.1221 c=0
Rk6 (\10\:qbint \14\:qbint) resistor r=0.2355 c=0
Rk7 (\12\:qbint \15\:qbint) resistor r=0.7734 c=0
Rk13 (\12\:CKb \13\:CKb) resistor r=0.4684 c=0
Rk14 (\13\:CKb \14\:CKb) resistor r=0.3626 c=0
Rk15 (\14\:CKb \16\:CKb) resistor r=0.6335 c=0
Rk16 (\16\:CKb \18\:CKb) resistor r=0.2774 c=0
Rk17 (\13\:CKb \19\:CKb) resistor r=0.0153 c=0
Rk18 (\14\:CKb \20\:CKb) resistor r=0.3252 c=0
Rk8 (\5\:n30 \7\:n30) resistor r=0.4351 c=0
Rk9 (\7\:n30 \8\:n30) resistor r=0.51 c=0
Rk10 (\4\:mout \5\:mout) resistor r=0.2384 c=0
Rk11 (\5\:mout \7\:mout) resistor r=0.2366 c=0
Rk12 (\5\:mout \9\:mout) resistor r=0.1276 c=0
Rk22 (\9\:CKbb \10\:CKbb) resistor r=0.5614 c=0
Rk23 (\10\:CKbb \11\:CKbb) resistor r=0.3571 c=0
Rk24 (\11\:CKbb \12\:CKbb) resistor r=0.2134 c=0
Rk25 (\12\:CKbb \13\:CKbb) resistor r=0.7606 c=0
Rk26 (\11\:CKbb \15\:CKbb) resistor r=0.2505 c=0
Rk27 (\12\:CKbb \16\:CKbb) resistor r=0.03035 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.1344 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.264 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.2513 c=0
Rk29 (\2\:Db \3\:Db) resistor r=0.7183 c=0
Rk30 (\3\:Db \5\:Db) resistor r=0.4026 c=0
Rk31 (\5\:Db \7\:Db) resistor r=0.3935 c=0
Rk32 (\3\:Db \9\:Db) resistor r=0.2962 c=0
Rk37 (\5\:SEb \6\:SEb) resistor r=0.04776 c=0
Rk38 (\6\:SEb \7\:SEb) resistor r=0.5307 c=0
Rk39 (\6\:SEb \9\:SEb) resistor r=0.6657 c=0
Rl27 (\1\:D \2\:D) resistor r=171.411 c=0
Rl28 (\2\:D \3\:D) resistor r=100.257 c=0
Rl4 (\1\:CK \2\:CK) resistor r=29.5379 c=0
Rl5 (\2\:CK \3\:CK) resistor r=56.461 c=0
Rl35 (\5\:SE \6\:SE) resistor r=187.23 c=0
Rl36 (\6\:SE \7\:SE) resistor r=42.9995 c=0
Rl32 (\3\:SE \4\:SE) resistor r=37.6944 c=0
Rl29 (\1\:SE \2\:SE) resistor r=74.2328 c=0
Rl33 (\1\:SI \2\:SI) resistor r=116.54 c=0
Rl34 (\2\:SI \3\:SI) resistor r=110.771 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2713 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=68.9449 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=34.3295 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=112.741 c=0
Rl10 (\6\:qbint \8\:qbint) resistor r=34.3295 c=0
Rl9 (\6\:qbint \7\:qbint) resistor r=0.5166 c=0
Rl26 (\8\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl14 (\3\:CKb \4\:CKb) resistor r=47.3097 c=0
Rl11 (CKb \2\:CKb) resistor r=43.4636 c=0
Rl21 (\5\:CKb \6\:CKb) resistor r=162.261 c=0
Rl24 (\6\:CKb \9\:CKb) resistor r=96.8761 c=0
Rl23 (\7\:CKb \8\:CKb) resistor r=159.159 c=0
Rl25 (\7\:CKb \10\:CKb) resistor r=30.4507 c=0
Rl22 (\6\:CKb \7\:CKb) resistor r=181.607 c=0
Rl6 (n30 \2\:n30) resistor r=146.154 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl17 (mout \2\:mout) resistor r=91.0764 c=0
Rl18 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl20 (\6\:CKbb \7\:CKbb) resistor r=43.4636 c=0
Rl19 (\4\:CKbb \5\:CKbb) resistor r=67.9995 c=0
Rl12 (CKbb \2\:CKbb) resistor r=25.0391 c=0
Rl13 (\2\:CKbb \3\:CKbb) resistor r=114.381 c=0
Rl15 (n20 \2\:n20) resistor r=86.3335 c=0
Rl16 (\2\:n20 \3\:n20) resistor r=33.5406 c=0
Rl30 (SEb \2\:SEb) resistor r=107.398 c=0
Rl31 (\2\:SEb \3\:SEb) resistor r=153.955 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz11 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz12 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz13 (\1\:VDD \6\:VDD) resistor r=15 c=0
Rz14 (\1\:VDD \8\:VDD) resistor r=15 c=0
Rz15 (\1\:VDD \10\:VDD) resistor r=12.5 c=0
Rz16 (\9\:VSS \10\:VSS) resistor r=75 c=0
Rz17 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz18 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz19 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz20 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz2 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz5 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz3 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz4 (\8\:mout \9\:mout) resistor r=75 c=0
Rz7 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\6\:Db \7\:Db) resistor r=75 c=0
Rz10 (\8\:SEb \9\:SEb) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry11 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry12 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry13 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry14 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry15 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry16 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry17 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry18 (\1\:VSS \6\:VSS) resistor r=15.5 c=0
Ry19 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry2 (\13\:qbint \14\:qbint) resistor r=62 c=0
Ry5 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry4 (\6\:mout \7\:mout) resistor r=62 c=0
Ry7 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry8 (\4\:Db \5\:Db) resistor r=62 c=0
Ry9 (\8\:Db \9\:Db) resistor r=62 c=0
Ry10 (\4\:SEb \5\:SEb) resistor r=62 c=0
Rx13 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx14 (\6\:SE \8\:SE) resistor r=45 c=0
Rx15 (\4\:SE \9\:SE) resistor r=45 c=0
Rx16 (\2\:SE \10\:SE) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\7\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (qbint \15\:qbint) resistor r=45 c=0
Rx6 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\4\:CKb \19\:CKb) resistor r=45 c=0
Rx8 (\2\:CKb \20\:CKb) resistor r=45 c=0
Rx4 (\3\:n30 \8\:n30) resistor r=45 c=0
Rx5 (\2\:mout \4\:mout) resistor r=45 c=0
Rx10 (\7\:CKbb \10\:CKbb) resistor r=45 c=0
Rx11 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx12 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=3.64e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.18462e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (\17\:CKb \3\:CK \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=2.755e-14 ps=9.7e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn45 (\11\:qbint \2\:n30 \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.465e-14 ps=1.6e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.845e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (n7 \8\:qbint \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.32e-14 ps=1.6e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.65e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\6\:n30 CKb n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.335e-14 ps=6.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.445e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\8\:mout CKbb \6\:n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=4.568e-14 ps=7.5e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=1.17e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\8\:mout n20 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.48e-14 ad=4.568e-14 ps=1.64e-06 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=8.1e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (n5 \3\:mout \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.48e-14 ad=8.7e-15 ps=1.64e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=5.95e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (\8\:n20 \4\:CKbb n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.525e-06 sb=4.9e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (\6\:Db \10\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.133e-14 ps=6.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.73e-06 sb=2.85e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\14\:CKbb \9\:CKb \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.09e-06 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn11 (n1 \3\:D \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.683e-14 ps=6.1e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.85e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn12 (Db \3\:SEb n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.683e-14 ad=2.32e-14 ps=6.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=6.55e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn14 (Db \3\:SE n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.8e-07 sb=4.5e-07 sd=160n sca=9.87692 scb=0.0087933 \
        scc=0.000232488 m=(1)
mn13 (n3 \3\:SI \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=3.45e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mn10 (\8\:SEb \7\:SE \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09e-06 sb=1.4e-07 sd=160n sca=9.87692 \
        scb=0.0087933 scc=0.000232488 m=(1)
mp20 (\15\:CKb \1\:CK \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.288e-14 ad=4.085e-14 ps=1.23e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=1.9e-07 sd=160n sca=28.366 scb=0.0254155 \
        scc=0.00302764 m=(1)
mp45 (\13\:qbint n30 \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.845e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp50 (n8 \5\:qbint \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=5.482e-14 ps=1.62e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.58e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp51 (\4\:n30 \3\:CKbb n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.482e-14 ad=3.44e-14 ps=9.4e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.05e-07 sb=1.28e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp40 (\4\:n30 \3\:CKb \6\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.44e-14 ps=7.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.1e-07 sb=1.075e-06 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp30 (\6\:mout \3\:n20 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.23e-14 ad=3.655e-14 ps=1.62e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=8.6e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp35 (n6 mout \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=1.29e-14 ps=1.62e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=5.95e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp36 (\4\:n20 \8\:CKb n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.87e-14 ps=5.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.495e-06 sb=4.9e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp25 (\4\:n20 \6\:CKbb \4\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.697e-14 ad=3.87e-14 ps=9.6e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72e-06 sb=2.65e-07 sd=160n sca=14.5646 \
        scb=0.0142004 scc=0.000753562 m=(1)
mp21 (\8\:CKbb \5\:CKb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.09e-06 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp11 (n2 \1\:D \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.978e-14 ps=7.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=8.85e-07 sd=160n sca=10.3256 \
        scb=0.00769229 scc=9.29431e-05 m=(1)
mp12 (\8\:Db \1\:SE n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.978e-14 ad=3.44e-14 ps=8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=6.55e-07 sd=160n sca=10.5972 \
        scb=0.00776431 scc=9.29552e-05 m=(1)
mp14 (\8\:Db SEb n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.8e-07 sb=4.5e-07 sd=160n sca=11.4263 scb=0.00831104 \
        scc=9.35693e-05 m=(1)
mp13 (n4 \1\:SI \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.85e-07 sb=3.45e-07 sd=160n sca=12.2213 \
        scb=0.00924687 scc=9.7291e-05 m=(1)
mp10 (\4\:SEb \5\:SE \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09e-06 sb=1.4e-07 sd=160n sca=16.0509 \
        scb=0.0157301 scc=0.000264062 m=(1)
ends SDFFQX1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:28:48 2012 )
// Library name: gsclib045
// Cell name: SDFFQX2
// View name: extracted

simulator lang=spectre

subckt SDFFQX2 CK D Q SE SI VDD VSS
mp55_1__rcx (\1\:Q qbint VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.131e-14 ad=6.24e-14 ps=1.155e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.03462e-07 sd=160n sca=41.3017 \
        scb=0.035902 scc=0.00422214 m=(2)
C1 (D VSS) capacitor c=8.20112e-17
C2 (Q VSS) capacitor c=9.96005e-18
C3 (CK VSS) capacitor c=6.14957e-17
C4 (SE VSS) capacitor c=7.29784e-17
C5 (VDD VSS) capacitor c=3.99633e-16
C6 (SI VSS) capacitor c=9.18205e-17
C7 (qbint VSS) capacitor c=1.51664e-16
C8 (CKb VSS) capacitor c=4.43088e-17
C9 (n30 VSS) capacitor c=3.09886e-17
C10 (n7 VSS) capacitor c=4.3707e-18
C11 (mout VSS) capacitor c=7.98878e-17
C12 (CKbb VSS) capacitor c=2.23511e-17
C13 (n20 VSS) capacitor c=3.9558e-17
C14 (Db VSS) capacitor c=9.88814e-17
C15 (n1 VSS) capacitor c=8.18964e-18
C16 (SEb VSS) capacitor c=4.58499e-17
C17 (n8 VSS) capacitor c=7.52667e-18
C18 (\7\:SE VSS) capacitor c=5.16852e-17
C19 (\3\:SI VSS) capacitor c=6.50629e-17
C20 (\1\:SE VSS) capacitor c=4.01041e-17
C21 (\1\:D VSS) capacitor c=4.57661e-17
C22 (\5\:CKb VSS) capacitor c=6.5032e-17
C23 (\6\:CKbb VSS) capacitor c=4.08137e-17
C24 (\8\:CKb VSS) capacitor c=7.18149e-17
C25 (\3\:CKb VSS) capacitor c=5.00448e-17
C26 (\3\:CKbb VSS) capacitor c=4.98023e-17
C27 (\8\:qbint VSS) capacitor c=3.11209e-17
C28 (\3\:n30 VSS) capacitor c=5.09838e-17
C29 (\1\:CK VSS) capacitor c=4.25812e-17
C30 (\5\:SE VSS) capacitor c=2.5577e-17
C31 (\1\:SI VSS) capacitor c=6.6106e-17
C32 (\3\:SE VSS) capacitor c=6.83555e-17
C33 (\3\:SEb VSS) capacitor c=5.63631e-17
C34 (\3\:D VSS) capacitor c=3.67728e-17
C35 (\9\:CKb VSS) capacitor c=2.85125e-17
C36 (\10\:CKb VSS) capacitor c=3.77007e-17
C37 (\5\:CKbb VSS) capacitor c=7.67326e-17
C38 (\3\:mout VSS) capacitor c=5.41802e-17
C39 (\3\:n20 VSS) capacitor c=4.22308e-17
C40 (\10\:qbint VSS) capacitor c=4.87981e-17
C41 (\3\:CK VSS) capacitor c=4.13347e-17
C42 (\6\:SE VSS) capacitor c=5.33263e-17
C43 (\2\:SI VSS) capacitor c=6.48973e-17
C44 (\4\:SE VSS) capacitor c=4.4794e-17
C45 (\2\:SEb VSS) capacitor c=5.3028e-17
C46 (\2\:SE VSS) capacitor c=4.03843e-17
C47 (\2\:D VSS) capacitor c=7.87715e-17
C48 (\7\:CKbb VSS) capacitor c=3.86427e-17
C49 (\4\:CKbb VSS) capacitor c=4.02305e-17
C50 (\11\:CKb VSS) capacitor c=3.03272e-17
C51 (\2\:mout VSS) capacitor c=5.43702e-17
C52 (\2\:n20 VSS) capacitor c=3.91188e-17
C53 (\4\:CKb VSS) capacitor c=2.53048e-17
C54 (\2\:CKbb VSS) capacitor c=4.80422e-17
C55 (\2\:CKb VSS) capacitor c=3.60444e-17
C56 (\9\:qbint VSS) capacitor c=4.04265e-17
C57 (\2\:CK VSS) capacitor c=3.98602e-17
C58 (\6\:qbint VSS) capacitor c=1.91542e-17
C59 (\8\:SEb VSS) capacitor c=1.32966e-17
C60 (\1\:VDD VSS) capacitor c=5.43981e-17
C61 (\6\:Db VSS) capacitor c=4.54276e-17
C62 (\12\:VDD VSS) capacitor c=4.04996e-17
C63 (\8\:CKbb VSS) capacitor c=7.18127e-17
C64 (\4\:Db VSS) capacitor c=1.08204e-16
C65 (\4\:n20 VSS) capacitor c=3.5147e-17
C66 (\14\:VDD VSS) capacitor c=1.69093e-17
C67 (\6\:mout VSS) capacitor c=3.98897e-17
C68 (\9\:n30 VSS) capacitor c=6.94322e-17
C69 (\16\:VDD VSS) capacitor c=3.61741e-17
C70 (\12\:qbint VSS) capacitor c=6.68131e-17
C71 (\15\:CKb VSS) capacitor c=1.12597e-16
C72 (\1\:Q VSS) capacitor c=7.82556e-17
C73 (\3\:VDD VSS) capacitor c=3.85266e-17
C74 (\4\:SEb VSS) capacitor c=7.06888e-17
C75 (\14\:CKbb VSS) capacitor c=5.45951e-17
C76 (\8\:Db VSS) capacitor c=8.19375e-17
C77 (\8\:n20 VSS) capacitor c=5.55217e-17
C78 (\8\:mout VSS) capacitor c=3.61522e-17
C79 (\5\:n30 VSS) capacitor c=2.30504e-17
C80 (\14\:qbint VSS) capacitor c=1.29567e-16
C81 (\18\:CKb VSS) capacitor c=1.10706e-16
C82 (\4\:Q VSS) capacitor c=2.5289e-17
C83 (\2\:n30 VSS) capacitor c=2.96625e-17
C84 (\6\:CKb VSS) capacitor c=6.46076e-17
C85 (\7\:CKb VSS) capacitor c=6.13446e-17
C86 (\3\:Q VSS) capacitor c=3.751e-17
C87 (\4\:CK VSS) capacitor c=4.451e-17
C88 (\11\:qbint VSS) capacitor c=4.15409e-17
C89 (\16\:qbint VSS) capacitor c=1.35471e-16
C90 (\7\:n30 VSS) capacitor c=7.44388e-17
C91 (\8\:n30 VSS) capacitor c=8.195e-17
C92 (\4\:mout VSS) capacitor c=4.97062e-17
C93 (\5\:mout VSS) capacitor c=5.1848e-17
C94 (\12\:CKb VSS) capacitor c=6.04807e-17
C95 (\13\:CKb VSS) capacitor c=8.62708e-17
C96 (\14\:CKb VSS) capacitor c=9.39628e-17
C97 (\17\:CKb VSS) capacitor c=5.54406e-17
C98 (\6\:n20 VSS) capacitor c=6.02023e-17
C99 (\7\:n20 VSS) capacitor c=5.11456e-17
C100 (\10\:CKbb VSS) capacitor c=1.24114e-16
C101 (\11\:CKbb VSS) capacitor c=6.55916e-17
C102 (\12\:CKbb VSS) capacitor c=7.70595e-17
C103 (\13\:CKbb VSS) capacitor c=1.14552e-16
C104 (\4\:D VSS) capacitor c=3.43479e-17
C105 (\3\:Db VSS) capacitor c=1.30614e-16
C106 (\8\:SE VSS) capacitor c=4.68497e-17
C107 (\10\:SE VSS) capacitor c=7.75366e-17
C108 (\4\:SI VSS) capacitor c=4.36076e-17
C109 (\6\:SEb VSS) capacitor c=1.07079e-16
C110 (\7\:SEb VSS) capacitor c=6.16118e-17
C111 (\5\:VDD VSS) capacitor c=2.29988e-17
C112 (\6\:VDD VSS) capacitor c=6.32348e-17
C113 (\7\:VDD VSS) capacitor c=2.59201e-17
Rk27 (\4\:D D) resistor r=0.06529 c=0
Rk2 (\3\:Q Q) resistor r=0.002419 c=0
Rk1 (\2\:Q \3\:Q) resistor r=0.3231 c=0
Rk3 (\3\:Q \5\:Q) resistor r=0.1898 c=0
Rk4 (CK \4\:CK) resistor r=0.1109 c=0
Rk32 (\8\:SE SE) resistor r=0.2343 c=0
Rk34 (SE \10\:SE) resistor r=0.3782 c=0
Rk51 (\2\:VDD \4\:VDD) resistor r=0.6041 c=0
Rk52 (\4\:VDD \5\:VDD) resistor r=0.05746 c=0
Rk53 (\5\:VDD \6\:VDD) resistor r=0.5486 c=0
Rk54 (\6\:VDD \7\:VDD) resistor r=0.5637 c=0
Rk56 (\8\:VDD VDD) resistor r=0.3307 c=0
Rk55 (\7\:VDD \8\:VDD) resistor r=0.03239 c=0
Rk59 (\5\:VDD \13\:VDD) resistor r=0.2584 c=0
Rk60 (\6\:VDD \15\:VDD) resistor r=0.07369 c=0
Rk61 (\7\:VDD \17\:VDD) resistor r=0.209 c=0
Rk35 (\4\:SI SI) resistor r=0.1351 c=0
Rk39 (\2\:VSS \4\:VSS) resistor r=0.6634 c=0
Rk40 (\4\:VSS \5\:VSS) resistor r=0.05746 c=0
Rk41 (\5\:VSS \6\:VSS) resistor r=0.5477 c=0
Rk42 (\6\:VSS \7\:VSS) resistor r=0.5961 c=0
Rk43 (\5\:VSS \9\:VSS) resistor r=0.2966 c=0
Rk44 (\6\:VSS \11\:VSS) resistor r=0.04329 c=0
Rk47 (\12\:VSS VSS) resistor r=0.0151 c=0
Rk45 (\7\:VSS \12\:VSS) resistor r=0.3307 c=0
Rk48 (\7\:VSS \15\:VSS) resistor r=0.3674 c=0
Rk5 (\11\:qbint \13\:qbint) resistor r=0.2244 c=0
Rk6 (\13\:qbint \15\:qbint) resistor r=0.3633 c=0
Rk7 (\15\:qbint \16\:qbint) resistor r=0.835 c=0
Rk14 (\12\:CKb \13\:CKb) resistor r=0.464 c=0
Rk15 (\13\:CKb \14\:CKb) resistor r=0.3948 c=0
Rk16 (\14\:CKb \16\:CKb) resistor r=0.4697 c=0
Rk17 (\14\:CKb \17\:CKb) resistor r=0.2686 c=0
Rk18 (\16\:CKb \19\:CKb) resistor r=0.6422 c=0
Rk8 (\6\:n30 \7\:n30) resistor r=0.06409 c=0
Rk9 (\7\:n30 \8\:n30) resistor r=0.432 c=0
Rk10 (\7\:n30 \10\:n30) resistor r=0.3852 c=0
Rk11 (\4\:mout \5\:mout) resistor r=0.2532 c=0
Rk12 (\5\:mout \7\:mout) resistor r=0.2422 c=0
Rk13 (\5\:mout \9\:mout) resistor r=0.1387 c=0
Rk22 (\9\:CKbb \10\:CKbb) resistor r=0.5321 c=0
Rk23 (\10\:CKbb \11\:CKbb) resistor r=0.3682 c=0
Rk24 (\11\:CKbb \12\:CKbb) resistor r=0.1381 c=0
Rk25 (\12\:CKbb \13\:CKbb) resistor r=0.78 c=0
Rk26 (\11\:CKbb \15\:CKbb) resistor r=0.2499 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.1397 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.2722 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.1974 c=0
Rk28 (\2\:Db \3\:Db) resistor r=0.6893 c=0
Rk29 (\3\:Db \5\:Db) resistor r=0.4325 c=0
Rk30 (\3\:Db \7\:Db) resistor r=0.271 c=0
Rk31 (\5\:Db \9\:Db) resistor r=0.48 c=0
Rk36 (\5\:SEb \6\:SEb) resistor r=0.7076 c=0
Rk37 (\6\:SEb \7\:SEb) resistor r=0.4859 c=0
Rk38 (\6\:SEb \9\:SEb) resistor r=0.04776 c=0
Rl30 (\1\:D \2\:D) resistor r=119.488 c=0
Rl31 (\2\:D \3\:D) resistor r=123.334 c=0
Rl7 (\1\:CK \2\:CK) resistor r=139.56 c=0
Rl8 (\2\:CK \3\:CK) resistor r=53.0211 c=0
Rl39 (\6\:SE \7\:SE) resistor r=166.483 c=0
Rl38 (\5\:SE \6\:SE) resistor r=36.5385 c=0
Rl35 (\3\:SE \4\:SE) resistor r=35.3072 c=0
Rl32 (\1\:SE \2\:SE) resistor r=79.5379 c=0
Rl37 (\2\:SI \3\:SI) resistor r=104.104 c=0
Rl36 (\1\:SI \2\:SI) resistor r=96.8456 c=0
Rl12 (\9\:qbint \8\:qbint) resistor r=30.1196 c=0
Rl13 (\9\:qbint \10\:qbint) resistor r=94.0258 c=0
Rl5 (qbint \6\:qbint) resistor r=4.8851 c=0
Rl29 (\8\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl17 (\3\:CKb \4\:CKb) resistor r=37.6944 c=0
Rl14 (CKb \2\:CKb) resistor r=53.079 c=0
Rl24 (\5\:CKb \6\:CKb) resistor r=148.799 c=0
Rl27 (\6\:CKb \9\:CKb) resistor r=81.4915 c=0
Rl26 (\7\:CKb \8\:CKb) resistor r=186.082 c=0
Rl28 (\7\:CKb \10\:CKb) resistor r=30.4507 c=0
Rl25 (\6\:CKb \7\:CKb) resistor r=164.3 c=0
Rl9 (n30 \2\:n30) resistor r=37.477 c=0
Rl10 (\2\:n30 \3\:n30) resistor r=52.8616 c=0
Rl11 (\2\:n30 \4\:n30) resistor r=6.1589 c=0
Rl20 (mout \2\:mout) resistor r=93.4636 c=0
Rl21 (\2\:mout \3\:mout) resistor r=33.8482 c=0
Rl23 (\6\:CKbb \7\:CKbb) resistor r=41.5405 c=0
Rl22 (\4\:CKbb \5\:CKbb) resistor r=40.8563 c=0
Rl15 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl16 (\2\:CKbb \3\:CKbb) resistor r=138.016 c=0
Rl18 (n20 \2\:n20) resistor r=31.9251 c=0
Rl19 (\2\:n20 \3\:n20) resistor r=95.3867 c=0
Rl33 (SEb \2\:SEb) resistor r=76.9231 c=0
Rl34 (\2\:SEb \3\:SEb) resistor r=127.421 c=0
Rz1 (\5\:Q \4\:Q) resistor r=75 c=0
Rz17 (\4\:VDD \3\:VDD) resistor r=6.25 c=0
Rz18 (\8\:VDD \3\:VDD) resistor r=6.25 c=0
Rz11 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz12 (\9\:VSS \8\:VSS) resistor r=75 c=0
Rz13 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz14 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz2 (\15\:qbint \14\:qbint) resistor r=75 c=0
Rz5 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz3 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz4 (\8\:mout \9\:mout) resistor r=75 c=0
Rz7 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\8\:Db \9\:Db) resistor r=75 c=0
Rz10 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry1 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry13 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry15 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry16 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry17 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry11 (\4\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry12 (\7\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry2 (\13\:qbint \12\:qbint) resistor r=62 c=0
Ry5 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\9\:n30 \10\:n30) resistor r=62 c=0
Ry4 (\6\:mout \7\:mout) resistor r=62 c=0
Ry7 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry8 (\4\:Db \5\:Db) resistor r=62 c=0
Ry9 (\6\:Db \7\:Db) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Rx13 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx15 (\4\:SE SE) resistor r=45 c=0
Rx14 (\6\:SE \8\:SE) resistor r=45 c=0
Rx16 (\2\:SE \10\:SE) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\11\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (\16\:qbint \6\:qbint) resistor r=45 c=0
Rx6 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\4\:CKb \13\:CKb) resistor r=45 c=0
Rx8 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx4 (\4\:n30 \8\:n30) resistor r=45 c=0
Rx5 (\2\:mout \4\:mout) resistor r=45 c=0
Rx10 (\7\:CKbb \10\:CKbb) resistor r=45 c=0
Rx11 (\4\:CKbb \12\:CKbb) resistor r=45 c=0
Rx12 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn55 (\4\:Q qbint \12\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.003e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.29038e-07 sd=160n sca=7.84363 \
        scb=0.00546499 scc=9.84911e-05 m=(2)
mn20 (\18\:CKb \3\:CK \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.407e-14 ps=9e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=2.35e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn45 (\14\:qbint n30 \14\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=2.87e-14 ps=7.9e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.41317e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn50 (n7 \10\:qbint \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.595e-14 ad=2.682e-14 ps=7.9e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.705e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\5\:n30 CKb n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=3.335e-14 ps=6.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=1.475e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\8\:mout CKbb \5\:n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.335e-14 ad=4.277e-14 ps=7.5e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=1.2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn30 (\8\:mout \3\:n20 \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.41e-14 ad=4.278e-14 ps=1.6e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=8.6e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (n5 \3\:mout \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=8.7e-15 ps=1.6e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.485e-06 sb=5.95e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (\8\:n20 \5\:CKbb n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.973e-14 ps=4.1e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59e-06 sb=4.9e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (\8\:Db \10\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.973e-14 ad=3.48e-14 ps=7e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.84e-06 sb=2.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\14\:CKbb \9\:CKb \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.205e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (n1 \3\:D \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.205e-14 ps=6.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1e-06 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn12 (Db \3\:SEb n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.205e-14 ad=2.32e-14 ps=8.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.8e-07 sb=6.65e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn14 (Db \3\:SE n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.85e-07 sb=4.6e-07 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn13 (n3 \1\:SI \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=8.7e-15 ps=6.3e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.9e-07 sb=3.55e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn10 (\4\:SEb \5\:SE \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.03e-14 ps=6.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp20 (\15\:CKb \1\:CK VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.802e-14 ad=3.87e-14 ps=1.25e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=1.8e-07 sd=160n sca=13.4091 \
        scb=0.0119825 scc=0.00042533 m=(1)
mp45 (\12\:qbint \3\:n30 \16\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=7.71e-14 ad=4.34e-14 ps=1.48e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.67661e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp50 (n8 \8\:qbint \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.71e-14 ad=7.202e-14 ps=1.48e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.28488e-07 sb=1.69e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp51 (\9\:n30 \3\:CKbb n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.202e-14 ad=3.44e-14 ps=1.1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.08488e-07 sb=1.31e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp40 (\9\:n30 \3\:CKb \6\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.44e-14 ps=8.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.13488e-07 sb=1.105e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp30 (\6\:mout n20 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.93e-14 ad=4.3e-14 ps=1.57e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15849e-06 sb=8.6e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp25 (\4\:n20 \6\:CKbb \4\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.052e-14 ad=4.515e-14 ps=9e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78349e-06 sb=2.35e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp35 (n6 mout \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.93e-14 ad=1.29e-14 ps=1.57e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42349e-06 sb=5.95e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp36 (\4\:n20 \8\:CKb n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=4.515e-14 ps=5.5e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.52849e-06 sb=4.9e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp21 (\8\:CKbb \5\:CKb \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.15e-06 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp11 (n2 \1\:D \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.45e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp12 (\6\:Db \1\:SE n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.87e-14 ps=7.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=7.25e-07 sd=160n sca=10.8061 \
        scb=0.00857865 scc=0.000148871 m=(1)
mp14 (\6\:Db SEb n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.365e-14 ad=3.87e-14 ps=6.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=5e-07 sd=160n sca=11.3106 scb=0.00875354 \
        scc=0.000148925 m=(1)
mp13 (n4 \3\:SI \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.365e-14 ps=7.5e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.45e-07 sb=3.45e-07 sd=160n sca=12.0628 \
        scb=0.00935347 scc=0.000149867 m=(1)
mp10 (\8\:SEb \7\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=1.4e-07 sd=160n sca=14.4353 \
        scb=0.0129221 scc=0.000190612 m=(1)
ends SDFFQX2
// End of subcircuit definition.

// Generated for: spectre (May  9 17:29:26 2012 )
// Library name: gsclib045
// Cell name: SDFFQX4
// View name: extracted

simulator lang=spectre

subckt SDFFQX4 CK D Q SE SI VDD VSS
mp20 (\17\:CKb \4\:CK \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.39721e-06 sd=160n sca=59.4536 \
        scb=0.0473468 scc=0.00729053 m=(1)
C1 (D VSS) capacitor c=7.23676e-17
C2 (CK VSS) capacitor c=5.45216e-17
C3 (Q VSS) capacitor c=2.97243e-16
C4 (SE VSS) capacitor c=6.45373e-17
C5 (VDD VSS) capacitor c=3.2061e-16
C6 (SI VSS) capacitor c=4.2e-17
C7 (CKb VSS) capacitor c=5.55081e-17
C8 (qbint VSS) capacitor c=2.6415e-16
C9 (n30 VSS) capacitor c=1.92767e-16
C10 (n7 VSS) capacitor c=7.38617e-19
C11 (mout VSS) capacitor c=3.85997e-17
C12 (CKbb VSS) capacitor c=4.38176e-17
C13 (n20 VSS) capacitor c=5.39537e-17
C14 (n5 VSS) capacitor c=1.91161e-18
C15 (Db VSS) capacitor c=9.92033e-17
C16 (n1 VSS) capacitor c=5.99035e-18
C17 (SEb VSS) capacitor c=3.28545e-17
C18 (n8 VSS) capacitor c=2.04398e-18
C19 (n6 VSS) capacitor c=2.92314e-18
C20 (n2 VSS) capacitor c=1.93991e-19
C21 (n4 VSS) capacitor c=3.42778e-18
C22 (\7\:SE VSS) capacitor c=4.95237e-17
C23 (\3\:SI VSS) capacitor c=5.03829e-17
C24 (\2\:SE VSS) capacitor c=4.76605e-17
C25 (\1\:D VSS) capacitor c=5.97791e-17
C26 (\6\:CKb VSS) capacitor c=5.04844e-17
C27 (\8\:CKbb VSS) capacitor c=2.54883e-17
C28 (\4\:CKb VSS) capacitor c=5.3017e-17
C29 (\4\:mout VSS) capacitor c=6.84535e-17
C30 (\3\:n20 VSS) capacitor c=3.11311e-17
C31 (\2\:CKbb VSS) capacitor c=4.008e-17
C32 (\17\:qbint VSS) capacitor c=4.96897e-17
C33 (\4\:CK VSS) capacitor c=3.14637e-17
C34 (\5\:SE VSS) capacitor c=2.72852e-17
C35 (\1\:SI VSS) capacitor c=6.43858e-17
C36 (\3\:SE VSS) capacitor c=6.79361e-17
C37 (\3\:SEb VSS) capacitor c=7.00262e-17
C38 (\3\:D VSS) capacitor c=3.52631e-17
C39 (\10\:CKb VSS) capacitor c=3.04844e-17
C40 (\9\:CKb VSS) capacitor c=1.28013e-17
C41 (\7\:CKbb VSS) capacitor c=4.78831e-17
C42 (\3\:CKbb VSS) capacitor c=4.42959e-17
C43 (\2\:CKb VSS) capacitor c=5.19123e-17
C44 (\14\:qbint VSS) capacitor c=3.5528e-17
C45 (\3\:CK VSS) capacitor c=2.82623e-17
C46 (\6\:SE VSS) capacitor c=5.46735e-17
C47 (\2\:SI VSS) capacitor c=7.59189e-17
C48 (\4\:SE VSS) capacitor c=4.89615e-17
C49 (\1\:SE VSS) capacitor c=5.17388e-17
C50 (\2\:D VSS) capacitor c=5.24819e-17
C51 (\8\:CKb VSS) capacitor c=4.34574e-17
C52 (\5\:CKbb VSS) capacitor c=1.80561e-17
C53 (\5\:CKb VSS) capacitor c=4.46656e-17
C54 (\3\:mout VSS) capacitor c=5.6411e-17
C55 (\2\:n20 VSS) capacitor c=4.53441e-17
C56 (\4\:CKbb VSS) capacitor c=3.67713e-17
C57 (\3\:CKb VSS) capacitor c=2.25087e-17
C58 (\16\:qbint VSS) capacitor c=4.81174e-17
C59 (\1\:CK VSS) capacitor c=1.9044e-17
C60 (\9\:SEb VSS) capacitor c=7.71419e-18
C61 (\12\:VDD VSS) capacitor c=3.3732e-17
C62 (\9\:Db VSS) capacitor c=7.12879e-17
C63 (\1\:VDD VSS) capacitor c=4.16617e-17
C64 (\9\:CKbb VSS) capacitor c=6.92336e-17
C65 (\5\:Db VSS) capacitor c=7.4119e-17
C66 (\6\:n20 VSS) capacitor c=9.46115e-17
C67 (\14\:VDD VSS) capacitor c=1.37226e-17
C68 (\8\:mout VSS) capacitor c=6.249e-17
C69 (\12\:n30 VSS) capacitor c=2.72612e-17
C70 (\24\:qbint VSS) capacitor c=7.0859e-17
C71 (\17\:CKb VSS) capacitor c=4.02159e-17
C72 (\4\:VDD VSS) capacitor c=1.13928e-16
C73 (\5\:SEb VSS) capacitor c=6.99109e-17
C74 (\15\:CKbb VSS) capacitor c=8.81908e-17
C75 (\7\:Db VSS) capacitor c=9.98011e-17
C76 (\4\:n20 VSS) capacitor c=8.83198e-17
C77 (\5\:mout VSS) capacitor c=2.93282e-17
C78 (\8\:n30 VSS) capacitor c=8.24349e-17
C79 (\22\:qbint VSS) capacitor c=3.35128e-17
C80 (\14\:CKb VSS) capacitor c=1.76574e-16
C81 (\2\:CK VSS) capacitor c=1.28434e-17
C82 (\6\:CKbb VSS) capacitor c=3.23462e-17
C83 (\7\:CKb VSS) capacitor c=5.8659e-17
C84 (\2\:SEb VSS) capacitor c=6.65974e-17
C85 (\5\:CK VSS) capacitor c=6.28677e-17
C86 (\18\:qbint VSS) capacitor c=5.42568e-17
C87 (\19\:qbint VSS) capacitor c=2.06896e-17
C88 (\20\:qbint VSS) capacitor c=2.59219e-17
C89 (\21\:qbint VSS) capacitor c=3.89398e-17
C90 (\10\:n30 VSS) capacitor c=8.29629e-17
C91 (\11\:n30 VSS) capacitor c=5.84307e-17
C92 (\7\:mout VSS) capacitor c=4.13761e-17
C93 (\10\:mout VSS) capacitor c=4.72748e-17
C94 (\8\:n20 VSS) capacitor c=7.16453e-17
C95 (\11\:CKb VSS) capacitor c=9.35123e-17
C96 (\12\:CKb VSS) capacitor c=1.26909e-16
C97 (\13\:CKb VSS) capacitor c=2.30401e-16
C98 (\16\:CKb VSS) capacitor c=7.42881e-17
C99 (\11\:CKbb VSS) capacitor c=1.83925e-16
C100 (\12\:CKbb VSS) capacitor c=1.05617e-16
C101 (\14\:CKbb VSS) capacitor c=4.22422e-17
C102 (\17\:CKbb VSS) capacitor c=1.27063e-16
C103 (\4\:D VSS) capacitor c=4.44807e-17
C104 (\3\:Db VSS) capacitor c=1.56012e-16
C105 (\4\:Db VSS) capacitor c=1.13083e-16
C106 (\8\:SE VSS) capacitor c=4.9168e-17
C107 (\9\:SE VSS) capacitor c=7.30768e-17
C108 (\4\:SI VSS) capacitor c=8.59992e-17
C109 (\7\:SEb VSS) capacitor c=8.32327e-17
C110 (\8\:SEb VSS) capacitor c=6.87936e-17
C111 (\3\:VDD VSS) capacitor c=1.22534e-17
C112 (\7\:VDD VSS) capacitor c=2.1371e-17
C113 (\8\:VDD VSS) capacitor c=2.94421e-16
Rk31 (\4\:D D) resistor r=0.08242 c=0
Rk1 (CK \5\:CK) resistor r=0.0703 c=0
Rk38 (\9\:SE SE) resistor r=0.2325 c=0
Rk37 (\8\:SE \9\:SE) resistor r=0.3512 c=0
Rk64 (\2\:VDD \3\:VDD) resistor r=0.2529 c=0
Rk65 (\3\:VDD \5\:VDD) resistor r=0.04744 c=0
Rk66 (\5\:VDD \6\:VDD) resistor r=0.6519 c=0
Rk67 (\6\:VDD \7\:VDD) resistor r=0.05903 c=0
Rk79 (\8\:VDD VDD) resistor r=0.1174 c=0
Rk68 (\7\:VDD \8\:VDD) resistor r=0.5428 c=0
Rk71 (\3\:VDD \11\:VDD) resistor r=0.3032 c=0
Rk72 (\11\:VDD \13\:VDD) resistor r=0.3349 c=0
Rk73 (\7\:VDD \15\:VDD) resistor r=0.0433 c=0
Rk40 (SI \4\:SI) resistor r=0.0119 c=0
Rk44 (\2\:VSS \3\:VSS) resistor r=0.09258 c=0
Rk45 (\3\:VSS \4\:VSS) resistor r=0.2079 c=0
Rk46 (\4\:VSS \5\:VSS) resistor r=0.1879 c=0
Rk47 (\5\:VSS \6\:VSS) resistor r=0.3634 c=0
Rk48 (\6\:VSS \7\:VSS) resistor r=0.3533 c=0
Rk49 (\7\:VSS \8\:VSS) resistor r=0.248 c=0
Rk50 (\8\:VSS \9\:VSS) resistor r=0.2907 c=0
Rk56 (\14\:VSS VSS) resistor r=0.0499 c=0
Rk55 (\9\:VSS \14\:VSS) resistor r=0.05246 c=0
Rk57 (\3\:VSS \16\:VSS) resistor r=0.2951 c=0
Rk58 (\5\:VSS \18\:VSS) resistor r=0.286 c=0
Rk59 (\7\:VSS \20\:VSS) resistor r=0.07381 c=0
Rk20 (\11\:CKb \12\:CKb) resistor r=0.5815 c=0
Rk21 (\12\:CKb \13\:CKb) resistor r=0.6021 c=0
Rk22 (\13\:CKb \15\:CKb) resistor r=1.5784 c=0
Rk23 (\12\:CKb \16\:CKb) resistor r=0.3493 c=0
Rk24 (\15\:CKb \18\:CKb) resistor r=0.2855 c=0
Rk7 (\18\:qbint \19\:qbint) resistor r=0.2925 c=0
Rk8 (\19\:qbint \20\:qbint) resistor r=0.0683 c=0
Rk9 (\20\:qbint \21\:qbint) resistor r=0.1858 c=0
Rk10 (\19\:qbint \23\:qbint) resistor r=0.188 c=0
Rk11 (\20\:qbint \25\:qbint) resistor r=0.2839 c=0
Rk12 (\9\:n30 \10\:n30) resistor r=0.516 c=0
Rk13 (\10\:n30 \11\:n30) resistor r=0.2866 c=0
Rk14 (\10\:n30 \13\:n30) resistor r=0.2095 c=0
Rk15 (\6\:mout \7\:mout) resistor r=0.09754 c=0
Rk16 (\7\:mout \9\:mout) resistor r=0.2708 c=0
Rk17 (\7\:mout \10\:mout) resistor r=0.1967 c=0
Rk25 (\10\:CKbb \11\:CKbb) resistor r=0.6188 c=0
Rk26 (\11\:CKbb \12\:CKbb) resistor r=0.2783 c=0
Rk27 (\11\:CKbb \13\:CKbb) resistor r=0.9614 c=0
Rk28 (\13\:CKbb \14\:CKbb) resistor r=0.1478 c=0
Rk29 (\12\:CKbb \16\:CKbb) resistor r=0.5819 c=0
Rk30 (\13\:CKbb \17\:CKbb) resistor r=0.04616 c=0
Rk18 (\5\:n20 \7\:n20) resistor r=0.416 c=0
Rk19 (\7\:n20 \8\:n20) resistor r=0.4113 c=0
Rk32 (\2\:Db \3\:Db) resistor r=0.6544 c=0
Rk33 (\3\:Db \4\:Db) resistor r=0.36 c=0
Rk34 (\4\:Db \6\:Db) resistor r=0.3483 c=0
Rk35 (\3\:Db \8\:Db) resistor r=0.6392 c=0
Rk36 (\4\:Db \10\:Db) resistor r=0.5483 c=0
Rk41 (\6\:SEb \7\:SEb) resistor r=0.6289 c=0
Rk42 (\7\:SEb \8\:SEb) resistor r=0.4055 c=0
Rk43 (\7\:SEb \10\:SEb) resistor r=0.02784 c=0
Rl42 (\1\:D \2\:D) resistor r=116.076 c=0
Rl43 (\2\:D \3\:D) resistor r=89.1533 c=0
Rl3 (\2\:CK \4\:CK) resistor r=40.0987 c=0
Rl2 (\2\:CK \3\:CK) resistor r=43.9449 c=0
Rl1 (\1\:CK \2\:CK) resistor r=1.2713 c=0
Rl52 (\6\:SE \7\:SE) resistor r=170.33 c=0
Rl51 (\5\:SE \6\:SE) resistor r=36.5385 c=0
Rl48 (\3\:SE \4\:SE) resistor r=35.3072 c=0
Rl44 (\1\:SE \2\:SE) resistor r=66.565 c=0
Rl50 (\2\:SI \3\:SI) resistor r=111.516 c=0
Rl49 (\1\:SI \2\:SI) resistor r=92.1028 c=0
Rl26 (CKb \2\:CKb) resistor r=153.412 c=0
Rl40 (\8\:CKb \9\:CKb) resistor r=26.1559 c=0
Rl34 (\4\:CKb \5\:CKb) resistor r=48.7687 c=0
Rl27 (\2\:CKb \3\:CKb) resistor r=26.1559 c=0
Rl38 (\6\:CKb \7\:CKb) resistor r=156.926 c=0
Rl41 (\7\:CKb \10\:CKb) resistor r=70.3874 c=0
Rl39 (\7\:CKb \8\:CKb) resistor r=241.784 c=0
Rl24 (\15\:qbint \17\:qbint) resistor r=104.785 c=0
Rl22 (\15\:qbint \14\:qbint) resistor r=47.0924 c=0
Rl23 (\15\:qbint \16\:qbint) resistor r=2.9709 c=0
Rl31 (mout \2\:mout) resistor r=37.477 c=0
Rl33 (\2\:mout \4\:mout) resistor r=114.4 c=0
Rl32 (\2\:mout \3\:mout) resistor r=2.7461 c=0
Rl25 (CKbb \2\:CKbb) resistor r=57.6695 c=0
Rl28 (\3\:CKbb \4\:CKbb) resistor r=66.0764 c=0
Rl37 (\6\:CKbb \8\:CKbb) resistor r=39.7465 c=0
Rl36 (\6\:CKbb \7\:CKbb) resistor r=156.166 c=0
Rl35 (\5\:CKbb \6\:CKbb) resistor r=27.7015 c=0
Rl29 (n20 \2\:n20) resistor r=94.3522 c=0
Rl30 (\2\:n20 \3\:n20) resistor r=63.8117 c=0
Rl45 (SEb \2\:SEb) resistor r=40.1031 c=0
Rl46 (\2\:SEb \3\:SEb) resistor r=193.515 c=0
Rl47 (\2\:SEb \4\:SEb) resistor r=3.3229 c=0
Rz19 (\5\:VDD \4\:VDD) resistor r=75 c=0
Rz20 (\6\:VDD \4\:VDD) resistor r=6.25 c=0
Rz21 (\8\:VDD \4\:VDD) resistor r=9.375 c=0
Rz22 (\11\:VDD \4\:VDD) resistor r=12.5 c=0
Rz12 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz13 (\18\:VSS \17\:VSS) resistor r=75 c=0
Rz14 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz7 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz3 (\23\:qbint \22\:qbint) resistor r=75 c=0
Rz4 (\9\:n30 \8\:n30) resistor r=75 c=0
Rz5 (\5\:mout \6\:mout) resistor r=75 c=0
Rz8 (\15\:CKbb \16\:CKbb) resistor r=75 c=0
Rz6 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz9 (Db \2\:Db) resistor r=75 c=0
Rz10 (\7\:Db \8\:Db) resistor r=75 c=0
Rz11 (\5\:SEb \6\:SEb) resistor r=75 c=0
Ry18 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry19 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry20 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry13 (\4\:VSS \1\:VSS) resistor r=15.5 c=0
Ry14 (\6\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry15 (\8\:VSS \1\:VSS) resistor r=12.4 c=0
Ry16 (\9\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry17 (\14\:VSS \1\:VSS) resistor r=31 c=0
Ry7 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry3 (\25\:qbint \24\:qbint) resistor r=31 c=0
Ry4 (\13\:n30 \12\:n30) resistor r=62 c=0
Ry5 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry6 (\6\:n20 \7\:n20) resistor r=62 c=0
Ry9 (\5\:Db \6\:Db) resistor r=62 c=0
Ry10 (\9\:Db \10\:Db) resistor r=62 c=0
Ry11 (\9\:SEb \10\:SEb) resistor r=62 c=0
Rx13 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\1\:CK \5\:CK) resistor r=45 c=0
Rx16 (\6\:SE SE) resistor r=45 c=0
Rx14 (\1\:SE \8\:SE) resistor r=45 c=0
Rx15 (\4\:SE \9\:SE) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx7 (\8\:CKb \11\:CKb) resistor r=45 c=0
Rx8 (\3\:CKb \13\:CKb) resistor r=45 c=0
Rx9 (\5\:CKb \16\:CKb) resistor r=45 c=0
Rx2 (\18\:qbint \16\:qbint) resistor r=45 c=0
Rx3 (\21\:qbint qbint) resistor r=45 c=0
Rx4 (\11\:n30 n30) resistor r=45 c=0
Rx5 (\3\:mout \10\:mout) resistor r=45 c=0
Rx10 (\5\:CKbb \12\:CKbb) resistor r=45 c=0
Rx11 (CKbb \14\:CKbb) resistor r=45 c=0
Rx12 (\4\:CKbb \17\:CKbb) resistor r=45 c=0
Rx6 (\2\:n20 \8\:n20) resistor r=45 c=0
Rx18 (\4\:SEb \8\:SEb) resistor r=45 c=0
mn20 (\14\:CKb \3\:CK \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.345e-14 ad=2.03e-14 ps=1.68e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55_1__rcx (Q qbint \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.688e-14 ad=4.16e-14 ps=1.62e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.53365e-07 sb=1.5826e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn45_1__rcx (\22\:qbint n30 \9\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.387e-14 ad=3.383e-14 ps=1.6e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23451e-06 sb=1.50537e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(2)
mn50 (n7 \14\:qbint \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.49e-14 ad=4.495e-14 ps=1.6e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72e-06 sb=1.72e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\8\:n30 \2\:CKb n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=2.32e-14 ps=9.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.365e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn35 (\4\:n20 \7\:CKbb n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.885e-14 ad=4.422e-14 ps=5.5e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn40 (\5\:mout \3\:CKbb \8\:n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.697e-14 ps=6.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.16e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn30 (\5\:mout n20 \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.43e-14 ad=3.697e-14 ps=1.64e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.6e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn36 (n5 mout \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.43e-14 ad=1.885e-14 ps=1.64e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.65e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn25 (\7\:Db \9\:CKb \4\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.422e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21 (\15\:CKbb \10\:CKb \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=6.452e-14 ps=6.1e-07 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.45e-07 sb=1.175e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (n1 \3\:D \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.77e-14 ps=6.1e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.5e-07 sb=9.7e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn12 (Db \3\:SEb n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=3.77e-14 \
        ad=2.32e-14 ps=8.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.55e-07 sb=6.65e-07 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn14 (Db \3\:SE n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.16e-06 sb=4.6e-07 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn13 (n3 \1\:SI \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=8.7e-15 ps=6.3e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.265e-06 sb=3.55e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn10 (\5\:SEb \5\:SE \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.465e-14 ad=2.03e-14 ps=6.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp55_1__rcx (Q qbint \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.506e-14 ad=6.24e-14 ps=1.13e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.53878e-06 sd=160n sca=33.5925 \
        scb=0.0236177 scc=0.00338536 m=(4)
mp45_1__rcx (\24\:qbint n30 \8\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=6.452e-14 ad=4.96e-14 ps=1.12e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09234e-06 sb=1.48056e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(2)
mp50 (n8 \17\:qbint \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.895e-14 ad=2.687e-14 ps=1.08e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.53012e-06 sb=1.705e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp51 (\12\:n30 \2\:CKbb n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.687e-14 ad=4.3e-14 ps=6.8e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.70012e-06 sb=1.535e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp25 (\6\:n20 \8\:CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.127e-14 ad=3.44e-14 ps=1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.85e-07 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp40 (\12\:n30 CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.88e-14 ad=4.3e-14 ps=1.07e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.91442e-06 sb=1.29e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp30 (\8\:mout \3\:n20 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.205e-14 ad=6.88e-14 ps=1.6e-06 pd=1.07e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.25e-07 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp35 (n6 \4\:mout \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.205e-14 ad=2.473e-14 ps=1.6e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.5e-07 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp36 (\6\:n20 \4\:CKb n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.472e-14 ad=3.44e-14 ps=6.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.9e-07 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp21 (\9\:CKbb \6\:CKb \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12e-06 sd=160n sca=10.6366 \
        scb=0.00827102 scc=0.000128406 m=(1)
mp11 (n2 \1\:D \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=2.15e-14 ps=7.5e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=9.15e-07 sd=160n sca=10.6366 \
        scb=0.00827102 scc=0.000128406 m=(1)
mp12 (\9\:Db \2\:SE n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.15e-14 ad=3.87e-14 ps=6.3e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=7.7e-07 sd=160n sca=10.6461 \
        scb=0.00827274 scc=0.000128406 m=(1)
mp14 (\9\:Db SEb n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.332e-14 ad=3.87e-14 ps=7.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=5.45e-07 sd=160n sca=11.2732 \
        scb=0.00852207 scc=0.000128512 m=(1)
mp13 (n4 \3\:SI \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.332e-14 ps=7.5e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=3.45e-07 sd=160n sca=12.5323 \
        scb=0.0098256 scc=0.000132754 m=(1)
mp10 (\9\:SEb \7\:SE \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=1.4e-07 sd=160n sca=16.3619 \
        scb=0.0163088 scc=0.000299525 m=(1)
ends SDFFQX4
// End of subcircuit definition.

// Generated for: spectre (May  9 17:30:04 2012 )
// Library name: gsclib045
// Cell name: SDFFQXL
// View name: extracted

simulator lang=spectre

subckt SDFFQXL CK D Q SE SI VDD VSS
mp55 (\3\:Q \4\:qbint \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.65e-07 sd=160n sca=22.7477 \
        scb=0.0252121 scc=0.00126954 m=(1)
C1 (D VSS) capacitor c=6.07317e-17
C2 (Q VSS) capacitor c=6.45461e-17
C3 (CK VSS) capacitor c=8.08121e-17
C4 (SE VSS) capacitor c=5.17429e-17
C5 (VDD VSS) capacitor c=3.62866e-16
C6 (SI VSS) capacitor c=3.94438e-17
C7 (qbint VSS) capacitor c=2.74867e-17
C8 (CKb VSS) capacitor c=5.22389e-17
C9 (n30 VSS) capacitor c=4.59338e-17
C10 (mout VSS) capacitor c=6.48296e-17
C11 (CKbb VSS) capacitor c=1.7877e-17
C12 (n20 VSS) capacitor c=3.83015e-17
C13 (Db VSS) capacitor c=8.25085e-17
C14 (n1 VSS) capacitor c=5.70493e-18
C15 (SEb VSS) capacitor c=3.40018e-17
C16 (n8 VSS) capacitor c=2.80538e-18
C17 (n2 VSS) capacitor c=6.53665e-20
C18 (\5\:SE VSS) capacitor c=5.25331e-17
C19 (\1\:SI VSS) capacitor c=5.19239e-17
C20 (\1\:SE VSS) capacitor c=4.06661e-17
C21 (\1\:D VSS) capacitor c=5.26983e-17
C22 (\5\:CKb VSS) capacitor c=5.41392e-17
C23 (\6\:CKbb VSS) capacitor c=4.41763e-17
C24 (\8\:CKb VSS) capacitor c=4.58432e-17
C25 (\3\:CKb VSS) capacitor c=5.25411e-17
C26 (\3\:CKbb VSS) capacitor c=4.51552e-17
C27 (\5\:qbint VSS) capacitor c=4.5613e-17
C28 (\4\:CK VSS) capacitor c=3.91199e-17
C29 (\4\:qbint VSS) capacitor c=5.63547e-17
C30 (\7\:SE VSS) capacitor c=2.59417e-17
C31 (\3\:SI VSS) capacitor c=7.5015e-17
C32 (\3\:SE VSS) capacitor c=6.77912e-17
C33 (\3\:SEb VSS) capacitor c=7.0391e-17
C34 (\4\:D VSS) capacitor c=3.31878e-17
C35 (\9\:CKb VSS) capacitor c=2.50484e-17
C36 (\10\:CKb VSS) capacitor c=2.69923e-17
C37 (\4\:CKbb VSS) capacitor c=7.58273e-17
C38 (\3\:mout VSS) capacitor c=5.20558e-17
C39 (\3\:n20 VSS) capacitor c=3.90594e-17
C40 (\8\:qbint VSS) capacitor c=4.9301e-17
C41 (\2\:n30 VSS) capacitor c=4.07444e-17
C42 (\1\:CK VSS) capacitor c=4.38252e-17
C43 (\3\:qbint VSS) capacitor c=2.56827e-17
C44 (\6\:SE VSS) capacitor c=5.26657e-17
C45 (\2\:SI VSS) capacitor c=6.32621e-17
C46 (\4\:SE VSS) capacitor c=4.37887e-17
C47 (\2\:SEb VSS) capacitor c=6.96844e-17
C48 (\2\:SE VSS) capacitor c=4.11268e-17
C49 (\3\:D VSS) capacitor c=3.11994e-17
C50 (\7\:CKbb VSS) capacitor c=4.26534e-17
C51 (\11\:CKb VSS) capacitor c=2.86335e-17
C52 (\5\:CKbb VSS) capacitor c=2.68296e-17
C53 (\2\:mout VSS) capacitor c=4.53223e-17
C54 (\2\:n20 VSS) capacitor c=3.68426e-17
C55 (\2\:CKbb VSS) capacitor c=5.34407e-17
C56 (\4\:CKb VSS) capacitor c=2.29188e-17
C57 (\2\:CKb VSS) capacitor c=3.01009e-17
C58 (\7\:qbint VSS) capacitor c=4.82851e-17
C59 (\3\:n30 VSS) capacitor c=2.13723e-17
C60 (\3\:CK VSS) capacitor c=5.20985e-17
C61 (\8\:SEb VSS) capacitor c=2.00406e-17
C62 (\12\:VDD VSS) capacitor c=2.55202e-17
C63 (\4\:Db VSS) capacitor c=5.27593e-17
C64 (\14\:VDD VSS) capacitor c=2.91194e-17
C65 (\8\:CKbb VSS) capacitor c=8.98951e-17
C66 (\6\:Db VSS) capacitor c=1.20693e-16
C67 (\4\:n20 VSS) capacitor c=3.00849e-17
C68 (\16\:VDD VSS) capacitor c=2.68071e-17
C69 (\4\:mout VSS) capacitor c=5.03294e-17
C70 (\4\:n30 VSS) capacitor c=7.70052e-17
C71 (\18\:VDD VSS) capacitor c=2.70381e-17
C72 (\13\:qbint VSS) capacitor c=3.50586e-17
C73 (\15\:CKb VSS) capacitor c=1.08339e-16
C74 (\20\:VDD VSS) capacitor c=3.3097e-17
C75 (\3\:Q VSS) capacitor c=7.06105e-17
C76 (\1\:VDD VSS) capacitor c=1.17035e-16
C77 (\4\:SEb VSS) capacitor c=4.29321e-17
C78 (\14\:CKbb VSS) capacitor c=6.14277e-17
C79 (\8\:Db VSS) capacitor c=6.08339e-17
C80 (\8\:n20 VSS) capacitor c=5.62849e-17
C81 (\7\:mout VSS) capacitor c=3.88695e-17
C82 (\6\:n30 VSS) capacitor c=9.90233e-17
C83 (\11\:qbint VSS) capacitor c=9.30975e-17
C84 (\19\:CKb VSS) capacitor c=1.06322e-16
C85 (\2\:qbint VSS) capacitor c=3.32873e-17
C86 (\6\:CKb VSS) capacitor c=6.65387e-17
C87 (\7\:CKb VSS) capacitor c=7.6648e-17
C88 (\2\:D VSS) capacitor c=3.3895e-17
C89 (\5\:CK VSS) capacitor c=4.26285e-17
C90 (\9\:qbint VSS) capacitor c=3.1574e-17
C91 (\10\:qbint VSS) capacitor c=2.94213e-17
C92 (\15\:qbint VSS) capacitor c=1.03389e-16
C93 (\8\:n30 VSS) capacitor c=6.20707e-17
C94 (\6\:mout VSS) capacitor c=5.32789e-17
C95 (\9\:mout VSS) capacitor c=5.44803e-17
C96 (\12\:CKb VSS) capacitor c=6.70372e-17
C97 (\13\:CKb VSS) capacitor c=6.76687e-17
C98 (\14\:CKb VSS) capacitor c=8.448e-17
C99 (\17\:CKb VSS) capacitor c=1.43142e-17
C100 (\18\:CKb VSS) capacitor c=6.08945e-17
C101 (\6\:n20 VSS) capacitor c=5.1971e-17
C102 (\7\:n20 VSS) capacitor c=6.51072e-17
C103 (\10\:CKbb VSS) capacitor c=1.19951e-16
C104 (\11\:CKbb VSS) capacitor c=6.48019e-17
C105 (\12\:CKbb VSS) capacitor c=8.44419e-17
C106 (\13\:CKbb VSS) capacitor c=1.23894e-16
C107 (\16\:CKbb VSS) capacitor c=1.62065e-17
C108 (\5\:D VSS) capacitor c=4.01113e-17
C109 (\3\:Db VSS) capacitor c=1.38377e-16
C110 (\8\:SE VSS) capacitor c=6.7076e-17
C111 (\9\:SE VSS) capacitor c=7.15815e-17
C112 (\4\:SI VSS) capacitor c=1.00213e-16
C113 (\6\:SEb VSS) capacitor c=7.57518e-17
C114 (\7\:SEb VSS) capacitor c=5.9896e-17
C115 (\3\:VDD VSS) capacitor c=1.13566e-18
C116 (\5\:VDD VSS) capacitor c=1.03961e-18
C117 (\7\:VDD VSS) capacitor c=2.51122e-17
C118 (\9\:VDD VSS) capacitor c=2.50207e-17
C119 (\10\:VDD VSS) capacitor c=1.66322e-17
Rk28 (\5\:D D) resistor r=0.1705 c=0
Rk1 (\2\:Q Q) resistor r=0.002997 c=0
Rk2 (Q \4\:Q) resistor r=0.4885 c=0
Rk3 (\5\:CK CK) resistor r=0.1244 c=0
Rk34 (\9\:SE SE) resistor r=0.2199 c=0
Rk33 (\8\:SE \9\:SE) resistor r=0.3442 c=0
Rk35 (SE \10\:SE) resistor r=0.002697 c=0
Rk53 (\2\:VDD \3\:VDD) resistor r=0.09505 c=0
Rk54 (\3\:VDD \4\:VDD) resistor r=0.2053 c=0
Rk55 (\4\:VDD \5\:VDD) resistor r=0.2078 c=0
Rk56 (\5\:VDD \6\:VDD) resistor r=0.1427 c=0
Rk57 (\6\:VDD \7\:VDD) resistor r=0.5036 c=0
Rk58 (\7\:VDD \8\:VDD) resistor r=0.248 c=0
Rk59 (\8\:VDD \9\:VDD) resistor r=0.2605 c=0
Rk60 (\9\:VDD \10\:VDD) resistor r=0.3831 c=0
Rk62 (\11\:VDD VDD) resistor r=0.04988 c=0
Rk61 (\10\:VDD \11\:VDD) resistor r=0.05746 c=0
Rk63 (\3\:VDD \13\:VDD) resistor r=0.232 c=0
Rk64 (\5\:VDD \15\:VDD) resistor r=0.232 c=0
Rk65 (\7\:VDD \17\:VDD) resistor r=0.1288 c=0
Rk66 (\9\:VDD \19\:VDD) resistor r=0.1288 c=0
Rk67 (\10\:VDD \21\:VDD) resistor r=0.1967 c=0
Rk36 (SI \4\:SI) resistor r=0.009246 c=0
Rk40 (\2\:VSS \3\:VSS) resistor r=0.08001 c=0
Rk41 (\3\:VSS \4\:VSS) resistor r=0.4209 c=0
Rk42 (\3\:VSS \6\:VSS) resistor r=0.2898 c=0
Rk43 (\4\:VSS \7\:VSS) resistor r=0.6737 c=0
Rk44 (\7\:VSS \8\:VSS) resistor r=0.3272 c=0
Rk45 (\8\:VSS \9\:VSS) resistor r=0.1442 c=0
Rk47 (\10\:VSS VSS) resistor r=0.08728 c=0
Rk46 (\9\:VSS \10\:VSS) resistor r=0.4173 c=0
Rk49 (\4\:VSS \13\:VSS) resistor r=0.34 c=0
Rk50 (\7\:VSS \15\:VSS) resistor r=0.04328 c=0
Rk51 (\9\:VSS \17\:VSS) resistor r=0.04328 c=0
Rk52 (\10\:VSS \19\:VSS) resistor r=0.07358 c=0
Rk4 (\9\:qbint \10\:qbint) resistor r=0.1674 c=0
Rk5 (\10\:qbint \12\:qbint) resistor r=0.1206 c=0
Rk6 (\10\:qbint \14\:qbint) resistor r=0.2091 c=0
Rk7 (\12\:qbint \15\:qbint) resistor r=0.7664 c=0
Rk13 (\12\:CKb \13\:CKb) resistor r=0.5284 c=0
Rk14 (\13\:CKb \14\:CKb) resistor r=0.2795 c=0
Rk15 (\14\:CKb \16\:CKb) resistor r=0.537 c=0
Rk16 (\13\:CKb \17\:CKb) resistor r=0.03285 c=0
Rk17 (\14\:CKb \18\:CKb) resistor r=0.3554 c=0
Rk18 (\16\:CKb \20\:CKb) resistor r=0.5296 c=0
Rk8 (\5\:n30 \7\:n30) resistor r=0.4132 c=0
Rk9 (\7\:n30 \8\:n30) resistor r=0.5086 c=0
Rk10 (\5\:mout \6\:mout) resistor r=0.239 c=0
Rk11 (\6\:mout \8\:mout) resistor r=0.12 c=0
Rk12 (\6\:mout \9\:mout) resistor r=0.2517 c=0
Rk22 (\9\:CKbb \10\:CKbb) resistor r=0.6491 c=0
Rk23 (\10\:CKbb \11\:CKbb) resistor r=0.3242 c=0
Rk24 (\11\:CKbb \12\:CKbb) resistor r=0.2057 c=0
Rk25 (\12\:CKbb \13\:CKbb) resistor r=0.7737 c=0
Rk26 (\11\:CKbb \15\:CKbb) resistor r=0.3653 c=0
Rk27 (\12\:CKbb \16\:CKbb) resistor r=0.0529 c=0
Rk19 (\5\:n20 \6\:n20) resistor r=0.1253 c=0
Rk20 (\6\:n20 \7\:n20) resistor r=0.3025 c=0
Rk21 (\6\:n20 \9\:n20) resistor r=0.2416 c=0
Rk29 (\2\:Db \3\:Db) resistor r=0.6437 c=0
Rk30 (\3\:Db \5\:Db) resistor r=0.2692 c=0
Rk31 (\3\:Db \7\:Db) resistor r=0.5881 c=0
Rk32 (\7\:Db \9\:Db) resistor r=0.3444 c=0
Rk37 (\5\:SEb \6\:SEb) resistor r=0.3961 c=0
Rk38 (\6\:SEb \7\:SEb) resistor r=0.3301 c=0
Rk39 (\6\:SEb \9\:SEb) resistor r=0.08492 c=0
Rl28 (\1\:D \2\:D) resistor r=137.695 c=0
Rl30 (\2\:D \4\:D) resistor r=97.3105 c=0
Rl29 (\2\:D \3\:D) resistor r=29.6836 c=0
Rl6 (\2\:CK \4\:CK) resistor r=142.76 c=0
Rl4 (\1\:CK \2\:CK) resistor r=113.913 c=0
Rl5 (\2\:CK \3\:CK) resistor r=2.733 c=0
Rl37 (\5\:SE \6\:SE) resistor r=183.848 c=0
Rl38 (\6\:SE \7\:SE) resistor r=26.1559 c=0
Rl34 (\3\:SE \4\:SE) resistor r=26.1559 c=0
Rl31 (\1\:SE \2\:SE) resistor r=76.1559 c=0
Rl35 (\1\:SI \2\:SI) resistor r=93.4636 c=0
Rl36 (\2\:SI \3\:SI) resistor r=116.54 c=0
Rl1 (qbint \2\:qbint) resistor r=5.0163 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=212.341 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=37.3411 c=0
Rl9 (\5\:qbint \6\:qbint) resistor r=99.2798 c=0
Rl11 (\6\:qbint \8\:qbint) resistor r=34.3295 c=0
Rl10 (\6\:qbint \7\:qbint) resistor r=0.5166 c=0
Rl27 (\8\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl13 (\3\:CKb \4\:CKb) resistor r=60.7713 c=0
Rl12 (CKb \2\:CKb) resistor r=30.0021 c=0
Rl22 (\5\:CKb \6\:CKb) resistor r=156.492 c=0
Rl25 (\6\:CKb \9\:CKb) resistor r=78.0797 c=0
Rl24 (\7\:CKb \8\:CKb) resistor r=134.159 c=0
Rl26 (\7\:CKb \10\:CKb) resistor r=30.4507 c=0
Rl23 (\6\:CKb \7\:CKb) resistor r=254.684 c=0
Rl7 (n30 \2\:n30) resistor r=132.692 c=0
Rl8 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl18 (mout \2\:mout) resistor r=77.6148 c=0
Rl19 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl21 (\6\:CKbb \7\:CKbb) resistor r=30.0021 c=0
Rl20 (\4\:CKbb \5\:CKbb) resistor r=76.1559 c=0
Rl14 (CKbb \2\:CKbb) resistor r=24.5191 c=0
Rl15 (\2\:CKbb \3\:CKbb) resistor r=110.587 c=0
Rl16 (n20 \2\:n20) resistor r=26.098 c=0
Rl17 (\2\:n20 \3\:n20) resistor r=74.1749 c=0
Rl32 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl33 (\2\:SEb \3\:SEb) resistor r=214.183 c=0
Rz1 (\1\:Q \2\:Q) resistor r=75 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz17 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz18 (\1\:VDD \6\:VDD) resistor r=25 c=0
Rz19 (\1\:VDD \8\:VDD) resistor r=6.25 c=0
Rz20 (\1\:VDD \11\:VDD) resistor r=37.5 c=0
Rz11 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz12 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz13 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz14 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz15 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz2 (\11\:qbint \12\:qbint) resistor r=75 c=0
Rz5 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz3 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\8\:Db \9\:Db) resistor r=75 c=0
Rz10 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry1 (\3\:Q \4\:Q) resistor r=62 c=0
Ry15 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry16 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry17 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry18 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry19 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry14 (\1\:VSS VSS) resistor r=62 c=0
Ry11 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry12 (\1\:VSS \4\:VSS) resistor r=7.75 c=0
Ry13 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry2 (\13\:qbint \14\:qbint) resistor r=62 c=0
Ry5 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry4 (\4\:mout \5\:mout) resistor r=62 c=0
Ry7 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry6 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry8 (\4\:Db \5\:Db) resistor r=62 c=0
Ry9 (\6\:Db \7\:Db) resistor r=62 c=0
Ry10 (\8\:SEb \9\:SEb) resistor r=62 c=0
Rx13 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (\3\:CK \5\:CK) resistor r=45 c=0
Rx14 (\2\:SE \8\:SE) resistor r=45 c=0
Rx15 (\4\:SE \9\:SE) resistor r=45 c=0
Rx16 (\6\:SE \10\:SE) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\7\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (qbint \15\:qbint) resistor r=45 c=0
Rx6 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\4\:CKb \17\:CKb) resistor r=45 c=0
Rx8 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx4 (\3\:n30 \8\:n30) resistor r=45 c=0
Rx5 (\2\:mout \9\:mout) resistor r=45 c=0
Rx10 (\7\:CKbb \10\:CKbb) resistor r=45 c=0
Rx11 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx12 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn55 (\1\:Q \3\:qbint \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.028e-14 ad=2.03e-14 ps=1.44e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.95e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn20 (\19\:CKb \1\:CK \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.028e-14 ad=2.538e-14 ps=1.44e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=1.75e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn45 (\11\:qbint \2\:n30 \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.465e-14 ps=1.6e-06 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.905e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (n7 \8\:qbint \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=1.233e-14 ps=1.6e-06 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.71e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\6\:n30 CKb n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.233e-14 ad=4.423e-14 ps=4.6e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=1.58e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\7\:mout CKbb \6\:n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.423e-14 ad=4.278e-14 ps=9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.45e-07 sb=1.23e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\7\:mout \3\:n20 \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.205e-14 ad=4.278e-14 ps=1.74e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=8.9e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (n5 \3\:mout \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.205e-14 ad=8.7e-15 ps=1.74e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-06 sb=6.25e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (\8\:n20 \4\:CKbb n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.555e-06 sb=5.2e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (\8\:Db \10\:CKb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.568e-14 ps=6.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.76e-06 sb=3.15e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn21 (\14\:CKbb \9\:CKb \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.19e-14 ad=2.03e-14 ps=7.3e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.285e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn11 (n1 \4\:D \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.19e-14 ad=3.842e-14 ps=7.3e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.02e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn12 (Db \3\:SEb n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.842e-14 ad=2.32e-14 ps=8.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.15e-07 sb=7.1e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn14 (Db \3\:SE n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.2e-07 sb=5.05e-07 sd=160n sca=11.7118 scb=0.0116498 \
        scc=0.000458536 m=(1)
mn13 (n3 \3\:SI \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=8.7e-15 ps=6.1e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn10 (\4\:SEb \7\:SE \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.827e-14 ps=6.1e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.23e-06 sb=1.95e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp20 (\15\:CKb \4\:CK \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.6e-07 sd=160n sca=13.584 \
        scb=0.0113598 scc=0.000108591 m=(1)
mp45 (\13\:qbint n30 \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.57e-14 ad=3.01e-14 ps=1.51e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.875e-06 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp50 (n8 \5\:qbint \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.57e-14 ad=4.837e-14 ps=1.51e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.61e-06 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp30 (\4\:mout n20 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.57e-14 ad=4.945e-14 ps=1.51e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.155e-06 sb=8.6e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp51 (\4\:n30 \3\:CKbb n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.837e-14 ad=3.44e-14 ps=8.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=1.34e-06 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp40 (\4\:n30 \3\:CKb \4\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=3.44e-14 ps=8.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8e-07 sb=1.135e-06 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp35 (n6 mout \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.57e-14 ad=1.935e-14 ps=1.51e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=5.95e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp36 (\4\:n20 \8\:CKb n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.935e-14 ad=3.87e-14 ps=6.1e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.555e-06 sb=4.6e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp25 (\4\:n20 \6\:CKbb \6\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.052e-14 ad=3.87e-14 ps=9e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=2.35e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp21 (\8\:CKbb \5\:CKb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.762e-14 ad=3.01e-14 ps=7.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.185e-06 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp11 (n2 \1\:D \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.547e-14 ps=7.8e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.6e-07 sb=9.65e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp12 (\4\:Db \1\:SE n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.547e-14 ad=3.762e-14 ps=7.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=7.55e-07 sd=160n sca=10.5693 \
        scb=0.00783293 scc=9.84607e-05 m=(1)
mp14 (\4\:Db SEb n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.117e-14 ad=3.762e-14 ps=7.2e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.9e-07 sb=5.35e-07 sd=160n sca=11.3905 \
        scb=0.00832609 scc=9.89279e-05 m=(1)
mp13 (n4 \1\:SI \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.117e-14 ps=7.5e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.8e-07 sb=3.45e-07 sd=160n sca=13.0884 \
        scb=0.0105751 scc=0.000113994 m=(1)
mp10 (\8\:SEb \5\:SE \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.185e-06 sb=1.4e-07 sd=160n sca=19.3888 \
        scb=0.0210602 scc=0.000665938 m=(1)
ends SDFFQXL
// End of subcircuit definition.

// Generated for: spectre (May  8 15:32:23 2012 )
// Library name: gsclib045
// Cell name: SDFFRHQX1
// View name: extracted

simulator lang=spectre

subckt SDFFRHQX1 CK D Q RN SE SI VDD VSS
mp55 (\1\:Q \4\:qbint \25\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.72308e-07 sd=160n sca=23.0036 \
        scb=0.0261368 scc=0.00127103 m=(1)
C1 (D VSS) capacitor c=4.02453e-17
C2 (Q VSS) capacitor c=1.32018e-17
C3 (SE VSS) capacitor c=7.29835e-17
C4 (VDD VSS) capacitor c=3.19083e-16
C5 (SI VSS) capacitor c=4.95894e-17
C6 (qbint VSS) capacitor c=1.8666e-17
C7 (CKb VSS) capacitor c=5.75641e-17
C8 (net337 VSS) capacitor c=4.46366e-18
C9 (n30 VSS) capacitor c=5.26225e-17
C10 (net405 VSS) capacitor c=2.68183e-18
C11 (mout VSS) capacitor c=5.78085e-17
C12 (CKbb VSS) capacitor c=2.14988e-17
C13 (n20 VSS) capacitor c=4.92579e-17
C14 (Db VSS) capacitor c=1.25197e-16
C15 (net450 VSS) capacitor c=6.64026e-18
C16 (SEb VSS) capacitor c=4.53363e-17
C17 (net326 VSS) capacitor c=3.58673e-18
C18 (net349 VSS) capacitor c=5.67054e-17
C19 (net381 VSS) capacitor c=1.5388e-18
C20 (net373 VSS) capacitor c=3.89779e-18
C21 (\5\:SE VSS) capacitor c=4.33742e-17
C22 (\3\:SI VSS) capacitor c=6.70732e-17
C23 (\2\:SE VSS) capacitor c=7.23799e-17
C24 (\1\:D VSS) capacitor c=1.07026e-16
C25 (\8\:CKb VSS) capacitor c=4.85877e-17
C26 (\7\:CKbb VSS) capacitor c=5.24778e-17
C27 (\5\:CKb VSS) capacitor c=5.31697e-17
C28 (\2\:RN VSS) capacitor c=1.35234e-16
C29 (\3\:n20 VSS) capacitor c=5.72447e-17
C30 (\3\:CKb VSS) capacitor c=4.39449e-17
C31 (\3\:CKbb VSS) capacitor c=8.76428e-17
C32 (\5\:qbint VSS) capacitor c=6.82722e-17
C33 (\3\:RN VSS) capacitor c=1.04194e-16
C34 (\1\:CK VSS) capacitor c=3.98388e-17
C35 (\4\:qbint VSS) capacitor c=5.66845e-17
C36 (\7\:SE VSS) capacitor c=3.24012e-17
C37 (\1\:SI VSS) capacitor c=7.95551e-17
C38 (\3\:SE VSS) capacitor c=5.76891e-17
C39 (\3\:SEb VSS) capacitor c=6.40842e-17
C40 (\4\:D VSS) capacitor c=3.83435e-17
C41 (\10\:CKb VSS) capacitor c=6.06352e-17
C42 (\7\:CKb VSS) capacitor c=4.71508e-17
C43 (\4\:CKbb VSS) capacitor c=4.60951e-17
C44 (\3\:mout VSS) capacitor c=6.53194e-17
C45 (\1\:RN VSS) capacitor c=8.87394e-17
C46 (\7\:qbint VSS) capacitor c=5.58413e-17
C47 (\5\:RN VSS) capacitor c=5.06381e-17
C48 (\3\:n30 VSS) capacitor c=2.89554e-17
C49 (\3\:CK VSS) capacitor c=4.8822e-17
C50 (\3\:qbint VSS) capacitor c=3.43207e-17
C51 (\6\:SE VSS) capacitor c=3.99169e-17
C52 (\2\:SI VSS) capacitor c=6.44661e-17
C53 (\4\:SE VSS) capacitor c=4.34497e-17
C54 (\2\:SEb VSS) capacitor c=5.75778e-17
C55 (\1\:SE VSS) capacitor c=5.17725e-17
C56 (\3\:D VSS) capacitor c=2.56117e-17
C57 (\9\:CKb VSS) capacitor c=2.7182e-17
C58 (\6\:CKbb VSS) capacitor c=3.78216e-17
C59 (\6\:CKb VSS) capacitor c=2.05361e-17
C60 (\5\:CKbb VSS) capacitor c=3.96094e-17
C61 (\2\:mout VSS) capacitor c=5.8223e-17
C62 (\2\:n20 VSS) capacitor c=4.8284e-17
C63 (\4\:CKb VSS) capacitor c=3.21145e-17
C64 (\2\:CKbb VSS) capacitor c=5.81635e-17
C65 (\2\:CKb VSS) capacitor c=5.74618e-17
C66 (\6\:qbint VSS) capacitor c=6.89973e-17
C67 (\6\:RN VSS) capacitor c=2.54588e-17
C68 (\2\:n30 VSS) capacitor c=3.91622e-17
C69 (\2\:CK VSS) capacitor c=4.49232e-17
C70 (\5\:SEb VSS) capacitor c=9.49605e-17
C71 (\13\:VDD VSS) capacitor c=3.57158e-17
C72 (\3\:Db VSS) capacitor c=1.44669e-16
C73 (\15\:VDD VSS) capacitor c=1.5325e-17
C74 (\8\:CKbb VSS) capacitor c=6.71514e-17
C75 (\6\:Db VSS) capacitor c=1.7105e-16
C76 (\4\:n20 VSS) capacitor c=5.70403e-17
C77 (\17\:VDD VSS) capacitor c=3.43218e-17
C78 (\3\:net349 VSS) capacitor c=6.77142e-17
C79 (\19\:VDD VSS) capacitor c=4.55952e-17
C80 (\8\:mout VSS) capacitor c=8.76952e-17
C81 (\4\:n30 VSS) capacitor c=1.20802e-16
C82 (\21\:VDD VSS) capacitor c=4.95628e-17
C83 (\12\:qbint VSS) capacitor c=5.58073e-17
C84 (\23\:VDD VSS) capacitor c=3.75339e-17
C85 (\15\:CKb VSS) capacitor c=1.3939e-16
C86 (\25\:VDD VSS) capacitor c=6.90152e-17
C87 (\1\:Q VSS) capacitor c=6.65752e-17
C88 (\1\:VDD VSS) capacitor c=9.02713e-17
C89 (\7\:SEb VSS) capacitor c=7.52394e-17
C90 (\14\:CKbb VSS) capacitor c=1.92016e-17
C91 (\8\:Db VSS) capacitor c=1.06039e-16
C92 (\8\:n20 VSS) capacitor c=9.33367e-17
C93 (\6\:mout VSS) capacitor c=6.53961e-17
C94 (\6\:n30 VSS) capacitor c=1.54843e-16
C95 (\10\:qbint VSS) capacitor c=1.45283e-16
C96 (\19\:CKb VSS) capacitor c=1.1267e-16
C97 (\4\:Q VSS) capacitor c=3.18303e-17
C98 (\2\:qbint VSS) capacitor c=2.41945e-17
C99 (\4\:RN VSS) capacitor c=3.35984e-17
C100 (\2\:D VSS) capacitor c=2.57251e-17
C101 (\3\:Q VSS) capacitor c=5.29535e-17
C102 (\4\:CK VSS) capacitor c=6.00298e-17
C103 (\5\:CK VSS) capacitor c=4.39801e-17
C104 (\8\:RN VSS) capacitor c=4.94482e-17
C105 (\9\:RN VSS) capacitor c=4.92634e-17
C106 (\8\:qbint VSS) capacitor c=6.41981e-17
C107 (\9\:qbint VSS) capacitor c=1.0413e-16
C108 (\14\:qbint VSS) capacitor c=1.25451e-16
C109 (\8\:n30 VSS) capacitor c=1.20311e-16
C110 (\4\:mout VSS) capacitor c=8.76156e-17
C111 (\5\:mout VSS) capacitor c=1.06221e-16
C112 (\6\:n20 VSS) capacitor c=9.93722e-17
C113 (\7\:n20 VSS) capacitor c=8.07966e-17
C114 (\10\:CKbb VSS) capacitor c=3.82308e-17
C115 (\11\:CKbb VSS) capacitor c=9.873e-17
C116 (\12\:CKbb VSS) capacitor c=2.22169e-16
C117 (\13\:CKbb VSS) capacitor c=1.90129e-16
C118 (\16\:CKbb VSS) capacitor c=3.85165e-17
C119 (\11\:CKb VSS) capacitor c=8.08544e-17
C120 (\12\:CKb VSS) capacitor c=1.49296e-16
C121 (\13\:CKb VSS) capacitor c=1.35122e-16
C122 (\14\:CKb VSS) capacitor c=1.65666e-16
C123 (\17\:CKb VSS) capacitor c=8.30345e-17
C124 (\18\:CKb VSS) capacitor c=5.23108e-17
C125 (\6\:D VSS) capacitor c=3.78475e-17
C126 (\5\:Db VSS) capacitor c=4.96719e-17
C127 (\4\:SI VSS) capacitor c=5.58424e-17
C128 (\8\:SE VSS) capacitor c=6.24425e-17
C129 (\9\:SE VSS) capacitor c=4.45178e-17
C130 (\10\:SE VSS) capacitor c=5.99557e-17
C131 (\4\:SEb VSS) capacitor c=8.14355e-17
C132 (\3\:VDD VSS) capacitor c=1.33767e-18
C133 (\5\:VDD VSS) capacitor c=2.64168e-17
C134 (\6\:VDD VSS) capacitor c=2.7281e-17
C135 (\8\:VDD VSS) capacitor c=3.14196e-17
C136 (\9\:VDD VSS) capacitor c=3.23475e-17
C137 (\11\:VDD VSS) capacitor c=9.39858e-18
Rk36 (\5\:D \6\:D) resistor r=0.002289 c=0
Rk37 (\7\:D D) resistor r=0.002403 c=0
Rk38 (\6\:D \7\:D) resistor r=0.09354 c=0
Rk2 (\3\:Q Q) resistor r=0.007258 c=0
Rk1 (\2\:Q \3\:Q) resistor r=0.4303 c=0
Rk3 (\3\:Q \5\:Q) resistor r=0.1825 c=0
Rk7 (\7\:RN \8\:RN) resistor r=0.008733 c=0
Rk8 (\9\:RN RN) resistor r=0.008733 c=0
Rk9 (\8\:RN \9\:RN) resistor r=0.01996 c=0
Rk45 (\8\:SE SE) resistor r=0.3149 c=0
Rk46 (SE \9\:SE) resistor r=0.0751 c=0
Rk47 (\9\:SE \10\:SE) resistor r=0.2249 c=0
Rk59 (\2\:VDD \3\:VDD) resistor r=0.1178 c=0
Rk60 (\3\:VDD \4\:VDD) resistor r=0.1831 c=0
Rk61 (\4\:VDD \5\:VDD) resistor r=0.1906 c=0
Rk62 (\5\:VDD \6\:VDD) resistor r=0.4657 c=0
Rk63 (\6\:VDD \7\:VDD) resistor r=0.09426 c=0
Rk64 (\7\:VDD \8\:VDD) resistor r=0.1253 c=0
Rk65 (\8\:VDD \9\:VDD) resistor r=0.4741 c=0
Rk66 (\9\:VDD \10\:VDD) resistor r=0.1027 c=0
Rk67 (\10\:VDD \11\:VDD) resistor r=0.163 c=0
Rk76 (\12\:VDD VDD) resistor r=0.151 c=0
Rk68 (\11\:VDD \12\:VDD) resistor r=0.1881 c=0
Rk69 (\3\:VDD \14\:VDD) resistor r=0.203 c=0
Rk70 (\5\:VDD \16\:VDD) resistor r=0.07476 c=0
Rk71 (\6\:VDD \18\:VDD) resistor r=0.04338 c=0
Rk72 (\8\:VDD \20\:VDD) resistor r=0.1543 c=0
Rk73 (\9\:VDD \22\:VDD) resistor r=0.247 c=0
Rk74 (\11\:VDD \24\:VDD) resistor r=0.1543 c=0
Rk75 (\12\:VDD \26\:VDD) resistor r=0.3671 c=0
Rk4 (CK \4\:CK) resistor r=0.004227 c=0
Rk6 (\4\:CK \5\:CK) resistor r=0.07064 c=0
Rk5 (\5\:CK \6\:CK) resistor r=0.004227 c=0
Rk44 (SI \4\:SI) resistor r=0.02621 c=0
Rk50 (\2\:VSS \4\:VSS) resistor r=0.7354 c=0
Rk51 (\4\:VSS \5\:VSS) resistor r=0.6777 c=0
Rk52 (\5\:VSS \6\:VSS) resistor r=0.5277 c=0
Rk54 (\7\:VSS VSS) resistor r=0.1251 c=0
Rk53 (\6\:VSS \7\:VSS) resistor r=0.4266 c=0
Rk55 (\4\:VSS \9\:VSS) resistor r=0.3693 c=0
Rk56 (\5\:VSS \11\:VSS) resistor r=0.2545 c=0
Rk57 (\6\:VSS \13\:VSS) resistor r=0.1976 c=0
Rk58 (\7\:VSS \15\:VSS) resistor r=0.3086 c=0
Rk10 (\8\:qbint \9\:qbint) resistor r=0.3799 c=0
Rk11 (\9\:qbint \11\:qbint) resistor r=0.5415 c=0
Rk12 (\9\:qbint \13\:qbint) resistor r=0.2374 c=0
Rk13 (\11\:qbint \14\:qbint) resistor r=0.6457 c=0
Rk29 (\11\:CKb \12\:CKb) resistor r=0.3924 c=0
Rk30 (\12\:CKb \13\:CKb) resistor r=0.8429 c=0
Rk31 (\13\:CKb \14\:CKb) resistor r=0.3488 c=0
Rk32 (\14\:CKb \16\:CKb) resistor r=0.781 c=0
Rk33 (\13\:CKb \17\:CKb) resistor r=0.2949 c=0
Rk34 (\14\:CKb \18\:CKb) resistor r=0.326 c=0
Rk35 (\16\:CKb \20\:CKb) resistor r=0.5326 c=0
Rk14 (\5\:n30 \7\:n30) resistor r=0.588 c=0
Rk15 (\7\:n30 \8\:n30) resistor r=0.7398 c=0
Rk16 (\4\:mout \5\:mout) resistor r=0.473 c=0
Rk17 (\5\:mout \7\:mout) resistor r=0.2059 c=0
Rk18 (\5\:mout \9\:mout) resistor r=0.3244 c=0
Rk23 (\9\:CKbb \10\:CKbb) resistor r=0.3799 c=0
Rk24 (\10\:CKbb \11\:CKbb) resistor r=0.1571 c=0
Rk25 (\11\:CKbb \12\:CKbb) resistor r=0.8393 c=0
Rk26 (\12\:CKbb \13\:CKbb) resistor r=1.0921 c=0
Rk27 (\10\:CKbb \15\:CKbb) resistor r=0.0921 c=0
Rk28 (\12\:CKbb \16\:CKbb) resistor r=0.07888 c=0
Rk20 (\5\:n20 \6\:n20) resistor r=0.2171 c=0
Rk21 (\6\:n20 \7\:n20) resistor r=0.5467 c=0
Rk22 (\6\:n20 \9\:n20) resistor r=0.3571 c=0
Rk39 (\2\:Db \4\:Db) resistor r=0.7348 c=0
Rk40 (\4\:Db \5\:Db) resistor r=0.0391 c=0
Rk41 (\5\:Db \7\:Db) resistor r=0.583 c=0
Rk42 (\7\:Db \9\:Db) resistor r=0.6106 c=0
Rk43 (\5\:Db \10\:Db) resistor r=0.0987 c=0
Rk48 (\4\:SEb \6\:SEb) resistor r=0.5531 c=0
Rk49 (\6\:SEb \8\:SEb) resistor r=0.5391 c=0
Rk19 (\2\:net349 \4\:net349) resistor r=0.3075 c=0
Rl29 (\1\:D \2\:D) resistor r=127.726 c=0
Rl31 (\2\:D \4\:D) resistor r=45.0334 c=0
Rl30 (\2\:D \3\:D) resistor r=3.1183 c=0
Rl17 (\2\:RN \3\:RN) resistor r=603.412 c=0
Rl16 (\1\:RN \2\:RN) resistor r=215.232 c=0
Rl18 (\3\:RN \4\:RN) resistor r=96.9565 c=0
Rl19 (\4\:RN \5\:RN) resistor r=106.572 c=0
Rl20 (\4\:RN \6\:RN) resistor r=5.013 c=0
Rl38 (\5\:SE \6\:SE) resistor r=119.922 c=0
Rl39 (\6\:SE \7\:SE) resistor r=46.8456 c=0
Rl35 (\3\:SE \4\:SE) resistor r=24.2328 c=0
Rl32 (\1\:SE \2\:SE) resistor r=36.4253 c=0
Rl4 (\1\:CK \2\:CK) resistor r=104.538 c=0
Rl5 (\2\:CK \3\:CK) resistor r=110.307 c=0
Rl37 (\2\:SI \3\:SI) resistor r=101.477 c=0
Rl36 (\1\:SI \2\:SI) resistor r=85.7713 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=160.771 c=0
Rl9 (\6\:qbint \7\:qbint) resistor r=24.2328 c=0
Rl1 (qbint \2\:qbint) resistor r=1.2334 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=121.957 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=41.1873 c=0
Rl28 (\8\:CKb \10\:CKb) resistor r=182.692 c=0
Rl25 (\5\:CKb \7\:CKb) resistor r=150 c=0
Rl27 (\8\:CKb \9\:CKb) resistor r=52.1862 c=0
Rl24 (\5\:CKb \6\:CKb) resistor r=64.1533 c=0
Rl11 (\3\:CKb \4\:CKb) resistor r=35.7713 c=0
Rl10 (CKb \2\:CKb) resistor r=70.3867 c=0
Rl6 (n30 \2\:n30) resistor r=158.384 c=0
Rl7 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl21 (mout \2\:mout) resistor r=108.79 c=0
Rl22 (\2\:mout \3\:mout) resistor r=72.2519 c=0
Rl26 (\6\:CKbb \7\:CKbb) resistor r=99.2573 c=0
Rl23 (\4\:CKbb \5\:CKbb) resistor r=41.5405 c=0
Rl12 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl13 (\2\:CKbb \3\:CKbb) resistor r=214.504 c=0
Rl14 (n20 \2\:n20) resistor r=138.462 c=0
Rl15 (\2\:n20 \3\:n20) resistor r=51.0989 c=0
Rl33 (SEb \2\:SEb) resistor r=24.2328 c=0
Rl34 (\2\:SEb \3\:SEb) resistor r=135.404 c=0
Rz1 (\4\:Q \5\:Q) resistor r=37.5 c=0
Rz16 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz17 (\1\:VDD \4\:VDD) resistor r=18.75 c=0
Rz18 (\1\:VDD \7\:VDD) resistor r=6.8182 c=0
Rz19 (\1\:VDD \10\:VDD) resistor r=25 c=0
Rz20 (\1\:VDD \12\:VDD) resistor r=18.75 c=0
Rz11 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz12 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz13 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz14 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz15 (\14\:VSS \15\:VSS) resistor r=37.5 c=0
Rz2 (\10\:qbint \11\:qbint) resistor r=75 c=0
Rz7 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz3 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz4 (\6\:mout \7\:mout) resistor r=75 c=0
Rz6 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\8\:Db \9\:Db) resistor r=75 c=0
Rz10 (\7\:SEb \8\:SEb) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry16 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry17 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry18 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry19 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry20 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry21 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry22 (\25\:VDD \26\:VDD) resistor r=20.6667 c=0
Ry14 (\3\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry15 (\3\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry2 (\12\:qbint \13\:qbint) resistor r=62 c=0
Ry9 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry3 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry4 (\8\:mout \9\:mout) resistor r=62 c=0
Ry8 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry10 (\3\:Db \4\:Db) resistor r=62 c=0
Ry11 (\6\:Db \7\:Db) resistor r=31 c=0
Ry12 (\3\:Db \10\:Db) resistor r=62 c=0
Ry13 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry5 (net349 \2\:net349) resistor r=62 c=0
Ry6 (\3\:net349 \4\:net349) resistor r=62 c=0
Rx15 (\3\:D \5\:D) resistor r=45 c=0
Rx2 (\6\:RN \7\:RN) resistor r=45 c=0
Rx17 (\1\:SE \8\:SE) resistor r=45 c=0
Rx18 (\4\:SE \9\:SE) resistor r=45 c=0
Rx19 (\6\:SE \10\:SE) resistor r=45 c=0
Rx1 (\2\:CK \6\:CK) resistor r=45 c=0
Rx16 (\2\:SI \4\:SI) resistor r=45 c=0
Rx3 (\6\:qbint \8\:qbint) resistor r=45 c=0
Rx4 (qbint \14\:qbint) resistor r=45 c=0
Rx11 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx12 (\6\:CKb \12\:CKb) resistor r=45 c=0
Rx13 (\4\:CKb \17\:CKb) resistor r=45 c=0
Rx14 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \8\:n30) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx8 (\6\:CKbb \11\:CKbb) resistor r=45 c=0
Rx9 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx10 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx20 (\2\:SEb \4\:SEb) resistor r=45 c=0
mn55 (\4\:Q \3\:qbint \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=2.73846e-07 sd=160n sca=10.5507 scb=0.0097116 \
        scc=0.000384728 m=(1)
mn20 (\19\:CKb \3\:CK \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.103e-14 ps=9e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.45e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn46 (\10\:qbint \3\:n30 net337 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=3.793e-14 ps=7.3e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85e-07 sb=2e-06 sd=160n sca=9.00745 scb=0.0073653 \
        scc=0.000173562 m=(1)
mn45 (net337 \5\:RN \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.77e-14 ad=3.28e-14 ps=1.06e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.9e-07 sb=1.95e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn50 (net405 \7\:qbint \12\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.77e-14 ad=1.23e-14 ps=1.06e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=1.685e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn51 (\6\:n30 CKb net405 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=5.228e-14 ps=5.3e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.6e-07 sb=1.58e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn40 (\6\:n30 CKbb \6\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.945e-14 ad=5.228e-14 ps=9.9e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06e-06 sb=1.28e-06 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn25 (\8\:n20 \7\:CKb \8\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.178e-14 ad=4.613e-14 ps=7.2e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.55e-07 sd=160n sca=9.00745 scb=0.0073653 \
        scc=0.000173562 m=(1)
mn30 (\6\:mout n20 \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.245e-14 ad=5.945e-14 ps=1.24e-06 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.395e-06 sb=9.45e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn35 (net426 \1\:RN \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.245e-14 ad=2.665e-14 ps=1.24e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63e-06 sb=7.1e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn36 (net422 \3\:mout net426 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.665e-14 ad=1.333e-14 ps=6.7e-07 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.805e-06 sb=5.35e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn37 (\8\:n20 \4\:CKbb net422 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.333e-14 ad=4.613e-14 ps=5.4e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.915e-06 sb=4.25e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn21 (\14\:CKbb \10\:CKb \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.12276e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn11 (net450 \4\:D \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=6.76e-14 ps=8.4e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.36635e-07 sb=8.51635e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn12 (Db \3\:SEb net450 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.76e-14 ad=4.16e-14 ps=1.04e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.41635e-07 sb=5.46635e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (Db \3\:SE net442 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.46635e-07 sb=3.41635e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn13 (net442 \1\:SI \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.51635e-07 sb=2.36635e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn10 (\7\:SEb \7\:SE \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12276e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp20 (\15\:CKb \1\:CK \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.118e-14 ps=1.16e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.45e-07 sd=160n sca=12.6299 \
        scb=0.00978612 scc=8.84613e-05 m=(1)
mp46 (\12\:qbint n30 \23\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.83e-14 ad=4.96e-14 ps=1.22e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.735e-06 sd=160n sca=12.1897 \
        scb=0.0106254 scc=0.000361908 m=(1)
mp45 (\21\:VDD \3\:RN \12\:qbint VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.96e-14 ad=6.82e-14 ps=9.4e-07 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.53e-06 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp50 (net326 \5\:qbint \21\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.82e-14 ad=4.805e-14 ps=1.06e-06 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.265e-06 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp51 (\4\:n30 \3\:CKbb net326 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.805e-14 ad=4.96e-14 ps=9.3e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.4e-07 sb=1.065e-06 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp40 (\4\:n30 \3\:CKb \8\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.13e-14 ad=4.96e-14 ps=1.08e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=8.6e-07 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp30 (\8\:mout \3\:n20 \19\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.38e-14 ad=7.13e-14 ps=1.32e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.32e-06 sb=5.85e-07 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp35 (\3\:net349 \2\:RN \19\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.38e-14 ad=4.96e-14 ps=1.32e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=3.2e-07 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp36 (\3\:net349 mout \17\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.883e-14 ad=4.96e-14 ps=1.47e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=1.15e-07 sd=160n sca=12.1411 \
        scb=0.0106159 scc=0.000361907 m=(1)
mp37 (\4\:n20 \5\:CKb net349 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp25 (\4\:n20 \7\:CKbb \6\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp21 (\8\:CKbb \8\:CKb \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.98e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.165e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp11 (net381 \1\:D \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.98e-14 ad=2.34e-14 ps=1.62e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=8.20897e-07 sd=160n sca=12.2138 \
        scb=0.0106342 scc=0.00038358 m=(1)
mp12 (\3\:Db \2\:SE net381 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=7.02e-14 ps=9e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40064e-07 sb=7.15897e-07 sd=160n sca=12.2524 \
        scb=0.0106415 scc=0.00038358 m=(1)
mp14 (\3\:Db SEb net373 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=7.02e-14 ps=1.05e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.65064e-07 sb=4.90897e-07 sd=160n sca=12.9125 \
        scb=0.0109255 scc=0.000383719 m=(1)
mp13 (net373 \3\:SI \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.147e-14 ad=5.265e-14 ps=1.31e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.45064e-07 sb=3.10897e-07 sd=160n sca=14.0619 \
        scb=0.0121239 scc=0.000387547 m=(1)
mp10 (\5\:SEb \5\:SE \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.147e-14 ad=3.01e-14 ps=1.31e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.4e-07 sd=160n sca=25.1693 \
        scb=0.0296469 scc=0.00157586 m=(1)
ends SDFFRHQX1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:31:20 2012 )
// Library name: gsclib045
// Cell name: SDFFRHQX2
// View name: extracted

simulator lang=spectre

subckt SDFFRHQX2 CK D Q RN SE SI VDD VSS
mp55_1__rcx (\3\:Q qbint VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.325e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.40064e-07 sd=160n sca=36.4171 \
        scb=0.0367067 scc=0.00372944 m=(2)
C1 (D VSS) capacitor c=4.10899e-17
C2 (Q VSS) capacitor c=4.35048e-17
C3 (RN VSS) capacitor c=6.3647e-17
C4 (SE VSS) capacitor c=5.36621e-17
C5 (VDD VSS) capacitor c=4.59602e-16
C6 (CK VSS) capacitor c=7.15189e-17
C7 (SI VSS) capacitor c=6.96209e-17
C8 (qbint VSS) capacitor c=1.7738e-16
C9 (CKb VSS) capacitor c=4.3481e-17
C10 (net337 VSS) capacitor c=9.17463e-18
C11 (n30 VSS) capacitor c=5.8159e-17
C12 (net405 VSS) capacitor c=3.70463e-18
C13 (mout VSS) capacitor c=5.56644e-17
C14 (CKbb VSS) capacitor c=2.1783e-17
C15 (n20 VSS) capacitor c=3.73225e-17
C16 (net426 VSS) capacitor c=6.64024e-19
C17 (net422 VSS) capacitor c=1.2838e-18
C18 (Db VSS) capacitor c=8.398e-17
C19 (net450 VSS) capacitor c=5.79847e-18
C20 (SEb VSS) capacitor c=4.54081e-17
C21 (net326 VSS) capacitor c=5.02997e-18
C22 (net349 VSS) capacitor c=6.84568e-17
C23 (net381 VSS) capacitor c=3.83547e-18
C24 (net373 VSS) capacitor c=4.02889e-18
C25 (\7\:SE VSS) capacitor c=4.82967e-17
C26 (\3\:SI VSS) capacitor c=5.81552e-17
C27 (\2\:SE VSS) capacitor c=5.1274e-17
C28 (\1\:D VSS) capacitor c=7.72761e-17
C29 (\8\:CKb VSS) capacitor c=3.79583e-17
C30 (\8\:CKbb VSS) capacitor c=5.25811e-17
C31 (\6\:CKb VSS) capacitor c=4.97007e-17
C32 (\3\:mout VSS) capacitor c=6.07591e-17
C33 (\2\:RN VSS) capacitor c=1.51349e-16
C34 (\3\:n20 VSS) capacitor c=5.50494e-17
C35 (\3\:CKb VSS) capacitor c=3.17282e-17
C36 (\3\:CKbb VSS) capacitor c=8.96171e-17
C37 (\8\:qbint VSS) capacitor c=8.48048e-17
C38 (\3\:RN VSS) capacitor c=1.16622e-16
C39 (\3\:CK VSS) capacitor c=4.48695e-17
C40 (\5\:SE VSS) capacitor c=3.0005e-17
C41 (\1\:SI VSS) capacitor c=7.99496e-17
C42 (\3\:SE VSS) capacitor c=6.48722e-17
C43 (\3\:SEb VSS) capacitor c=5.38613e-17
C44 (\4\:D VSS) capacitor c=3.8808e-17
C45 (\10\:CKb VSS) capacitor c=5.45796e-17
C46 (\5\:CKb VSS) capacitor c=5.23075e-17
C47 (\5\:CKbb VSS) capacitor c=4.19581e-17
C48 (\1\:RN VSS) capacitor c=1.02056e-16
C49 (\10\:qbint VSS) capacitor c=4.06841e-17
C50 (\5\:RN VSS) capacitor c=4.49581e-17
C51 (\3\:n30 VSS) capacitor c=2.07399e-17
C52 (\1\:CK VSS) capacitor c=3.82189e-17
C53 (\6\:SE VSS) capacitor c=3.90136e-17
C54 (\2\:SI VSS) capacitor c=6.55455e-17
C55 (\4\:SE VSS) capacitor c=4.19969e-17
C56 (\2\:SEb VSS) capacitor c=7.11473e-17
C57 (\1\:SE VSS) capacitor c=4.40487e-17
C58 (\3\:D VSS) capacitor c=2.84185e-17
C59 (\9\:CKb VSS) capacitor c=2.66487e-17
C60 (\7\:CKbb VSS) capacitor c=3.54445e-17
C61 (\7\:CKb VSS) capacitor c=1.8672e-17
C62 (\6\:CKbb VSS) capacitor c=4.72887e-17
C63 (\2\:mout VSS) capacitor c=7.88882e-17
C64 (\2\:n20 VSS) capacitor c=3.73988e-17
C65 (\4\:CKbb VSS) capacitor c=1.57815e-17
C66 (\4\:CKb VSS) capacitor c=3.53438e-17
C67 (\2\:CKb VSS) capacitor c=5.3244e-17
C68 (\9\:qbint VSS) capacitor c=5.01747e-17
C69 (\4\:RN VSS) capacitor c=5.12484e-17
C70 (\2\:n30 VSS) capacitor c=4.48482e-17
C71 (\2\:CK VSS) capacitor c=4.68892e-17
C72 (\6\:SEb VSS) capacitor c=1.13711e-16
C73 (\1\:VDD VSS) capacitor c=3.05448e-17
C74 (\4\:Db VSS) capacitor c=5.35661e-17
C75 (\14\:VDD VSS) capacitor c=1.18445e-17
C76 (\9\:CKbb VSS) capacitor c=6.97248e-17
C77 (\6\:Db VSS) capacitor c=1.63753e-16
C78 (\4\:n20 VSS) capacitor c=5.74092e-17
C79 (\16\:VDD VSS) capacitor c=2.1596e-17
C80 (\3\:net349 VSS) capacitor c=6.51935e-17
C81 (\18\:VDD VSS) capacitor c=3.07522e-17
C82 (\4\:mout VSS) capacitor c=4.39219e-17
C83 (\4\:n30 VSS) capacitor c=1.09875e-16
C84 (\20\:VDD VSS) capacitor c=3.63012e-17
C85 (\16\:qbint VSS) capacitor c=7.67918e-17
C86 (\22\:VDD VSS) capacitor c=2.4824e-17
C87 (\16\:CKb VSS) capacitor c=3.33657e-17
C88 (\3\:Q VSS) capacitor c=5.56578e-17
C89 (\3\:VDD VSS) capacitor c=6.86747e-17
C90 (\4\:SEb VSS) capacitor c=6.62919e-17
C91 (\12\:CKbb VSS) capacitor c=6.38607e-17
C92 (\8\:Db VSS) capacitor c=8.64362e-17
C93 (\8\:n20 VSS) capacitor c=7.1223e-17
C94 (\7\:mout VSS) capacitor c=4.05399e-17
C95 (\6\:n30 VSS) capacitor c=1.3075e-16
C96 (\13\:qbint VSS) capacitor c=1.46842e-16
C97 (\20\:CKb VSS) capacitor c=1.20132e-16
C98 (\1\:Q VSS) capacitor c=5.4396e-17
C99 (\2\:CKbb VSS) capacitor c=4.42401e-17
C100 (\2\:D VSS) capacitor c=2.28113e-17
C101 (\4\:CK VSS) capacitor c=5.47125e-17
C102 (\11\:qbint VSS) capacitor c=7.82759e-17
C103 (\12\:qbint VSS) capacitor c=1.3036e-16
C104 (\15\:qbint VSS) capacitor c=1.15282e-16
C105 (\6\:RN VSS) capacitor c=7.57435e-17
C106 (\8\:n30 VSS) capacitor c=1.09591e-16
C107 (\6\:mout VSS) capacitor c=8.18155e-17
C108 (\9\:mout VSS) capacitor c=7.79668e-17
C109 (\6\:n20 VSS) capacitor c=9.88692e-17
C110 (\7\:n20 VSS) capacitor c=1.02602e-16
C111 (\11\:CKbb VSS) capacitor c=4.44596e-17
C112 (\14\:CKbb VSS) capacitor c=1.63941e-16
C113 (\15\:CKbb VSS) capacitor c=1.19921e-16
C114 (\16\:CKbb VSS) capacitor c=1.68304e-17
C115 (\17\:CKbb VSS) capacitor c=6.19202e-17
C116 (\11\:CKb VSS) capacitor c=7.17665e-17
C117 (\12\:CKb VSS) capacitor c=1.81774e-16
C118 (\13\:CKb VSS) capacitor c=1.04635e-16
C119 (\14\:CKb VSS) capacitor c=1.33062e-16
C120 (\15\:CKb VSS) capacitor c=1.23564e-16
C121 (\18\:CKb VSS) capacitor c=5.42118e-17
C122 (\19\:CKb VSS) capacitor c=7.94687e-17
C123 (\5\:D VSS) capacitor c=6.90554e-17
C124 (\3\:Db VSS) capacitor c=1.28499e-16
C125 (\8\:SE VSS) capacitor c=7.19462e-17
C126 (\10\:SE VSS) capacitor c=4.97507e-17
C127 (\4\:SI VSS) capacitor c=7.19375e-17
C128 (\8\:SEb VSS) capacitor c=7.7402e-17
C129 (\5\:VDD VSS) capacitor c=3.08945e-17
C130 (\6\:VDD VSS) capacitor c=3.17633e-17
C131 (\8\:VDD VSS) capacitor c=3.18361e-17
C132 (\9\:VDD VSS) capacitor c=4.5314e-17
C133 (\10\:VDD VSS) capacitor c=1.36933e-17
Rk32 (\5\:D D) resistor r=0.1125 c=0
Rk1 (\2\:Q Q) resistor r=0.3383 c=0
Rk2 (Q \4\:Q) resistor r=0.04504 c=0
Rk8 (RN \6\:RN) resistor r=0.0315 c=0
Rk39 (\9\:SE SE) resistor r=0.009307 c=0
Rk38 (\8\:SE \9\:SE) resistor r=0.3319 c=0
Rk40 (SE \10\:SE) resistor r=0.2305 c=0
Rk57 (\2\:VDD \4\:VDD) resistor r=0.3869 c=0
Rk58 (\4\:VDD \5\:VDD) resistor r=0.2697 c=0
Rk59 (\5\:VDD \6\:VDD) resistor r=0.5494 c=0
Rk60 (\6\:VDD \7\:VDD) resistor r=0.1794 c=0
Rk61 (\7\:VDD \8\:VDD) resistor r=0.03993 c=0
Rk62 (\8\:VDD \9\:VDD) resistor r=0.5639 c=0
Rk63 (\9\:VDD \10\:VDD) resistor r=0.2504 c=0
Rk65 (\11\:VDD VDD) resistor r=0.2431 c=0
Rk64 (\10\:VDD \11\:VDD) resistor r=0.1478 c=0
Rk68 (\5\:VDD \15\:VDD) resistor r=0.04331 c=0
Rk69 (\6\:VDD \17\:VDD) resistor r=0.04331 c=0
Rk70 (\8\:VDD \19\:VDD) resistor r=0.1528 c=0
Rk71 (\9\:VDD \21\:VDD) resistor r=0.1528 c=0
Rk72 (\10\:VDD \23\:VDD) resistor r=0.1374 c=0
Rk3 (\4\:CK CK) resistor r=0.05672 c=0
Rk41 (\4\:SI SI) resistor r=0.1334 c=0
Rk44 (\2\:VSS \4\:VSS) resistor r=0.3672 c=0
Rk45 (\4\:VSS \5\:VSS) resistor r=0.4061 c=0
Rk46 (\5\:VSS \6\:VSS) resistor r=0.4462 c=0
Rk47 (\6\:VSS \7\:VSS) resistor r=0.2822 c=0
Rk48 (\7\:VSS \8\:VSS) resistor r=0.6783 c=0
Rk50 (\9\:VSS VSS) resistor r=0.3459 c=0
Rk49 (\8\:VSS \9\:VSS) resistor r=0.2406 c=0
Rk52 (\5\:VSS \12\:VSS) resistor r=0.231 c=0
Rk53 (\7\:VSS \14\:VSS) resistor r=0.04331 c=0
Rk54 (\8\:VSS \16\:VSS) resistor r=0.1628 c=0
Rk4 (\11\:qbint \12\:qbint) resistor r=0.4802 c=0
Rk5 (\12\:qbint \14\:qbint) resistor r=0.5459 c=0
Rk6 (\14\:qbint \15\:qbint) resistor r=0.7093 c=0
Rk7 (\12\:qbint \17\:qbint) resistor r=0.3532 c=0
Rk24 (\11\:CKb \12\:CKb) resistor r=0.4756 c=0
Rk25 (\12\:CKb \13\:CKb) resistor r=0.9859 c=0
Rk26 (\13\:CKb \14\:CKb) resistor r=0.2399 c=0
Rk27 (\14\:CKb \15\:CKb) resistor r=0.797 c=0
Rk28 (\15\:CKb \17\:CKb) resistor r=0.0824 c=0
Rk29 (\13\:CKb \18\:CKb) resistor r=0.2755 c=0
Rk30 (\14\:CKb \19\:CKb) resistor r=0.3888 c=0
Rk31 (\15\:CKb \21\:CKb) resistor r=0.6116 c=0
Rk9 (\5\:n30 \7\:n30) resistor r=0.4983 c=0
Rk10 (\7\:n30 \8\:n30) resistor r=0.8286 c=0
Rk11 (\5\:mout \6\:mout) resistor r=0.3143 c=0
Rk12 (\6\:mout \8\:mout) resistor r=0.09076 c=0
Rk13 (\6\:mout \9\:mout) resistor r=0.4237 c=0
Rk18 (\10\:CKbb \11\:CKbb) resistor r=0.3423 c=0
Rk19 (\11\:CKbb \13\:CKbb) resistor r=0.1285 c=0
Rk20 (\13\:CKbb \14\:CKbb) resistor r=0.6103 c=0
Rk21 (\14\:CKbb \15\:CKbb) resistor r=0.9205 c=0
Rk22 (\11\:CKbb \16\:CKbb) resistor r=0.04461 c=0
Rk23 (\14\:CKbb \17\:CKbb) resistor r=0.2339 c=0
Rk15 (\5\:n20 \6\:n20) resistor r=0.2275 c=0
Rk16 (\6\:n20 \7\:n20) resistor r=0.6229 c=0
Rk17 (\6\:n20 \9\:n20) resistor r=0.3042 c=0
Rk33 (\2\:Db \3\:Db) resistor r=0.5529 c=0
Rk34 (\3\:Db \5\:Db) resistor r=0.1548 c=0
Rk35 (\3\:Db \7\:Db) resistor r=0.6961 c=0
Rk36 (\7\:Db \9\:Db) resistor r=0.5164 c=0
Rk37 (\5\:Db \10\:Db) resistor r=0.1478 c=0
Rk42 (\5\:SEb \7\:SEb) resistor r=0.6566 c=0
Rk43 (\7\:SEb \8\:SEb) resistor r=0.4758 c=0
Rk14 (\2\:net349 \4\:net349) resistor r=0.2443 c=0
Rl32 (\1\:D \2\:D) resistor r=102.726 c=0
Rl34 (\2\:D \4\:D) resistor r=37.3411 c=0
Rl33 (\2\:D \3\:D) resistor r=6.9867 c=0
Rl21 (\2\:RN \3\:RN) resistor r=738.027 c=0
Rl20 (\1\:RN \2\:RN) resistor r=193.362 c=0
Rl22 (\3\:RN \4\:RN) resistor r=50 c=0
Rl23 (\4\:RN \5\:RN) resistor r=99.1758 c=0
Rl42 (\6\:SE \7\:SE) resistor r=95.3297 c=0
Rl41 (\5\:SE \6\:SE) resistor r=32.6923 c=0
Rl38 (\3\:SE \4\:SE) resistor r=24.2328 c=0
Rl35 (\1\:SE \2\:SE) resistor r=32.6096 c=0
Rl8 (\2\:CK \3\:CK) resistor r=129.944 c=0
Rl7 (\1\:CK \2\:CK) resistor r=53.0211 c=0
Rl40 (\2\:SI \3\:SI) resistor r=44.4497 c=0
Rl39 (\1\:SI \2\:SI) resistor r=86.3335 c=0
Rl11 (\9\:qbint \8\:qbint) resistor r=123.799 c=0
Rl12 (\9\:qbint \10\:qbint) resistor r=24.2328 c=0
Rl5 (qbint \6\:qbint) resistor r=3.5051 c=0
Rl31 (\8\:CKb \10\:CKb) resistor r=150 c=0
Rl27 (\5\:CKb \6\:CKb) resistor r=164.95 c=0
Rl30 (\8\:CKb \9\:CKb) resistor r=61.0982 c=0
Rl28 (\6\:CKb \7\:CKb) resistor r=37.2302 c=0
Rl14 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl13 (CKb \2\:CKb) resistor r=70.3867 c=0
Rl9 (n30 \2\:n30) resistor r=184.593 c=0
Rl10 (\2\:n30 \3\:n30) resistor r=24.7951 c=0
Rl24 (mout \2\:mout) resistor r=24.2328 c=0
Rl25 (\2\:mout \3\:mout) resistor r=119.952 c=0
Rl29 (\7\:CKbb \8\:CKbb) resistor r=113.439 c=0
Rl26 (\5\:CKbb \6\:CKbb) resistor r=35.7713 c=0
Rl15 (CKbb \2\:CKbb) resistor r=23.7402 c=0
Rl16 (\2\:CKbb \3\:CKbb) resistor r=176.797 c=0
Rl17 (\2\:CKbb \4\:CKbb) resistor r=35.2766 c=0
Rl18 (n20 \2\:n20) resistor r=70.3867 c=0
Rl19 (\2\:n20 \3\:n20) resistor r=97.631 c=0
Rl36 (SEb \2\:SEb) resistor r=25.0391 c=0
Rl37 (\2\:SEb \3\:SEb) resistor r=122.356 c=0
Rz1 (\2\:Q \1\:Q) resistor r=75 c=0
Rz20 (VDD \3\:VDD) resistor r=75 c=0
Rz17 (\4\:VDD \3\:VDD) resistor r=9.375 c=0
Rz18 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz19 (\11\:VDD \3\:VDD) resistor r=9.375 c=0
Rz11 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz12 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz13 (\14\:VSS \13\:VSS) resistor r=75 c=0
Rz14 (\16\:VSS \15\:VSS) resistor r=75 c=0
Rz2 (\14\:qbint \13\:qbint) resistor r=75 c=0
Rz7 (\20\:CKb \21\:CKb) resistor r=75 c=0
Rz3 (\6\:n30 \7\:n30) resistor r=75 c=0
Rz4 (\7\:mout \8\:mout) resistor r=75 c=0
Rz6 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz5 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz8 (Db \2\:Db) resistor r=75 c=0
Rz9 (\8\:Db \9\:Db) resistor r=75 c=0
Rz10 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry1 (\4\:Q \3\:Q) resistor r=20.6667 c=0
Ry17 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry18 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry19 (\17\:VDD \16\:VDD) resistor r=62 c=0
Ry20 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry21 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry22 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry14 (\4\:VSS \3\:VSS) resistor r=12.4 c=0
Ry15 (\6\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry16 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry2 (\17\:qbint \16\:qbint) resistor r=62 c=0
Ry9 (\16\:CKb \17\:CKb) resistor r=62 c=0
Ry3 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry4 (\4\:mout \5\:mout) resistor r=62 c=0
Ry8 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry7 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry10 (\4\:Db \5\:Db) resistor r=62 c=0
Ry11 (\6\:Db \7\:Db) resistor r=31 c=0
Ry12 (\4\:Db \10\:Db) resistor r=62 c=0
Ry13 (\6\:SEb \7\:SEb) resistor r=62 c=0
Ry5 (net349 \2\:net349) resistor r=62 c=0
Ry6 (\3\:net349 \4\:net349) resistor r=62 c=0
Rx15 (\3\:D \5\:D) resistor r=45 c=0
Rx4 (\4\:RN \6\:RN) resistor r=45 c=0
Rx16 (\1\:SE \8\:SE) resistor r=45 c=0
Rx17 (\4\:SE \9\:SE) resistor r=45 c=0
Rx18 (\6\:SE \10\:SE) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx19 (\2\:SI \4\:SI) resistor r=45 c=0
Rx2 (\11\:qbint \9\:qbint) resistor r=45 c=0
Rx3 (\15\:qbint \6\:qbint) resistor r=45 c=0
Rx11 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx12 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx13 (\4\:CKb \18\:CKb) resistor r=45 c=0
Rx14 (\2\:CKb \19\:CKb) resistor r=45 c=0
Rx5 (\2\:n30 \8\:n30) resistor r=45 c=0
Rx6 (\2\:mout \9\:mout) resistor r=45 c=0
Rx8 (\4\:CKbb \15\:CKbb) resistor r=45 c=0
Rx9 (\7\:CKbb \16\:CKbb) resistor r=45 c=0
Rx10 (\6\:CKbb \17\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx20 (\2\:SEb \8\:SEb) resistor r=45 c=0
mn55 (\1\:Q qbint VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.003e-14 ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.23462e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(2)
mn20 (\20\:CKb \1\:CK VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.263e-14 ps=9e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=2.25e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn46 (\13\:qbint \3\:n30 net337 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.458e-14 ad=4.613e-14 ps=1.04e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=2e-06 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn50 (net405 \10\:qbint \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=5.77e-14 ad=2.768e-14 ps=1.06e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=2e-06 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn45 (net337 \5\:RN \15\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.77e-14 ad=6.458e-14 ps=1.06e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=2e-06 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn51 (\6\:n30 CKb net405 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.768e-14 ad=3.69e-14 ps=6.8e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=1.895e-06 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn36 (net422 mout net426 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.768e-14 ps=5.3e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=6.45e-07 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn40 (\6\:n30 CKbb \7\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.1173e-13 ad=3.69e-14 ps=1.5e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=1.67e-06 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn30 (\7\:mout n20 \13\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.783e-14 ad=1.1173e-13 ps=1.47e-06 pd=1.5e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=1.08e-06 sd=160n sca=9.70996 \
        scb=0.0085072 scc=0.000244399 m=(1)
mn35 (net426 \1\:RN \13\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.783e-14 ad=1.23e-14 ps=1.47e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.5e-07 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn37 (\8\:n20 \5\:CKbb net422 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.767e-14 ad=5.432e-14 ps=6.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.65e-07 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn25 (\8\:n20 \5\:CKb \8\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.177e-14 ad=5.432e-14 ps=7.2e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.55e-07 sd=160n sca=9.70996 scb=0.0085072 \
        scc=0.000244399 m=(1)
mn21 (\12\:CKbb \10\:CKb \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=3.843e-14 ps=9e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.65e-07 sb=1.21621e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn11 (net450 \4\:D \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=5.07e-14 ps=9e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.40769e-07 sb=8.77212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn12 (Db \3\:SEb net450 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=6.37e-14 ps=9.1e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.80769e-07 sb=6.37212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (Db \3\:SE net442 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=6.37e-14 ps=6.4e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.70769e-07 sb=3.47212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn13 (net442 \1\:SI \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=1.56e-14 ps=8.6e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75769e-07 sb=2.42212e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn10 (\4\:SEb \5\:SE \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.615e-14 ad=2.03e-14 ps=8.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.33759e-06 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mp20 (\16\:CKb \3\:CK VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.4e-07 sd=160n sca=13.0129 \
        scb=0.0110013 scc=0.000282677 m=(1)
mp46 (\16\:qbint n30 \22\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.21e-14 ad=4.96e-14 ps=1.45e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.9e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp45 (\20\:VDD \3\:RN \16\:qbint VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.96e-14 ad=9.4e-14 ps=9.4e-07 pd=1.49e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.695e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp50 (net326 \8\:qbint \20\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.4e-14 ad=3.1e-14 ps=1.49e-06 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=1.43e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp35 (\3\:net349 \2\:RN \18\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.4e-14 ad=4.96e-14 ps=1.49e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.765e-06 sb=3.05e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp51 (\4\:n30 \3\:CKbb net326 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.1e-14 ad=7.905e-14 ps=8.2e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=1.285e-06 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp40 (\4\:n30 \3\:CKb \4\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.147e-13 ad=7.905e-14 ps=1.36e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.085e-06 sb=9.85e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp30 (\4\:mout \3\:n20 \18\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.4e-14 ad=1.147e-13 ps=1.49e-06 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-06 sb=5.7e-07 sd=160n sca=17.3904 \
        scb=0.0162056 scc=0.00137566 m=(1)
mp36 (\3\:net349 \3\:mout \16\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.64e-14 ad=4.96e-14 ps=1.64e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.97e-06 sb=1e-07 sd=160n sca=17.3904 scb=0.0162056 \
        scc=0.00137566 m=(1)
mp37 (\4\:n20 \6\:CKb net349 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=4.96e-14 ps=9.4e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=3.45e-07 sd=160n sca=33.4558 \
        scb=0.0229674 scc=0.00395167 m=(1)
mp25 (\4\:n20 \8\:CKbb \6\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.4e-07 sd=160n sca=33.4558 \
        scb=0.0229674 scc=0.00395167 m=(1)
mp21 (\9\:CKbb \8\:CKb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.05e-14 ad=3.01e-14 ps=1.85e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.17e-06 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp11 (net381 \1\:D \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.05e-14 ad=4.29e-14 ps=1.85e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.51603e-07 sb=8.29551e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp12 (\4\:Db \2\:SE net381 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.29e-14 ad=7.02e-14 ps=1e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.06603e-07 sb=6.74551e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp14 (\4\:Db SEb net373 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=7.02e-14 ps=1.05e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.31603e-07 sb=4.49551e-07 sd=160n sca=17.5519 \
        scb=0.0153572 scc=0.00137894 m=(1)
mp13 (net373 \3\:SI \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.265e-14 ps=1.16e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.11603e-07 sb=2.69551e-07 sd=160n sca=18.2813 \
        scb=0.0158345 scc=0.00137945 m=(1)
mp10 (\6\:SEb \7\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17e-06 sb=1.4e-07 sd=160n sca=26.3819 \
        scb=0.0255791 scc=0.00246259 m=(1)
ends SDFFRHQX2
// End of subcircuit definition.

// Generated for: spectre (May  9 17:31:57 2012 )
// Library name: gsclib045
// Cell name: SDFFRHQX4
// View name: extracted

simulator lang=spectre

subckt SDFFRHQX4 CK D Q RN SE SI VDD VSS
mp20 (\13\:CKb \3\:CK \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1192e-13 ad=4.085e-14 ps=1.88e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=1.4457e-06 sd=160n sca=18.4108 \
        scb=0.0197286 scc=0.000520456 m=(1)
C1 (D VSS) capacitor c=5.75318e-17
C2 (Q VSS) capacitor c=1.61854e-16
C3 (RN VSS) capacitor c=5.46916e-16
C4 (VDD VSS) capacitor c=4.55305e-16
C5 (CK VSS) capacitor c=4.21723e-17
C6 (CKb VSS) capacitor c=6.00541e-17
C7 (qbint VSS) capacitor c=2.64888e-16
C8 (21 VSS) capacitor c=2.881e-18
C9 (n30 VSS) capacitor c=1.23575e-16
C10 (22 VSS) capacitor c=2.92145e-18
C11 (net405 VSS) capacitor c=5.15127e-18
C12 (mout VSS) capacitor c=3.77311e-17
C13 (CKbb VSS) capacitor c=4.11627e-17
C14 (n20 VSS) capacitor c=2.12632e-17
C15 (net422 VSS) capacitor c=3.2421e-19
C16 (Db VSS) capacitor c=1.07721e-16
C17 (net450 VSS) capacitor c=1.78551e-18
C18 (SEb VSS) capacitor c=6.51843e-17
C19 (net442 VSS) capacitor c=4.49583e-18
C20 (net326 VSS) capacitor c=2.84457e-18
C21 (net349 VSS) capacitor c=7.62105e-17
C22 (net381 VSS) capacitor c=1.88088e-18
C23 (net373 VSS) capacitor c=4.93146e-18
C24 (\4\:SE VSS) capacitor c=3.38878e-17
C25 (\1\:SI VSS) capacitor c=5.1048e-17
C26 (\3\:SEb VSS) capacitor c=4.69814e-17
C27 (\3\:SE VSS) capacitor c=1.12352e-16
C28 (\1\:D VSS) capacitor c=1.00704e-16
C29 (\7\:CKb VSS) capacitor c=4.38892e-17
C30 (\7\:CKbb VSS) capacitor c=3.27663e-17
C31 (\4\:CKb VSS) capacitor c=4.69176e-17
C32 (\8\:RN VSS) capacitor c=4.08806e-17
C33 (\4\:n20 VSS) capacitor c=5.12549e-17
C34 (\2\:CKb VSS) capacitor c=4.40926e-17
C35 (\2\:CKbb VSS) capacitor c=4.38958e-17
C36 (\16\:qbint VSS) capacitor c=3.95536e-17
C37 (\3\:CK VSS) capacitor c=3.29688e-17
C38 (\6\:SE VSS) capacitor c=2.44073e-17
C39 (\3\:SI VSS) capacitor c=4.81453e-17
C40 (\1\:SE VSS) capacitor c=3.46516e-17
C41 (\3\:D VSS) capacitor c=6.90303e-17
C42 (\9\:CKb VSS) capacitor c=5.54346e-17
C43 (\6\:CKb VSS) capacitor c=4.14848e-17
C44 (\5\:CKbb VSS) capacitor c=4.11408e-17
C45 (\3\:mout VSS) capacitor c=3.58675e-17
C46 (\10\:RN VSS) capacitor c=3.54251e-17
C47 (\3\:n20 VSS) capacitor c=2.42281e-17
C48 (\3\:CKbb VSS) capacitor c=4.29146e-17
C49 (\18\:qbint VSS) capacitor c=3.85763e-17
C50 (\7\:RN VSS) capacitor c=3.12093e-17
C51 (\5\:n30 VSS) capacitor c=2.6889e-17
C52 (\4\:n30 VSS) capacitor c=3.49711e-17
C53 (\1\:RN VSS) capacitor c=4.13073e-17
C54 (\1\:CK VSS) capacitor c=3.44406e-17
C55 (\5\:SE VSS) capacitor c=2.32268e-17
C56 (\2\:SI VSS) capacitor c=4.50235e-17
C57 (\4\:SEb VSS) capacitor c=4.71312e-17
C58 (\2\:SE VSS) capacitor c=5.61886e-17
C59 (\2\:SEb VSS) capacitor c=5.96109e-17
C60 (\2\:D VSS) capacitor c=5.18515e-17
C61 (\8\:CKb VSS) capacitor c=2.25127e-17
C62 (\8\:CKbb VSS) capacitor c=1.70708e-17
C63 (\5\:CKb VSS) capacitor c=2.74008e-17
C64 (\6\:CKbb VSS) capacitor c=4.1674e-17
C65 (\2\:mout VSS) capacitor c=3.19082e-17
C66 (\9\:RN VSS) capacitor c=3.29582e-17
C67 (\4\:CKbb VSS) capacitor c=2.88458e-17
C68 (\3\:CKb VSS) capacitor c=2.52636e-17
C69 (\17\:qbint VSS) capacitor c=3.02838e-17
C70 (\2\:CK VSS) capacitor c=3.68152e-17
C71 (\7\:SEb VSS) capacitor c=8.92786e-17
C72 (\1\:VDD VSS) capacitor c=4.13718e-17
C73 (\6\:VDD VSS) capacitor c=4.935e-17
C74 (\9\:CKbb VSS) capacitor c=6.15019e-17
C75 (\7\:Db VSS) capacitor c=2.50107e-17
C76 (\5\:n20 VSS) capacitor c=1.02763e-16
C77 (\10\:VDD VSS) capacitor c=2.0724e-17
C78 (\3\:net349 VSS) capacitor c=7.88402e-17
C79 (\13\:VDD VSS) capacitor c=2.56169e-17
C80 (\5\:mout VSS) capacitor c=1.69106e-16
C81 (\11\:n30 VSS) capacitor c=8.67851e-17
C82 (\21\:VDD VSS) capacitor c=2.0362e-17
C83 (\20\:qbint VSS) capacitor c=1.49038e-16
C84 (\13\:CKb VSS) capacitor c=2.53029e-16
C85 (\3\:VDD VSS) capacitor c=1.69472e-16
C86 (\5\:SEb VSS) capacitor c=6.83599e-17
C87 (\9\:Db VSS) capacitor c=7.89721e-17
C88 (\16\:CKbb VSS) capacitor c=6.58435e-17
C89 (\5\:Db VSS) capacitor c=7.19722e-17
C90 (\9\:n20 VSS) capacitor c=1.76801e-17
C91 (\7\:mout VSS) capacitor c=8.87815e-17
C92 (\7\:n30 VSS) capacitor c=7.69784e-17
C93 (\23\:qbint VSS) capacitor c=7.51685e-17
C94 (\15\:CKb VSS) capacitor c=7.77592e-17
C95 (\2\:n20 VSS) capacitor c=1.81156e-17
C96 (\4\:CK VSS) capacitor c=6.21269e-17
C97 (\19\:qbint VSS) capacitor c=4.38018e-17
C98 (\27\:qbint VSS) capacitor c=6.67026e-17
C99 (\9\:n30 VSS) capacitor c=1.27449e-16
C100 (\10\:n30 VSS) capacitor c=1.11006e-16
C101 (\11\:RN VSS) capacitor c=2.44363e-16
C102 (\4\:mout VSS) capacitor c=1.23392e-16
C103 (\7\:n20 VSS) capacitor c=1.14665e-16
C104 (\8\:n20 VSS) capacitor c=1.02086e-16
C105 (\11\:CKbb VSS) capacitor c=5.91e-17
C106 (\12\:CKbb VSS) capacitor c=2.75695e-16
C107 (\13\:CKbb VSS) capacitor c=2.19597e-16
C108 (\14\:CKbb VSS) capacitor c=4.87297e-17
C109 (\15\:CKbb VSS) capacitor c=7.2544e-17
C110 (\18\:CKbb VSS) capacitor c=8.01467e-17
C111 (\19\:CKbb VSS) capacitor c=3.39969e-17
C112 (\10\:CKb VSS) capacitor c=9.93984e-17
C113 (\11\:CKb VSS) capacitor c=2.3952e-16
C114 (\12\:CKb VSS) capacitor c=3.63555e-16
C115 (\4\:D VSS) capacitor c=6.94129e-17
C116 (\3\:Db VSS) capacitor c=9.19272e-17
C117 (\4\:Db VSS) capacitor c=1.45424e-16
C118 (\4\:SI VSS) capacitor c=1.17623e-16
C119 (\7\:SE VSS) capacitor c=9.26387e-17
C120 (\8\:SE VSS) capacitor c=8.10002e-17
C121 (\9\:SEb VSS) capacitor c=1.13228e-16
C122 (\10\:SEb VSS) capacitor c=6.39834e-17
C123 (\5\:VDD VSS) capacitor c=4.04566e-17
C124 (\9\:VDD VSS) capacitor c=1.86558e-17
C125 (\12\:VDD VSS) capacitor c=2.93388e-17
C126 (\16\:VDD VSS) capacitor c=1.62812e-16
Rk36 (D \4\:D) resistor r=0.102 c=0
Rk69 (\2\:VSS \4\:VSS) resistor r=0.2745 c=0
Rk70 (\4\:VSS \5\:VSS) resistor r=0.3708 c=0
Rk71 (\5\:VSS \6\:VSS) resistor r=0.4811 c=0
Rk72 (\6\:VSS \7\:VSS) resistor r=0.5188 c=0
Rk73 (\7\:VSS \8\:VSS) resistor r=0.5338 c=0
Rk74 (\8\:VSS \9\:VSS) resistor r=0.1242 c=0
Rk79 (\10\:VSS VSS) resistor r=0.2929 c=0
Rk75 (\9\:VSS \10\:VSS) resistor r=0.4324 c=0
Rk80 (\5\:VSS \15\:VSS) resistor r=0.199 c=0
Rk81 (\7\:VSS \17\:VSS) resistor r=0.2814 c=0
Rk82 (\9\:VSS \19\:VSS) resistor r=0.04329 c=0
Rk14 (\11\:RN RN) resistor r=1.5556 c=0
Rk43 (SE \7\:SE) resistor r=0.004839 c=0
Rk44 (\7\:SE \8\:SE) resistor r=0.5605 c=0
Rk48 (\2\:VDD \4\:VDD) resistor r=0.3378 c=0
Rk49 (\4\:VDD \5\:VDD) resistor r=0.3408 c=0
Rk50 (\5\:VDD \7\:VDD) resistor r=0.308 c=0
Rk51 (\5\:VDD \8\:VDD) resistor r=0.5112 c=0
Rk52 (\8\:VDD \9\:VDD) resistor r=0.1568 c=0
Rk53 (\9\:VDD \11\:VDD) resistor r=0.04329 c=0
Rk54 (\9\:VDD \12\:VDD) resistor r=0.3437 c=0
Rk55 (\12\:VDD \14\:VDD) resistor r=0.04329 c=0
Rk56 (\12\:VDD \15\:VDD) resistor r=0.3473 c=0
Rk68 (\16\:VDD VDD) resistor r=0.2007 c=0
Rk57 (\15\:VDD \16\:VDD) resistor r=0.3257 c=0
Rk61 (\16\:VDD \22\:VDD) resistor r=0.07369 c=0
Rk1 (CK \4\:CK) resistor r=0.08996 c=0
Rk42 (\4\:SI SI) resistor r=0.003618 c=0
Rk32 (\10\:CKb \11\:CKb) resistor r=0.7047 c=0
Rk33 (\11\:CKb \12\:CKb) resistor r=1.2182 c=0
Rk34 (\12\:CKb \14\:CKb) resistor r=2.0634 c=0
Rk35 (\14\:CKb \16\:CKb) resistor r=0.6752 c=0
Rk6 (\19\:qbint \20\:qbint) resistor r=0.3218 c=0
Rk8 (\20\:qbint \24\:qbint) resistor r=0.3459 c=0
Rk10 (\20\:qbint \27\:qbint) resistor r=0.3813 c=0
Rk11 (\8\:n30 \9\:n30) resistor r=0.3531 c=0
Rk12 (\9\:n30 \10\:n30) resistor r=0.7375 c=0
Rk13 (\9\:n30 \12\:n30) resistor r=0.4576 c=0
Rk18 (\4\:mout \6\:mout) resistor r=0.8868 c=0
Rk19 (\6\:mout \8\:mout) resistor r=0.3841 c=0
Rk24 (\10\:CKbb \11\:CKbb) resistor r=0.3139 c=0
Rk25 (\11\:CKbb \12\:CKbb) resistor r=0.2854 c=0
Rk26 (\12\:CKbb \13\:CKbb) resistor r=1.5948 c=0
Rk27 (\13\:CKbb \14\:CKbb) resistor r=0.1614 c=0
Rk28 (\11\:CKbb \15\:CKbb) resistor r=0.2688 c=0
Rk29 (\15\:CKbb \17\:CKbb) resistor r=0.2917 c=0
Rk30 (\12\:CKbb \18\:CKbb) resistor r=0.457 c=0
Rk31 (\13\:CKbb \19\:CKbb) resistor r=0.1053 c=0
Rk21 (\6\:n20 \7\:n20) resistor r=0.5272 c=0
Rk22 (\7\:n20 \8\:n20) resistor r=0.6739 c=0
Rk23 (\7\:n20 \10\:n20) resistor r=0.05443 c=0
Rk37 (\2\:Db \3\:Db) resistor r=0.6307 c=0
Rk38 (\3\:Db \4\:Db) resistor r=0.3363 c=0
Rk39 (\4\:Db \6\:Db) resistor r=0.6008 c=0
Rk40 (\3\:Db \8\:Db) resistor r=0.07452 c=0
Rk41 (\4\:Db \10\:Db) resistor r=0.5425 c=0
Rk45 (\6\:SEb \8\:SEb) resistor r=0.5319 c=0
Rk46 (\8\:SEb \9\:SEb) resistor r=0.631 c=0
Rk47 (\9\:SEb \10\:SEb) resistor r=0.3029 c=0
Rk20 (\2\:net349 \4\:net349) resistor r=0.2505 c=0
Rl46 (\1\:D \2\:D) resistor r=98.3343 c=0
Rl47 (\2\:D \3\:D) resistor r=44.9225 c=0
Rl26 (RN \7\:RN) resistor r=34.3295 c=0
Rl17 (RN \1\:RN) resistor r=24.7951 c=0
Rl36 (\9\:RN \8\:RN) resistor r=29.5379 c=0
Rl37 (\9\:RN \10\:RN) resistor r=77.6149 c=0
Rl54 (\4\:SE \5\:SE) resistor r=100.692 c=0
Rl55 (\5\:SE \6\:SE) resistor r=33.3841 c=0
Rl50 (\2\:SE \3\:SE) resistor r=133.735 c=0
Rl49 (\1\:SE \2\:SE) resistor r=24.2328 c=0
Rl2 (\2\:CK \3\:CK) resistor r=76.7181 c=0
Rl1 (\1\:CK \2\:CK) resistor r=111.516 c=0
Rl52 (\1\:SI \2\:SI) resistor r=24.2328 c=0
Rl53 (\2\:SI \3\:SI) resistor r=106.925 c=0
Rl30 (CKb \2\:CKb) resistor r=133.771 c=0
Rl45 (\7\:CKb \9\:CKb) resistor r=205.769 c=0
Rl42 (\4\:CKb \6\:CKb) resistor r=134.615 c=0
Rl44 (\7\:CKb \8\:CKb) resistor r=37.2302 c=0
Rl41 (\4\:CKb \5\:CKb) resistor r=61.0515 c=0
Rl31 (\2\:CKb \3\:CKb) resistor r=30.0021 c=0
Rl27 (\17\:qbint \16\:qbint) resistor r=24.2328 c=0
Rl28 (\17\:qbint \18\:qbint) resistor r=80.0021 c=0
Rl22 (n30 \5\:n30) resistor r=64.5595 c=0
Rl21 (n30 \4\:n30) resistor r=64.6181 c=0
Rl38 (mout \2\:mout) resistor r=24.2328 c=0
Rl39 (\2\:mout \3\:mout) resistor r=80.0021 c=0
Rl29 (CKbb \2\:CKbb) resistor r=30.3481 c=0
Rl43 (\7\:CKbb \8\:CKbb) resistor r=35.3072 c=0
Rl40 (\5\:CKbb \6\:CKbb) resistor r=70.3867 c=0
Rl32 (\3\:CKbb \4\:CKbb) resistor r=37.6944 c=0
Rl33 (n20 \2\:n20) resistor r=2.7713 c=0
Rl35 (\2\:n20 \4\:n20) resistor r=90.0987 c=0
Rl34 (\2\:n20 \3\:n20) resistor r=34.3295 c=0
Rl51 (\3\:SEb \4\:SEb) resistor r=24.2328 c=0
Rl48 (SEb \2\:SEb) resistor r=54.5379 c=0
Rz18 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz19 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz20 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz21 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz12 (\4\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz13 (\8\:VDD \3\:VDD) resistor r=7.5 c=0
Rz14 (\15\:VDD \3\:VDD) resistor r=10.7143 c=0
Rz16 (\16\:VDD \3\:VDD) resistor r=6.25 c=0
Rz8 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz3 (\24\:qbint \23\:qbint) resistor r=75 c=0
Rz4 (\8\:n30 \7\:n30) resistor r=75 c=0
Rz5 (\7\:mout \8\:mout) resistor r=75 c=0
Rz7 (\16\:CKbb \17\:CKbb) resistor r=75 c=0
Rz6 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz9 (\5\:Db \6\:Db) resistor r=75 c=0
Rz10 (\9\:Db \10\:Db) resistor r=75 c=0
Rz11 (\5\:SEb \6\:SEb) resistor r=75 c=0
Ry24 (\4\:VSS \3\:VSS) resistor r=8.8571 c=0
Ry25 (\6\:VSS \3\:VSS) resistor r=6.2 c=0
Ry26 (\8\:VSS \3\:VSS) resistor r=5.6364 c=0
Ry27 (\10\:VSS \3\:VSS) resistor r=7.75 c=0
Ry15 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry16 (\7\:VDD \6\:VDD) resistor r=62 c=0
Ry17 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry18 (\14\:VDD \13\:VDD) resistor r=62 c=0
Ry20 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry11 (\13\:CKb \14\:CKb) resistor r=62 c=0
Ry5 (\12\:n30 \11\:n30) resistor r=62 c=0
Ry6 (\5\:mout \6\:mout) resistor r=62 c=0
Ry10 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry9 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry12 (Db \2\:Db) resistor r=20.6667 c=0
Ry13 (\7\:Db \8\:Db) resistor r=62 c=0
Ry14 (\7\:SEb \8\:SEb) resistor r=62 c=0
Ry7 (net349 \2\:net349) resistor r=62 c=0
Ry8 (\3\:net349 \4\:net349) resistor r=62 c=0
Rx17 (\2\:D \4\:D) resistor r=45 c=0
Rx5 (\11\:RN \9\:RN) resistor r=45 c=0
Rx19 (\5\:SE \7\:SE) resistor r=45 c=0
Rx20 (\2\:SE \8\:SE) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx18 (\2\:SI \4\:SI) resistor r=45 c=0
Rx14 (\8\:CKb \10\:CKb) resistor r=45 c=0
Rx15 (\5\:CKb \11\:CKb) resistor r=45 c=0
Rx16 (\3\:CKb \12\:CKb) resistor r=45 c=0
Rx2 (\19\:qbint qbint) resistor r=45 c=0
Rx3 (\27\:qbint \17\:qbint) resistor r=45 c=0
Rx4 (\10\:n30 n30) resistor r=45 c=0
Rx8 (\2\:mout \4\:mout) resistor r=45 c=0
Rx10 (CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\8\:CKbb \15\:CKbb) resistor r=45 c=0
Rx12 (\6\:CKbb \18\:CKbb) resistor r=45 c=0
Rx13 (\4\:CKbb \19\:CKbb) resistor r=45 c=0
Rx9 (n20 \8\:n20) resistor r=45 c=0
Rx21 (\4\:SEb \9\:SEb) resistor r=45 c=0
Rx22 (\2\:SEb \10\:SEb) resistor r=45 c=0
mn20 (\15\:CKb \1\:CK \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.96e-14 ad=2.03e-14 ps=1.12e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.67379e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn55 (Q qbint \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.528e-14 ad=5.2e-14 ps=9.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.32404e-07 sb=1.7451e-06 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(4)
mn45_1__rcx (21 \1\:RN \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.83e-14 ad=2.357e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19146e-06 sb=2e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn46_1__rcx (\23\:qbint \4\:n30 21 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.358e-14 ad=4.1e-14 ps=6.4e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35146e-06 sb=2e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn46 (\23\:qbint \5\:n30 22 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.69e-14 ad=4.1e-14 ps=7.7e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59646e-06 sb=2e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn45 (22 \7\:RN \18\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.93e-14 ad=3.69e-14 ps=1.53e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.81488e-06 sb=2e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn50 (net405 \18\:qbint \18\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=8.93e-14 ad=7.892e-14 ps=1.53e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.98598e-06 sb=2e-06 sd=160n sca=12.4149 \
        scb=0.012446 scc=0.000614222 m=(1)
mn51 (\7\:n30 CKb net405 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.892e-14 ad=3.28e-14 ps=1.18e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.865e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn35 (net426 \10\:RN \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=7.79e-14 ps=8.5e-07 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=9.9e-07 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn40 (\7\:n30 \3\:CKbb \7\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.38e-14 ad=3.28e-14 ps=1.13e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.66e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn30 (\7\:mout \3\:n20 \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.51e-14 ad=7.38e-14 ps=8.5e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.255e-06 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn36 (net422 \3\:mout net426 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.79e-14 ad=3.588e-14 ps=1.17e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.65e-07 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn37 (\9\:n20 \5\:CKbb net422 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.588e-14 ad=3.28e-14 ps=7.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn25 (\9\:n20 \6\:CKb \5\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=3.28e-14 ps=6.9e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=12.4149 scb=0.012446 \
        scc=0.000614222 m=(1)
mn21 (\16\:CKbb \9\:CKb \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=6.453e-14 ps=9e-07 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.45e-07 sb=1.405e-06 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn11 (net450 \3\:D \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=1.56e-14 ps=9e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.41154e-07 sb=9.57692e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn12 (\9\:Db SEb net450 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.46154e-07 sb=8.52692e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn14 (\9\:Db \1\:SE net442 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=4.16e-14 ps=9.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.51154e-07 sb=6.47692e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn13 (net442 \3\:SI \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=5.07e-14 ps=1.28e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.91154e-07 sb=4.07692e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn10 (\5\:SEb \6\:SE \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.12e-14 ad=2.827e-14 ps=1.28e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=1.95e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mp55_1__rcx (Q qbint \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1158e-13 ad=7.215e-14 ps=1.7225e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.12308e-07 sb=1.77333e-06 sd=160n sca=23.2892 \
        scb=0.0184233 scc=0.00227283 m=(4)
mp45_1__rcx (\16\:VDD RN \20\:qbint VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.96e-14 ad=1.181e-13 ps=9.4e-07 pd=1.795e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.23839e-06 sb=2e-06 sd=160n sca=25.4421 \
        scb=0.0206785 scc=0.00284317 m=(2)
mp46 (\20\:qbint n30 \21\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.15e-13 ad=4.96e-14 ps=1.84e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.44339e-06 sb=2e-06 sd=160n sca=25.4421 \
        scb=0.0206785 scc=0.00284317 m=(2)
mp50 (net326 \16\:qbint \16\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.274e-13 ad=6.665e-14 ps=1.92e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.83e-06 sd=160n sca=25.4421 scb=0.0206785 \
        scc=0.00284317 m=(1)
mp51 (\11\:n30 \2\:CKbb net326 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.665e-14 ad=4.96e-14 ps=1.05e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.57e-06 sd=160n sca=25.4421 scb=0.0206785 \
        scc=0.00284317 m=(1)
mp40 (\11\:n30 \2\:CKb \5\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.643e-13 ad=4.96e-14 ps=1.68e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.365e-06 sd=160n sca=25.4421 \
        scb=0.0206785 scc=0.00284317 m=(1)
mp30 (\5\:mout \4\:n20 \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.15e-13 ad=1.643e-13 ps=1.84e-06 pd=1.68e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.9e-07 sd=160n sca=25.4421 scb=0.0206785 \
        scc=0.00284317 m=(1)
mp35 (\3\:net349 \8\:RN \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.15e-13 ad=1.178e-13 ps=1.84e-06 pd=1.38e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.25e-07 sd=160n sca=25.4421 scb=0.0206785 \
        scc=0.00284317 m=(1)
mp36 (\3\:net349 mout \10\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.89e-14 ad=1.178e-13 ps=1.74e-06 pd=1.38e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1e-07 sd=160n sca=25.4421 scb=0.0206785 \
        scc=0.00284317 m=(1)
mp37 (\5\:n20 \4\:CKb net349 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.58e-14 ad=1.116e-13 ps=9e-07 pd=1.34e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.15484e-07 sb=5.4371e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp25 (\5\:n20 \7\:CKbb \7\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=1.116e-13 ps=1.02e-06 pd=1.34e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.20484e-07 sb=1.3871e-07 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp21 (\9\:CKbb \7\:CKb \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.34e-14 ad=2.73e-14 ps=1.3e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26977e-07 sb=1.11279e-06 sd=160n sca=12.9303 \
        scb=0.0120133 scc=0.000461649 m=(1)
mp11 (net381 \1\:D \6\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.34e-14 ad=2.34e-14 ps=1.3e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.83013e-07 sb=8.54295e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp12 (Db \3\:SE net381 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.88013e-07 sb=7.49295e-07 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(1)
mp13 (net373 \1\:SI \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.062e-13 ad=4.875e-14 ps=1.54e-06 pd=1.03e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.63013e-07 sb=3.74295e-07 sd=160n sca=19.5664 \
        scb=0.0165531 scc=0.00171569 m=(1)
mp14 (Db \3\:SEb net373 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.875e-14 ad=6.24e-14 ps=1.03e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.93013e-07 sb=5.44295e-07 sd=160n sca=19.095 \
        scb=0.0163725 scc=0.00171562 m=(1)
mp10 (\7\:SEb \4\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.062e-13 ad=3.01e-14 ps=1.54e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.14442e-06 sb=1.4e-07 sd=160n sca=31.4748 \
        scb=0.0307939 scc=0.00317368 m=(1)
ends SDFFRHQX4
// End of subcircuit definition.

// Generated for: spectre (May  9 17:32:36 2012 )
// Library name: gsclib045
// Cell name: SDFFRHQX8
// View name: extracted

simulator lang=spectre

subckt SDFFRHQX8 CK D Q RN SE SI VDD VSS
mp55_1__rcx (Q qbint \18\:VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=7.374e-14 ps=1.21e-06 pd=1.22143e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.9209e-06 sd=160n sca=32.089 \
        scb=0.0262252 scc=0.00294457 m=(7)
C1 (D VSS) capacitor c=4.54615e-17
C2 (Q VSS) capacitor c=4.93586e-16
C3 (RN VSS) capacitor c=4.42126e-16
C4 (SE VSS) capacitor c=3.12161e-17
C5 (VDD VSS) capacitor c=3.85401e-16
C6 (CK VSS) capacitor c=7.21325e-17
C7 (SI VSS) capacitor c=9.6661e-17
C8 (qbint VSS) capacitor c=3.9064e-16
C9 (21 VSS) capacitor c=2.98312e-18
C10 (n30 VSS) capacitor c=4.97107e-16
C11 (22 VSS) capacitor c=2.09613e-18
C12 (23 VSS) capacitor c=3.531e-18
C13 (CKb VSS) capacitor c=4.58289e-17
C14 (net405 VSS) capacitor c=2.24031e-18
C15 (mout VSS) capacitor c=4.62557e-17
C16 (CKbb VSS) capacitor c=2.16921e-17
C17 (n20 VSS) capacitor c=4.03791e-17
C18 (net426 VSS) capacitor c=4.88418e-18
C19 (net422 VSS) capacitor c=3.3758e-18
C20 (Db VSS) capacitor c=8.80971e-17
C21 (net450 VSS) capacitor c=8.07784e-18
C22 (SEb VSS) capacitor c=4.57475e-17
C23 (net326 VSS) capacitor c=3.00682e-18
C24 (net349 VSS) capacitor c=7.65595e-17
C25 (net381 VSS) capacitor c=3.34044e-18
C26 (net373 VSS) capacitor c=4.08851e-18
C27 (\7\:SE VSS) capacitor c=4.40587e-17
C28 (\3\:SI VSS) capacitor c=5.65134e-17
C29 (\2\:SE VSS) capacitor c=5.41785e-17
C30 (\1\:D VSS) capacitor c=7.76975e-17
C31 (\8\:CKb VSS) capacitor c=3.68773e-17
C32 (\7\:CKbb VSS) capacitor c=5.04911e-17
C33 (\5\:CKb VSS) capacitor c=4.20219e-17
C34 (\12\:RN VSS) capacitor c=6.82715e-17
C35 (\3\:n20 VSS) capacitor c=4.45557e-17
C36 (\3\:CKb VSS) capacitor c=3.47002e-17
C37 (\3\:CKbb VSS) capacitor c=6.6412e-17
C38 (\28\:qbint VSS) capacitor c=5.15306e-17
C39 (\1\:CK VSS) capacitor c=4.26661e-17
C40 (\5\:SE VSS) capacitor c=3.3226e-17
C41 (\1\:SI VSS) capacitor c=8.57877e-17
C42 (\3\:SE VSS) capacitor c=6.9663e-17
C43 (\3\:SEb VSS) capacitor c=5.98381e-17
C44 (\4\:D VSS) capacitor c=3.41877e-17
C45 (\10\:CKb VSS) capacitor c=4.6151e-17
C46 (\7\:CKb VSS) capacitor c=4.23764e-17
C47 (\4\:CKbb VSS) capacitor c=4.13568e-17
C48 (\3\:mout VSS) capacitor c=4.17203e-17
C49 (\11\:RN VSS) capacitor c=7.11385e-17
C50 (\30\:qbint VSS) capacitor c=6.05624e-17
C51 (\3\:CK VSS) capacitor c=3.63873e-17
C52 (\10\:n30 VSS) capacitor c=3.94081e-17
C53 (\4\:RN VSS) capacitor c=3.4848e-17
C54 (\7\:RN VSS) capacitor c=1.92792e-17
C55 (\6\:n30 VSS) capacitor c=2.23046e-17
C56 (\5\:n30 VSS) capacitor c=3.23167e-17
C57 (\1\:RN VSS) capacitor c=4.92829e-17
C58 (\6\:SE VSS) capacitor c=3.85395e-17
C59 (\2\:SI VSS) capacitor c=5.9974e-17
C60 (\4\:SE VSS) capacitor c=4.54904e-17
C61 (\1\:SE VSS) capacitor c=4.07922e-17
C62 (\3\:D VSS) capacitor c=2.05344e-17
C63 (\9\:CKb VSS) capacitor c=2.49447e-17
C64 (\6\:CKbb VSS) capacitor c=3.3942e-17
C65 (\6\:CKb VSS) capacitor c=2.05403e-17
C66 (\5\:CKbb VSS) capacitor c=3.87205e-17
C67 (\2\:mout VSS) capacitor c=4.34224e-17
C68 (\2\:n20 VSS) capacitor c=3.70814e-17
C69 (\13\:RN VSS) capacitor c=3.48257e-17
C70 (\2\:CKbb VSS) capacitor c=5.81842e-17
C71 (\4\:CKb VSS) capacitor c=3.78377e-17
C72 (\2\:CKb VSS) capacitor c=3.96691e-17
C73 (\29\:qbint VSS) capacitor c=4.21705e-17
C74 (\2\:CK VSS) capacitor c=3.24749e-17
C75 (\9\:RN VSS) capacitor c=1.93488e-17
C76 (\7\:SEb VSS) capacitor c=9.91084e-17
C77 (\1\:VDD VSS) capacitor c=2.95967e-17
C78 (\4\:Db VSS) capacitor c=5.24751e-17
C79 (\8\:VDD VSS) capacitor c=1.16647e-17
C80 (\8\:CKbb VSS) capacitor c=7.14249e-17
C81 (\6\:Db VSS) capacitor c=1.52812e-16
C82 (\4\:n20 VSS) capacitor c=6.99714e-17
C83 (\10\:VDD VSS) capacitor c=2.04806e-17
C84 (\3\:net349 VSS) capacitor c=7.53979e-17
C85 (\12\:VDD VSS) capacitor c=7.13571e-17
C86 (\7\:mout VSS) capacitor c=6.18038e-17
C87 (\11\:n30 VSS) capacitor c=1.02578e-16
C88 (\15\:VDD VSS) capacitor c=2.39457e-17
C89 (\18\:CKb VSS) capacitor c=1.0245e-16
C90 (\33\:qbint VSS) capacitor c=2.40091e-16
C91 (\3\:VDD VSS) capacitor c=1.29369e-16
C92 (\5\:SEb VSS) capacitor c=6.1187e-17
C93 (\14\:CKbb VSS) capacitor c=9.56242e-18
C94 (\8\:Db VSS) capacitor c=1.06483e-16
C95 (\8\:n20 VSS) capacitor c=7.12833e-17
C96 (\4\:mout VSS) capacitor c=4.18712e-17
C97 (\13\:n30 VSS) capacitor c=2.40824e-16
C98 (\15\:CKb VSS) capacitor c=1.32062e-16
C99 (\39\:qbint VSS) capacitor c=7.16765e-17
C100 (\43\:qbint VSS) capacitor c=7.34659e-17
C101 (\2\:D VSS) capacitor c=2.14615e-17
C102 (\2\:SEb VSS) capacitor c=5.50861e-17
C103 (\4\:CK VSS) capacitor c=4.52264e-17
C104 (\31\:qbint VSS) capacitor c=1.39026e-16
C105 (\32\:qbint VSS) capacitor c=1.40378e-16
C106 (\45\:qbint VSS) capacitor c=4.30712e-17
C107 (\16\:RN VSS) capacitor c=1.64596e-16
C108 (\17\:RN VSS) capacitor c=1.59912e-16
C109 (\6\:mout VSS) capacitor c=1.09755e-16
C110 (\9\:mout VSS) capacitor c=1.02275e-16
C111 (\6\:n20 VSS) capacitor c=1.11416e-16
C112 (\7\:n20 VSS) capacitor c=1.1459e-16
C113 (\10\:CKbb VSS) capacitor c=4.67394e-17
C114 (\11\:CKbb VSS) capacitor c=8.97553e-17
C115 (\12\:CKbb VSS) capacitor c=2.1587e-16
C116 (\13\:CKbb VSS) capacitor c=1.49263e-16
C117 (\16\:CKbb VSS) capacitor c=4.45202e-17
C118 (\11\:CKb VSS) capacitor c=7.56999e-17
C119 (\12\:CKb VSS) capacitor c=2.14396e-16
C120 (\13\:CKb VSS) capacitor c=2.39874e-16
C121 (\14\:CKb VSS) capacitor c=1.63397e-16
C122 (\17\:CKb VSS) capacitor c=6.8463e-17
C123 (\5\:D VSS) capacitor c=6.93502e-17
C124 (\3\:Db VSS) capacitor c=1.44313e-16
C125 (\8\:SE VSS) capacitor c=7.16897e-17
C126 (\9\:SE VSS) capacitor c=5.98324e-17
C127 (\10\:SE VSS) capacitor c=4.85066e-17
C128 (\4\:SI VSS) capacitor c=4.28512e-17
C129 (\9\:SEb VSS) capacitor c=7.6632e-17
C130 (\5\:VDD VSS) capacitor c=3.3756e-17
C131 (\6\:VDD VSS) capacitor c=3.65748e-17
C132 (\14\:VDD VSS) capacitor c=3.58205e-17
C133 (\18\:VDD VSS) capacitor c=5.2354e-16
Rk51 (\5\:D D) resistor r=0.1126 c=0
Rk31 (\16\:RN \17\:RN) resistor r=1.2883 c=0
Rk57 (\8\:SE \9\:SE) resistor r=0.3402 c=0
Rk59 (\10\:SE SE) resistor r=0.05396 c=0
Rk58 (\9\:SE \10\:SE) resistor r=0.2318 c=0
Rk86 (\2\:VDD \4\:VDD) resistor r=0.4328 c=0
Rk87 (\4\:VDD \5\:VDD) resistor r=0.2196 c=0
Rk88 (\5\:VDD \6\:VDD) resistor r=0.5797 c=0
Rk89 (\6\:VDD \7\:VDD) resistor r=0.2497 c=0
Rk90 (\5\:VDD \9\:VDD) resistor r=0.04333 c=0
Rk91 (\6\:VDD \11\:VDD) resistor r=0.04333 c=0
Rk92 (\7\:VDD \13\:VDD) resistor r=0.3934 c=0
Rk93 (\7\:VDD \14\:VDD) resistor r=0.6041 c=0
Rk94 (\14\:VDD \16\:VDD) resistor r=0.04333 c=0
Rk95 (\14\:VDD \17\:VDD) resistor r=0.09669 c=0
Rk96 (\17\:VDD \18\:VDD) resistor r=0.1895 c=0
Rk113 (\41\:VDD VDD) resistor r=0.04992 c=0
Rk112 (\18\:VDD \41\:VDD) resistor r=0.1152 c=0
Rk17 (\4\:CK CK) resistor r=0.1298 c=0
Rk60 (\4\:SI SI) resistor r=0.06227 c=0
Rk63 (\2\:VSS \3\:VSS) resistor r=0.1353 c=0
Rk64 (\3\:VSS \4\:VSS) resistor r=0.4211 c=0
Rk65 (\4\:VSS \5\:VSS) resistor r=0.1453 c=0
Rk66 (\5\:VSS \6\:VSS) resistor r=0.6696 c=0
Rk67 (\6\:VSS \7\:VSS) resistor r=0.5342 c=0
Rk68 (\7\:VSS \8\:VSS) resistor r=0.05906 c=0
Rk69 (\8\:VSS \9\:VSS) resistor r=0.5506 c=0
Rk70 (\9\:VSS \10\:VSS) resistor r=0.03994 c=0
Rk76 (\11\:VSS VSS) resistor r=0.2078 c=0
Rk71 (\10\:VSS \11\:VSS) resistor r=0.3786 c=0
Rk77 (\3\:VSS \17\:VSS) resistor r=0.292 c=0
Rk78 (\4\:VSS \19\:VSS) resistor r=0.2317 c=0
Rk79 (\6\:VSS \21\:VSS) resistor r=0.18 c=0
Rk80 (\8\:VSS \23\:VSS) resistor r=0.04333 c=0
Rk81 (\9\:VSS \25\:VSS) resistor r=0.2841 c=0
Rk19 (\32\:qbint \33\:qbint) resistor r=0.1506 c=0
Rk18 (\31\:qbint \32\:qbint) resistor r=0.9963 c=0
Rk23 (\32\:qbint \40\:qbint) resistor r=0.4295 c=0
Rk25 (\33\:qbint \44\:qbint) resistor r=0.3434 c=0
Rk26 (\33\:qbint \45\:qbint) resistor r=0.3623 c=0
Rk28 (\14\:n30 n30) resistor r=1.3505 c=0
Rk27 (\12\:n30 \14\:n30) resistor r=0.4947 c=0
Rk45 (\11\:CKb \12\:CKb) resistor r=0.4769 c=0
Rk46 (\12\:CKb \13\:CKb) resistor r=1.4046 c=0
Rk47 (\13\:CKb \14\:CKb) resistor r=0.6599 c=0
Rk48 (\14\:CKb \16\:CKb) resistor r=0.6379 c=0
Rk49 (\13\:CKb \17\:CKb) resistor r=0.2643 c=0
Rk50 (\16\:CKb \19\:CKb) resistor r=0.5821 c=0
Rk32 (\5\:mout \6\:mout) resistor r=0.1059 c=0
Rk33 (\6\:mout \8\:mout) resistor r=0.3215 c=0
Rk34 (\6\:mout \9\:mout) resistor r=0.5477 c=0
Rk39 (\9\:CKbb \10\:CKbb) resistor r=0.3455 c=0
Rk40 (\10\:CKbb \11\:CKbb) resistor r=0.1402 c=0
Rk41 (\11\:CKbb \12\:CKbb) resistor r=0.7931 c=0
Rk42 (\12\:CKbb \13\:CKbb) resistor r=1.1085 c=0
Rk43 (\10\:CKbb \15\:CKbb) resistor r=0.1152 c=0
Rk44 (\12\:CKbb \16\:CKbb) resistor r=0.1529 c=0
Rk36 (\5\:n20 \6\:n20) resistor r=0.3056 c=0
Rk37 (\6\:n20 \7\:n20) resistor r=0.712 c=0
Rk38 (\6\:n20 \9\:n20) resistor r=0.3051 c=0
Rk52 (\2\:Db \3\:Db) resistor r=0.6178 c=0
Rk53 (\3\:Db \5\:Db) resistor r=0.149 c=0
Rk54 (\3\:Db \7\:Db) resistor r=0.6938 c=0
Rk55 (\7\:Db \9\:Db) resistor r=0.6083 c=0
Rk56 (\5\:Db \10\:Db) resistor r=0.1474 c=0
Rk61 (\6\:SEb \8\:SEb) resistor r=0.6167 c=0
Rk62 (\8\:SEb \9\:SEb) resistor r=0.4689 c=0
Rk35 (\2\:net349 \4\:net349) resistor r=0.2887 c=0
Rl63 (\1\:D \2\:D) resistor r=102.726 c=0
Rl65 (\2\:D \4\:D) resistor r=37.3411 c=0
Rl64 (\2\:D \3\:D) resistor r=6.9867 c=0
Rl53 (\11\:RN \12\:RN) resistor r=182.258 c=0
Rl35 (RN \4\:RN) resistor r=28.0797 c=0
Rl37 (RN \7\:RN) resistor r=24.2328 c=0
Rl27 (RN \1\:RN) resistor r=24.5316 c=0
Rl54 (\13\:RN \12\:RN) resistor r=189.898 c=0
Rl39 (\9\:RN RN) resistor r=24.2328 c=0
Rl74 (\6\:SE \7\:SE) resistor r=95.3297 c=0
Rl73 (\5\:SE \6\:SE) resistor r=40.3846 c=0
Rl70 (\3\:SE \4\:SE) resistor r=24.2328 c=0
Rl66 (\1\:SE \2\:SE) resistor r=33.8727 c=0
Rl43 (\1\:CK \2\:CK) resistor r=90.3846 c=0
Rl44 (\2\:CK \3\:CK) resistor r=39.5604 c=0
Rl72 (\2\:SI \3\:SI) resistor r=30.0268 c=0
Rl71 (\1\:SI \2\:SI) resistor r=91.6329 c=0
Rl45 (\29\:qbint \28\:qbint) resistor r=39.1533 c=0
Rl46 (\29\:qbint \30\:qbint) resistor r=89.1533 c=0
Rl42 (n30 \10\:n30) resistor r=26.3736 c=0
Rl33 (n30 \6\:n30) resistor r=28.0797 c=0
Rl32 (n30 \5\:n30) resistor r=28.0797 c=0
Rl62 (\8\:CKb \10\:CKb) resistor r=150 c=0
Rl59 (\5\:CKb \7\:CKb) resistor r=142.308 c=0
Rl61 (\8\:CKb \9\:CKb) resistor r=54.5379 c=0
Rl58 (\5\:CKb \6\:CKb) resistor r=37.2302 c=0
Rl48 (\3\:CKb \4\:CKb) resistor r=29.5379 c=0
Rl47 (CKb \2\:CKb) resistor r=33.3841 c=0
Rl55 (mout \2\:mout) resistor r=98.7687 c=0
Rl56 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl60 (\6\:CKbb \7\:CKbb) resistor r=89.6769 c=0
Rl57 (\4\:CKbb \5\:CKbb) resistor r=28.079 c=0
Rl49 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl50 (\2\:CKbb \3\:CKbb) resistor r=174.12 c=0
Rl51 (n20 \2\:n20) resistor r=84.4104 c=0
Rl52 (\2\:n20 \3\:n20) resistor r=35.7065 c=0
Rl67 (SEb \2\:SEb) resistor r=67.4757 c=0
Rl68 (\2\:SEb \3\:SEb) resistor r=138.049 c=0
Rl69 (\2\:SEb \4\:SEb) resistor r=1.2666 c=0
Rz24 (\4\:VDD \3\:VDD) resistor r=8.3333 c=0
Rz25 (\7\:VDD \3\:VDD) resistor r=6.25 c=0
Rz26 (\17\:VDD \3\:VDD) resistor r=37.5 c=0
Rz28 (\18\:VDD \3\:VDD) resistor r=5.3571 c=0
Rz29 (\41\:VDD \3\:VDD) resistor r=37.5 c=0
Rz15 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz16 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz17 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz18 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz19 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz5 (\40\:qbint \39\:qbint) resistor r=75 c=0
Rz6 (\44\:qbint \43\:qbint) resistor r=75 c=0
Rz7 (\14\:n30 \13\:n30) resistor r=75 c=0
Rz11 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz8 (\4\:mout \5\:mout) resistor r=75 c=0
Rz10 (\14\:CKbb \15\:CKbb) resistor r=75 c=0
Rz9 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz12 (Db \2\:Db) resistor r=75 c=0
Rz13 (\8\:Db \9\:Db) resistor r=75 c=0
Rz14 (\5\:SEb \6\:SEb) resistor r=75 c=0
Ry24 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry25 (\9\:VDD \8\:VDD) resistor r=62 c=0
Ry26 (\11\:VDD \10\:VDD) resistor r=62 c=0
Ry27 (\13\:VDD \12\:VDD) resistor r=62 c=0
Ry28 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry19 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry20 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry21 (\7\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry22 (\10\:VSS \1\:VSS) resistor r=62 c=0
Ry23 (\11\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry8 (\12\:n30 \11\:n30) resistor r=62 c=0
Ry14 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry9 (\7\:mout \8\:mout) resistor r=62 c=0
Ry13 (\8\:CKbb \9\:CKbb) resistor r=62 c=0
Ry12 (\4\:n20 \5\:n20) resistor r=31 c=0
Ry15 (\4\:Db \5\:Db) resistor r=62 c=0
Ry16 (\6\:Db \7\:Db) resistor r=31 c=0
Ry17 (\4\:Db \10\:Db) resistor r=62 c=0
Ry18 (\7\:SEb \8\:SEb) resistor r=62 c=0
Ry10 (net349 \2\:net349) resistor r=62 c=0
Ry11 (\3\:net349 \4\:net349) resistor r=62 c=0
Rx19 (\3\:D \5\:D) resistor r=45 c=0
Rx8 (\16\:RN \13\:RN) resistor r=45 c=0
Rx9 (\17\:RN \9\:RN) resistor r=45 c=0
Rx20 (\1\:SE \8\:SE) resistor r=45 c=0
Rx21 (\4\:SE \9\:SE) resistor r=45 c=0
Rx22 (\6\:SE \10\:SE) resistor r=45 c=0
Rx3 (\2\:CK \4\:CK) resistor r=45 c=0
Rx23 (\2\:SI \4\:SI) resistor r=45 c=0
Rx4 (\31\:qbint \29\:qbint) resistor r=45 c=0
Rx5 (\45\:qbint qbint) resistor r=45 c=0
Rx15 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx16 (\6\:CKb \12\:CKb) resistor r=45 c=0
Rx17 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx18 (\4\:CKb \17\:CKb) resistor r=45 c=0
Rx10 (\2\:mout \9\:mout) resistor r=45 c=0
Rx12 (\6\:CKbb \11\:CKbb) resistor r=45 c=0
Rx13 (\2\:CKbb \13\:CKbb) resistor r=45 c=0
Rx14 (\5\:CKbb \16\:CKbb) resistor r=45 c=0
Rx11 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx24 (\4\:SEb \9\:SEb) resistor r=45 c=0
mn55_1__rcx (Q qbint \11\:VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=4.636e-14 ps=9.1e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.92051e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn45_1__rcx (21 \1\:RN \11\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=2.73e-14 ps=9.1e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=1.12e-06 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn46_1__rcx (\43\:qbint \5\:n30 21 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=2.73e-14 ad=4.94e-14 ps=7.3e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.725e-06 sb=9.7e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn46_2__rcx (\43\:qbint \6\:n30 22 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.42e-14 ad=4.94e-14 ps=8.6e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.96e-06 sb=7.35e-07 sd=160n sca=13.9783 \
        scb=0.013979 scc=0.000942864 m=(1)
mn45_2__rcx (22 \7\:RN \24\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=4.42e-14 ps=9e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.2e-07 sd=160n sca=13.9783 scb=0.013979 \
        scc=0.000942864 m=(1)
mn45 (23 \4\:RN \24\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.94e-14 ad=2.21e-14 ps=9e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.85e-07 sd=160n sca=13.9783 scb=0.013979 \
        scc=0.000942864 m=(1)
mn46 (\39\:qbint \10\:n30 23 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=2.21e-14 ad=4.03e-14 ps=6.9e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.55e-07 sd=160n sca=13.9783 scb=0.013979 \
        scc=0.000942864 m=(1)
mn20 (\15\:CKb \3\:CK \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.33e-14 ad=4.132e-14 ps=1.37e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=2e-06 sd=160n sca=11.4452 scb=0.0112553 \
        scc=0.00042156 m=(1)
mn50 (net405 \30\:qbint \22\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=7.33e-14 ad=2.357e-14 ps=1.37e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.3878e-07 sb=1.99e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn51 (\13\:n30 CKb net405 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.357e-14 ad=4.92e-14 ps=6.4e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9878e-07 sb=1.83e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn40 (\13\:n30 CKbb \4\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.073e-14 ad=4.92e-14 ps=1.1e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.8378e-07 sb=1.545e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn30 (\4\:mout n20 \20\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.778e-14 ad=7.073e-14 ps=1.15e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.27378e-06 sb=1.155e-06 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn35 (net426 \11\:RN \20\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.778e-14 ad=3.178e-14 ps=1.15e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.59378e-06 sb=8.35e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn36 (net422 \3\:mout net426 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.178e-14 ad=2.358e-14 ps=7.2e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79378e-06 sb=6.35e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn37 (\8\:n20 \4\:CKbb net422 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.358e-14 ad=5.945e-14 ps=6.4e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9078e-06 sb=4.75e-07 sd=160n sca=10.3195 \
        scb=0.00946099 scc=0.0003152 m=(1)
mn25 (\8\:n20 \7\:CKb \8\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=5.945e-14 ps=6.9e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=10.3195 scb=0.00946099 \
        scc=0.0003152 m=(1)
mn21 (\14\:CKbb \10\:CKb \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.8e-14 ad=3.407e-14 ps=9.6e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=1.29379e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn11 (net450 \4\:D \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.8e-14 ad=7.28e-14 ps=9.6e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40769e-07 sb=9.32981e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn12 (Db \3\:SEb net450 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=7.28e-14 ad=4.16e-14 ps=1.08e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65769e-07 sb=6.07981e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (Db \3\:SE net442 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.70769e-07 sb=4.02981e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn13 (net442 \1\:SI \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.75769e-07 sb=2.97981e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn10 (\5\:SEb \5\:SE \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=3.625e-14 ps=8.4e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27793e-06 sb=2.5e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp45_1__rcx (\18\:VDD RN \33\:qbint VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.37e-14 ad=7.203e-14 ps=1.10667e-06 pd=1.17667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.605e-06 sb=1.265e-06 sd=160n \
        sca=28.7024 scb=0.0198217 scc=0.00315848 m=(3)
mp46_1__rcx (\33\:qbint n30 \18\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=8.49e-14 ad=6.37e-14 ps=1.37e-06 pd=1.10667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.81e-06 sb=1.06e-06 sd=160n \
        sca=28.7024 scb=0.0198217 scc=0.00315848 m=(3)
mp20 (\18\:CKb \1\:CK \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.195e-14 ad=3.01e-14 ps=1.98e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.735e-06 sd=160n sca=27.1298 \
        scb=0.023603 scc=0.0032399 m=(1)
mp50 (net326 \28\:qbint \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=8.195e-14 ad=4.495e-14 ps=1.98e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.77984e-07 sb=1.525e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp51 (\11\:n30 \3\:CKbb net326 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.495e-14 ad=7.595e-14 ps=9.1e-07 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.67984e-07 sb=1.335e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp40 (\11\:n30 \3\:CKb \7\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.455e-14 ad=7.595e-14 ps=1.23e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.57984e-07 sb=1.045e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp36 (\3\:net349 mout \10\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.77e-14 ad=8.525e-14 ps=1.71e-06 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.63298e-06 sb=1.7e-07 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp30 (\7\:mout \3\:n20 \12\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.96e-14 ad=9.455e-14 ps=9.4e-07 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.10798e-06 sb=6.95e-07 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp35 (\3\:net349 \12\:RN \12\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.96e-14 ad=8.525e-14 ps=9.4e-07 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.31298e-06 sb=4.9e-07 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp37 (\4\:n20 \5\:CKb net349 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=29.7112 \
        scb=0.0220652 scc=0.00347629 m=(1)
mp25 (\4\:n20 \7\:CKbb \6\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=29.7112 \
        scb=0.0220652 scc=0.00347629 m=(1)
mp21 (\8\:CKbb \8\:CKb \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.695e-14 ad=3.01e-14 ps=1.91e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.19e-06 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp11 (net381 \1\:D \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.695e-14 ad=3.9e-14 ps=1.91e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.68141e-07 sb=8.19551e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp12 (\4\:Db \2\:SE net381 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=7.02e-14 ps=9.8e-07 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.13141e-07 sb=6.74551e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(1)
mp14 (\4\:Db SEb net373 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.265e-14 ad=7.02e-14 ps=1.05e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.38141e-07 sb=4.49551e-07 sd=160n sca=17.5238 \
        scb=0.0153466 scc=0.00137894 m=(1)
mp13 (net373 \3\:SI \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.265e-14 ps=1.16e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.18141e-07 sb=2.69551e-07 sd=160n sca=18.2259 \
        scb=0.0157849 scc=0.00137936 m=(1)
mp10 (\7\:SEb \7\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.19e-06 sb=1.4e-07 sd=160n sca=26.1974 \
        scb=0.0252592 scc=0.00245634 m=(1)
ends SDFFRHQX8
// End of subcircuit definition.

// Generated for: spectre (May  9 17:33:14 2012 )
// Library name: gsclib045
// Cell name: SDFFRX1
// View name: extracted

simulator lang=spectre

subckt SDFFRX1 CK D Q QN RN SE SI VDD VSS
mp57 (\1\:QN \4\:qint \28\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.142e-14 ad=5.46e-14 ps=1.52e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.49744e-07 sd=160n sca=35.1619 \
        scb=0.02637 scc=0.00345369 m=(1)
C1 (QN VSS) capacitor c=2.14019e-17
C2 (RN VSS) capacitor c=8.80956e-17
C3 (SE VSS) capacitor c=4.2503e-17
C4 (CK VSS) capacitor c=6.84585e-17
C5 (SI VSS) capacitor c=7.82307e-17
C6 (VDD VSS) capacitor c=3.66802e-16
C7 (D VSS) capacitor c=5.71726e-17
C8 (qint VSS) capacitor c=2.13982e-17
C9 (qbint VSS) capacitor c=4.03554e-17
C10 (CKb VSS) capacitor c=4.46733e-17
C11 (n9 VSS) capacitor c=2.50111e-18
C12 (n30 VSS) capacitor c=2.03892e-17
C13 (n11 VSS) capacitor c=4.35612e-18
C14 (mout VSS) capacitor c=5.69845e-17
C15 (Ckbb VSS) capacitor c=2.28658e-17
C16 (n20 VSS) capacitor c=3.8795e-17
C17 (n7 VSS) capacitor c=7.275e-19
C18 (Db VSS) capacitor c=1.01776e-16
C19 (n1 VSS) capacitor c=8.34339e-18
C20 (SEb VSS) capacitor c=3.74809e-17
C21 (n8 VSS) capacitor c=3.12581e-18
C22 (n6 VSS) capacitor c=6.32659e-17
C23 (n2 VSS) capacitor c=7.58328e-18
C24 (\5\:SE VSS) capacitor c=3.41269e-17
C25 (\1\:SI VSS) capacitor c=4.13886e-17
C26 (\1\:SE VSS) capacitor c=3.90306e-17
C27 (\1\:D VSS) capacitor c=5.98202e-17
C28 (\9\:CKb VSS) capacitor c=5.3675e-17
C29 (\7\:Ckbb VSS) capacitor c=4.6081e-17
C30 (\6\:CKb VSS) capacitor c=4.93434e-17
C31 (\6\:RN VSS) capacitor c=6.70851e-17
C32 (\3\:n20 VSS) capacitor c=4.34683e-17
C33 (\3\:CKb VSS) capacitor c=3.59123e-17
C34 (\3\:Ckbb VSS) capacitor c=6.47041e-17
C35 (\8\:qbint VSS) capacitor c=5.38513e-17
C36 (\3\:RN VSS) capacitor c=3.85958e-17
C37 (\3\:n30 VSS) capacitor c=4.99167e-17
C38 (\1\:CK VSS) capacitor c=3.05978e-17
C39 (\7\:qbint VSS) capacitor c=3.07896e-17
C40 (\4\:qint VSS) capacitor c=4.40371e-17
C41 (\7\:SE VSS) capacitor c=1.84657e-17
C42 (\3\:SI VSS) capacitor c=5.50292e-17
C43 (\3\:SE VSS) capacitor c=6.69497e-17
C44 (\3\:SEb VSS) capacitor c=5.88072e-17
C45 (\3\:D VSS) capacitor c=2.5819e-17
C46 (\8\:CKb VSS) capacitor c=5.49373e-17
C47 (\5\:CKb VSS) capacitor c=4.71486e-17
C48 (\4\:Ckbb VSS) capacitor c=7.28332e-17
C49 (\3\:mout VSS) capacitor c=5.77751e-17
C50 (\5\:RN VSS) capacitor c=8.9086e-17
C51 (\10\:qbint VSS) capacitor c=3.8414e-17
C52 (\1\:RN VSS) capacitor c=5.13212e-17
C53 (\2\:n30 VSS) capacitor c=4.57522e-17
C54 (\3\:CK VSS) capacitor c=3.37724e-17
C55 (\5\:qbint VSS) capacitor c=2.97804e-17
C56 (\4\:qbint VSS) capacitor c=3.12472e-17
C57 (\3\:qint VSS) capacitor c=3.63072e-17
C58 (\6\:SE VSS) capacitor c=2.65182e-17
C59 (\2\:SI VSS) capacitor c=5.42384e-17
C60 (\4\:SE VSS) capacitor c=6.03027e-17
C61 (\2\:SEb VSS) capacitor c=7.22978e-17
C62 (\2\:SE VSS) capacitor c=4.36842e-17
C63 (\2\:D VSS) capacitor c=3.85195e-17
C64 (\10\:CKb VSS) capacitor c=2.17162e-17
C65 (\6\:Ckbb VSS) capacitor c=3.09007e-17
C66 (\7\:CKb VSS) capacitor c=2.073e-17
C67 (\5\:Ckbb VSS) capacitor c=3.32134e-17
C68 (\2\:mout VSS) capacitor c=5.96977e-17
C69 (\7\:RN VSS) capacitor c=2.76825e-17
C70 (\2\:n20 VSS) capacitor c=4.52248e-17
C71 (\4\:CKb VSS) capacitor c=3.08979e-17
C72 (\2\:Ckbb VSS) capacitor c=5.19539e-17
C73 (\2\:CKb VSS) capacitor c=5.46729e-17
C74 (\9\:qbint VSS) capacitor c=4.81514e-17
C75 (\2\:RN VSS) capacitor c=4.16073e-17
C76 (\4\:RN VSS) capacitor c=2.51173e-17
C77 (\2\:CK VSS) capacitor c=2.89786e-17
C78 (\4\:SEb VSS) capacitor c=7.28637e-18
C79 (\1\:VDD VSS) capacitor c=3.33956e-17
C80 (\8\:Db VSS) capacitor c=3.05643e-17
C81 (\16\:VDD VSS) capacitor c=7.58738e-18
C82 (\13\:Ckbb VSS) capacitor c=7.66722e-17
C83 (\4\:Db VSS) capacitor c=1.57896e-16
C84 (\7\:n20 VSS) capacitor c=5.2651e-17
C85 (\18\:VDD VSS) capacitor c=4.05594e-17
C86 (\3\:n6 VSS) capacitor c=6.72166e-17
C87 (\20\:VDD VSS) capacitor c=2.58308e-17
C88 (\8\:mout VSS) capacitor c=6.05336e-17
C89 (\7\:n30 VSS) capacitor c=8.45018e-17
C90 (\22\:VDD VSS) capacitor c=2.56093e-17
C91 (\11\:qbint VSS) capacitor c=9.78504e-17
C92 (\24\:VDD VSS) capacitor c=1.02303e-17
C93 (\15\:CKb VSS) capacitor c=1.3324e-16
C94 (\26\:VDD VSS) capacitor c=4.36637e-17
C95 (\1\:Q VSS) capacitor c=7.34198e-17
C96 (\5\:qint VSS) capacitor c=2.45201e-17
C97 (\28\:VDD VSS) capacitor c=1.86864e-17
C98 (\1\:QN VSS) capacitor c=3.52742e-17
C99 (\3\:VDD VSS) capacitor c=1.35545e-16
C100 (\8\:SEb VSS) capacitor c=5.74971e-17
C101 (\9\:Ckbb VSS) capacitor c=1.15104e-16
C102 (\6\:Db VSS) capacitor c=7.65146e-17
C103 (\4\:n20 VSS) capacitor c=5.11943e-17
C104 (\6\:mout VSS) capacitor c=3.1252e-17
C105 (\4\:n30 VSS) capacitor c=1.22603e-16
C106 (\14\:qbint VSS) capacitor c=7.44996e-17
C107 (\19\:CKb VSS) capacitor c=6.37027e-17
C108 (\3\:Q VSS) capacitor c=7.68222e-17
C109 (\9\:qint VSS) capacitor c=2.36247e-17
C110 (\3\:QN VSS) capacitor c=2.6311e-17
C111 (\2\:qint VSS) capacitor c=7.32123e-18
C112 (\2\:qbint VSS) capacitor c=4.04494e-17
C113 (\3\:qbint VSS) capacitor c=3.02935e-17
C114 (\7\:qint VSS) capacitor c=2.70819e-17
C115 (\8\:qint VSS) capacitor c=2.04247e-17
C116 (\4\:CK VSS) capacitor c=4.13363e-17
C117 (\8\:RN VSS) capacitor c=4.02463e-17
C118 (\13\:qbint VSS) capacitor c=1.12041e-16
C119 (\16\:qbint VSS) capacitor c=8.5471e-17
C120 (\17\:qbint VSS) capacitor c=1.1112e-16
C121 (\6\:n30 VSS) capacitor c=9.70385e-17
C122 (\9\:RN VSS) capacitor c=1.67345e-16
C123 (\10\:RN VSS) capacitor c=1.65829e-16
C124 (\4\:mout VSS) capacitor c=6.49364e-17
C125 (\5\:mout VSS) capacitor c=7.40983e-17
C126 (\6\:n20 VSS) capacitor c=1.09501e-16
C127 (\9\:n20 VSS) capacitor c=8.59827e-17
C128 (\8\:Ckbb VSS) capacitor c=3.41213e-17
C129 (\11\:Ckbb VSS) capacitor c=1.86926e-16
C130 (\12\:Ckbb VSS) capacitor c=1.30427e-16
C131 (\11\:CKb VSS) capacitor c=7.98663e-17
C132 (\12\:CKb VSS) capacitor c=1.64212e-16
C133 (\13\:CKb VSS) capacitor c=1.27532e-16
C134 (\14\:CKb VSS) capacitor c=1.57472e-16
C135 (\17\:CKb VSS) capacitor c=6.84395e-17
C136 (\18\:CKb VSS) capacitor c=7.02243e-17
C137 (\4\:D VSS) capacitor c=4.91028e-17
C138 (\3\:Db VSS) capacitor c=1.52963e-16
C139 (\4\:SI VSS) capacitor c=4.66404e-17
C140 (\8\:SE VSS) capacitor c=7.85932e-17
C141 (\9\:SE VSS) capacitor c=1.0202e-16
C142 (\10\:SE VSS) capacitor c=4.23604e-17
C143 (\6\:SEb VSS) capacitor c=7.93567e-17
C144 (\7\:SEb VSS) capacitor c=9.46947e-17
C145 (\5\:VDD VSS) capacitor c=1.20602e-17
C146 (\7\:VDD VSS) capacitor c=1.74167e-17
C147 (\8\:VDD VSS) capacitor c=1.63735e-17
C148 (\10\:VDD VSS) capacitor c=3.18692e-17
C149 (\11\:VDD VSS) capacitor c=7.87277e-18
C150 (\13\:VDD VSS) capacitor c=1.01807e-17
C151 (\15\:VDD VSS) capacitor c=5.07132e-18
Rk2 (\4\:QN QN) resistor r=0.07593 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.3057 c=0
Rk9 (\8\:RN RN) resistor r=0.1221 c=0
Rk16 (\9\:RN \10\:RN) resistor r=1.0603 c=0
Rk41 (SE \8\:SE) resistor r=0.09091 c=0
Rk42 (\8\:SE \9\:SE) resistor r=0.5972 c=0
Rk43 (\9\:SE \10\:SE) resistor r=0.1875 c=0
Rk8 (\4\:CK CK) resistor r=0.1844 c=0
Rk40 (SI \4\:SI) resistor r=0.04461 c=0
Rk47 (\2\:VDD \4\:VDD) resistor r=0.4042 c=0
Rk48 (\4\:VDD \5\:VDD) resistor r=0.3885 c=0
Rk49 (\5\:VDD \6\:VDD) resistor r=0.1628 c=0
Rk50 (\6\:VDD \7\:VDD) resistor r=0.401 c=0
Rk51 (\7\:VDD \8\:VDD) resistor r=0.2193 c=0
Rk52 (\8\:VDD \9\:VDD) resistor r=0.1292 c=0
Rk53 (\9\:VDD \10\:VDD) resistor r=0.4101 c=0
Rk54 (\10\:VDD \11\:VDD) resistor r=0.1993 c=0
Rk55 (\11\:VDD \12\:VDD) resistor r=0.1402 c=0
Rk56 (\12\:VDD \13\:VDD) resistor r=0.1929 c=0
Rk57 (\13\:VDD \14\:VDD) resistor r=0.2581 c=0
Rk59 (\15\:VDD VDD) resistor r=0.1976 c=0
Rk58 (\14\:VDD \15\:VDD) resistor r=0.05246 c=0
Rk60 (\5\:VDD \17\:VDD) resistor r=0.07381 c=0
Rk61 (\7\:VDD \19\:VDD) resistor r=0.1759 c=0
Rk62 (\8\:VDD \21\:VDD) resistor r=0.0433 c=0
Rk63 (\10\:VDD \23\:VDD) resistor r=0.0433 c=0
Rk64 (\11\:VDD \25\:VDD) resistor r=0.07381 c=0
Rk65 (\13\:VDD \27\:VDD) resistor r=0.2785 c=0
Rk66 (\15\:VDD \29\:VDD) resistor r=0.224 c=0
Rk35 (\4\:D D) resistor r=0.1361 c=0
Rk6 (\2\:Q Q) resistor r=0.3602 c=0
Rk7 (Q \4\:Q) resistor r=0.04708 c=0
Rk67 (\2\:VSS \3\:VSS) resistor r=0.1803 c=0
Rk68 (\3\:VSS \4\:VSS) resistor r=0.4434 c=0
Rk69 (\4\:VSS \5\:VSS) resistor r=0.1277 c=0
Rk70 (\5\:VSS \6\:VSS) resistor r=0.5565 c=0
Rk71 (\6\:VSS \7\:VSS) resistor r=0.2957 c=0
Rk72 (\7\:VSS \8\:VSS) resistor r=0.3107 c=0
Rk73 (\8\:VSS \9\:VSS) resistor r=0.4411 c=0
Rk74 (\9\:VSS \10\:VSS) resistor r=0.1151 c=0
Rk75 (\10\:VSS \11\:VSS) resistor r=0.288 c=0
Rk77 (\12\:VSS VSS) resistor r=0.0499 c=0
Rk76 (\11\:VSS \12\:VSS) resistor r=0.1477 c=0
Rk78 (\3\:VSS \14\:VSS) resistor r=0.1993 c=0
Rk79 (\4\:VSS \16\:VSS) resistor r=0.2039 c=0
Rk80 (\6\:VSS \18\:VSS) resistor r=0.1225 c=0
Rk81 (\8\:VSS \20\:VSS) resistor r=0.1506 c=0
Rk82 (\10\:VSS \22\:VSS) resistor r=0.2864 c=0
Rk83 (\11\:VSS \24\:VSS) resistor r=0.07381 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.1177 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1193 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.1057 c=0
Rk10 (\12\:qbint \13\:qbint) resistor r=0.5616 c=0
Rk11 (\13\:qbint \15\:qbint) resistor r=0.1131 c=0
Rk12 (\13\:qbint \16\:qbint) resistor r=0.4471 c=0
Rk13 (\15\:qbint \17\:qbint) resistor r=0.677 c=0
Rk28 (\11\:CKb \12\:CKb) resistor r=0.5573 c=0
Rk29 (\12\:CKb \13\:CKb) resistor r=0.8047 c=0
Rk30 (\13\:CKb \14\:CKb) resistor r=0.2989 c=0
Rk31 (\14\:CKb \16\:CKb) resistor r=0.9156 c=0
Rk32 (\13\:CKb \17\:CKb) resistor r=0.2834 c=0
Rk33 (\14\:CKb \18\:CKb) resistor r=0.3719 c=0
Rk34 (\16\:CKb \20\:CKb) resistor r=0.3553 c=0
Rk14 (\5\:n30 \6\:n30) resistor r=0.6434 c=0
Rk15 (\5\:n30 \8\:n30) resistor r=0.4521 c=0
Rk17 (\4\:mout \5\:mout) resistor r=0.4543 c=0
Rk18 (\5\:mout \7\:mout) resistor r=0.1108 c=0
Rk19 (\5\:mout \9\:mout) resistor r=0.2121 c=0
Rk24 (\8\:Ckbb \10\:Ckbb) resistor r=0.2636 c=0
Rk25 (\10\:Ckbb \11\:Ckbb) resistor r=0.5614 c=0
Rk26 (\11\:Ckbb \12\:Ckbb) resistor r=1.129 c=0
Rk27 (\10\:Ckbb \14\:Ckbb) resistor r=0.5596 c=0
Rk21 (\5\:n20 \6\:n20) resistor r=0.2469 c=0
Rk22 (\6\:n20 \8\:n20) resistor r=0.2957 c=0
Rk23 (\6\:n20 \9\:n20) resistor r=0.5202 c=0
Rk36 (\2\:Db \3\:Db) resistor r=0.7641 c=0
Rk37 (\3\:Db \5\:Db) resistor r=0.7638 c=0
Rk38 (\5\:Db \7\:Db) resistor r=0.4683 c=0
Rk39 (\3\:Db \9\:Db) resistor r=0.178 c=0
Rk44 (\5\:SEb \6\:SEb) resistor r=0.04786 c=0
Rk45 (\6\:SEb \7\:SEb) resistor r=0.5956 c=0
Rk46 (\6\:SEb \9\:SEb) resistor r=0.4871 c=0
Rk20 (\2\:n6 \4\:n6) resistor r=0.219 c=0
Rl25 (\5\:RN \6\:RN) resistor r=188.027 c=0
Rl26 (\6\:RN \7\:RN) resistor r=87.2302 c=0
Rl15 (\2\:RN \3\:RN) resistor r=51.1559 c=0
Rl14 (\1\:RN \2\:RN) resistor r=87.6944 c=0
Rl16 (\3\:RN \4\:RN) resistor r=87.2302 c=0
Rl43 (\5\:SE \6\:SE) resistor r=158.384 c=0
Rl44 (\6\:SE \7\:SE) resistor r=29.5379 c=0
Rl40 (\3\:SE \4\:SE) resistor r=81.461 c=0
Rl37 (\1\:SE \2\:SE) resistor r=79.5379 c=0
Rl10 (\1\:CK \2\:CK) resistor r=37.2302 c=0
Rl11 (\2\:CK \3\:CK) resistor r=44.9225 c=0
Rl41 (\1\:SI \2\:SI) resistor r=98.7687 c=0
Rl42 (\2\:SI \3\:SI) resistor r=89.1533 c=0
Rl35 (\1\:D \2\:D) resistor r=160.618 c=0
Rl36 (\2\:D \3\:D) resistor r=26.1559 c=0
Rl1 (qint \2\:qint) resistor r=5.915 c=0
Rl3 (\2\:qint \4\:qint) resistor r=49.7141 c=0
Rl2 (\2\:qint \3\:qint) resistor r=34.3295 c=0
Rl17 (\8\:qbint \9\:qbint) resistor r=102.615 c=0
Rl18 (\9\:qbint \10\:qbint) resistor r=39.1533 c=0
Rl4 (qbint \2\:qbint) resistor r=68.2462 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=37.477 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=5.6723 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=41.5412 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=47.3105 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=145.337 c=0
Rl33 (\8\:CKb \9\:CKb) resistor r=211.022 c=0
Rl30 (\5\:CKb \6\:CKb) resistor r=150.368 c=0
Rl34 (\9\:CKb \10\:CKb) resistor r=50.6918 c=0
Rl31 (\6\:CKb \7\:CKb) resistor r=47.2519 c=0
Rl22 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl19 (CKb \2\:CKb) resistor r=64.6174 c=0
Rl12 (n30 \2\:n30) resistor r=26.1559 c=0
Rl13 (\2\:n30 \3\:n30) resistor r=170.72 c=0
Rl27 (mout \2\:mout) resistor r=114.617 c=0
Rl28 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl32 (\6\:Ckbb \7\:Ckbb) resistor r=118.744 c=0
Rl29 (\4\:Ckbb \5\:Ckbb) resistor r=26.1559 c=0
Rl20 (Ckbb \2\:Ckbb) resistor r=24.2328 c=0
Rl21 (\2\:Ckbb \3\:Ckbb) resistor r=164.504 c=0
Rl23 (n20 \2\:n20) resistor r=97.3098 c=0
Rl24 (\2\:n20 \3\:n20) resistor r=53.4003 c=0
Rl38 (SEb \2\:SEb) resistor r=26.9231 c=0
Rl39 (\2\:SEb \3\:SEb) resistor r=167.606 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz13 (\3\:VDD \4\:VDD) resistor r=9.375 c=0
Rz14 (\3\:VDD \6\:VDD) resistor r=25 c=0
Rz15 (\3\:VDD \9\:VDD) resistor r=6.25 c=0
Rz16 (\3\:VDD \12\:VDD) resistor r=25 c=0
Rz17 (\3\:VDD \14\:VDD) resistor r=12.5 c=0
Rz3 (\3\:Q \4\:Q) resistor r=75 c=0
Rz18 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz19 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz20 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz21 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz22 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz23 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz4 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz9 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz5 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz6 (\6\:mout \7\:mout) resistor r=75 c=0
Rz8 (\9\:Ckbb \10\:Ckbb) resistor r=75 c=0
Rz7 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\6\:Db \7\:Db) resistor r=75 c=0
Rz12 (\8\:SEb \9\:SEb) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry15 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry16 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry17 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry18 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry19 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry20 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry21 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry22 (\28\:VDD \29\:VDD) resistor r=62 c=0
Ry3 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry23 (\1\:VSS \2\:VSS) resistor r=15.5 c=0
Ry24 (\1\:VSS \5\:VSS) resistor r=5.6364 c=0
Ry25 (\1\:VSS \7\:VSS) resistor r=10.3333 c=0
Ry26 (\1\:VSS \9\:VSS) resistor r=6.8889 c=0
Ry27 (\1\:VSS \12\:VSS) resistor r=31 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry4 (\11\:qbint \12\:qbint) resistor r=62 c=0
Ry11 (\15\:CKb \16\:CKb) resistor r=62 c=0
Ry5 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry6 (\8\:mout \9\:mout) resistor r=62 c=0
Ry10 (\13\:Ckbb \14\:Ckbb) resistor r=62 c=0
Ry9 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry12 (\4\:Db \5\:Db) resistor r=62 c=0
Ry13 (\8\:Db \9\:Db) resistor r=62 c=0
Ry14 (\4\:SEb \5\:SEb) resistor r=62 c=0
Ry7 (n6 \2\:n6) resistor r=62 c=0
Ry8 (\3\:n6 \4\:n6) resistor r=62 c=0
Rx3 (\2\:RN \8\:RN) resistor r=45 c=0
Rx7 (\7\:RN \9\:RN) resistor r=45 c=0
Rx8 (\4\:RN \10\:RN) resistor r=45 c=0
Rx20 (\6\:SE \8\:SE) resistor r=45 c=0
Rx21 (\4\:SE \9\:SE) resistor r=45 c=0
Rx22 (\2\:SE \10\:SE) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx19 (\2\:SI \4\:SI) resistor r=45 c=0
Rx18 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx4 (\9\:qbint \16\:qbint) resistor r=45 c=0
Rx5 (\6\:qbint \17\:qbint) resistor r=45 c=0
Rx14 (\10\:CKb \11\:CKb) resistor r=45 c=0
Rx15 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx16 (\4\:CKb \17\:CKb) resistor r=45 c=0
Rx17 (\2\:CKb \18\:CKb) resistor r=45 c=0
Rx6 (n30 \6\:n30) resistor r=45 c=0
Rx9 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\6\:Ckbb \8\:Ckbb) resistor r=45 c=0
Rx12 (\5\:Ckbb \11\:Ckbb) resistor r=45 c=0
Rx13 (\2\:Ckbb \12\:Ckbb) resistor r=45 c=0
Rx10 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx23 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.273e-14 ad=3.64e-14 ps=1.67e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.50577e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\9\:qint \4\:qbint \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.273e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\3\:Q \5\:qbint \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=3.64e-14 ps=9.7e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.51923e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (\19\:CKb \3\:CK \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.873e-14 ad=3.625e-14 ps=9.7e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.1e-07 sb=2.5e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn46 (\14\:qbint \2\:n30 n9 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.523e-14 ad=3.698e-14 ps=5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=2e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn45 (n9 \1\:RN \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=1.523e-14 ps=1.05e-06 pd=5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=2e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn50 (n11 \10\:qbint \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=1.957e-14 ps=1.05e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.81e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn51 (\4\:n30 CKb n11 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=2.9e-14 ps=5.6e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.5e-07 sb=1.63e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn35 (n7 \5\:RN \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.255e-14 ad=8.7e-15 ps=1.22e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.85e-06 sb=6.3e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn40 (\6\:mout Ckbb \4\:n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=5.728e-14 ps=6.9e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.095e-06 sb=1.385e-06 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn30 (\6\:mout n20 \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.255e-14 ad=5.728e-14 ps=1.22e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.535e-06 sb=9.45e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn36 (n5 \3\:mout n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=1.958e-14 ps=4.1e-07 pd=5.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.955e-06 sb=5.25e-07 sd=160n sca=9.50767 scb=0.00818119 \
        scc=0.00019576 m=(1)
mn37 (\4\:n20 \4\:Ckbb n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=2.32e-14 ps=5.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=9.50767 \
        scb=0.00818119 scc=0.00019576 m=(1)
mn25 (\6\:Db \5\:CKb \4\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=9.50767 scb=0.00818119 \
        scc=0.00019576 m=(1)
mn21 (\9\:Ckbb \8\:CKb \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=4.64e-14 ps=6.1e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.2e-07 sb=1.635e-06 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn11 (n1 \3\:D \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=5.148e-14 ps=6.1e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=1.43e-06 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn12 (Db \3\:SEb n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.148e-14 ad=2.32e-14 ps=1e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.25e-07 sb=1.03e-06 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn14 (Db \3\:SE n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.13e-06 sb=8.25e-07 sd=160n sca=7.37439 scb=0.00450456 \
        scc=4.82709e-05 m=(1)
mn13 (n3 \3\:SI \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.525e-14 ad=8.7e-15 ps=1.19e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.235e-06 sb=7.2e-07 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn10 (\8\:SEb \7\:SE \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.525e-14 ad=3.263e-14 ps=1.19e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.73e-06 sb=2.25e-07 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mp56 (\5\:qint \7\:qbint \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.142e-14 ad=3.01e-14 ps=1.52e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=47.1852 \
        scb=0.0292558 scc=0.00588561 m=(1)
mp55 (\1\:Q qbint \26\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.965e-14 ad=5.46e-14 ps=1.2e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.02628e-07 sd=160n sca=20.5009 \
        scb=0.0171135 scc=0.00197772 m=(1)
mp20 (\15\:CKb \1\:CK \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.965e-14 ad=3.87e-14 ps=1.2e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=1.8e-07 sd=160n sca=28.4541 \
        scb=0.0241553 scc=0.00347654 m=(1)
mp46 (\11\:qbint \3\:n30 \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.39e-14 ad=3.44e-14 ps=1.73e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.855e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp45 (\11\:qbint \3\:RN \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.049e-13 ad=3.44e-14 ps=1.83e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1.65e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp50 (n8 \8\:qbint \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.049e-13 ad=3.978e-14 ps=1.83e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.385e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp51 (\7\:n30 \3\:Ckbb n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.978e-14 ad=5.483e-14 ps=8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8e-07 sb=1.155e-06 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp40 (\7\:n30 \3\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.16e-14 ad=5.483e-14 ps=9.1e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1e-06 sb=8.55e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp30 (\8\:mout \3\:n20 \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.049e-13 ad=5.16e-14 ps=1.83e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=5.7e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp35 (\3\:n6 \6\:RN \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.049e-13 ad=3.44e-14 ps=1.83e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.65e-06 sb=3.05e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp36 (\3\:n6 mout \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.59e-14 ad=3.44e-14 ps=1.41e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.855e-06 sb=1e-07 sd=160n sca=29.9075 \
        scb=0.0247057 scc=0.00372713 m=(1)
mp37 (\7\:n20 \6\:CKb n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp25 (\7\:n20 \7\:Ckbb \4\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp21 (\13\:Ckbb \9\:CKb \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.91e-14 ad=3.01e-14 ps=1.81e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.54e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp11 (n2 \1\:D \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.91e-14 ad=5.697e-14 ps=1.81e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.315e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp12 (\8\:Db \1\:SE n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.697e-14 ad=3.44e-14 ps=9.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=1.005e-06 sd=160n sca=21.1782 \
        scb=0.0203295 scc=0.00208843 m=(1)
mp14 (\8\:Db SEb n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=2.58e-14 \
        ad=3.44e-14 ps=6.7e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.8e-07 sb=8e-07 sd=160n sca=21.1782 scb=0.0203295 \
        scc=0.00208843 m=(1)
mp13 (n4 \1\:SI \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.675e-14 ad=2.58e-14 ps=1.33e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=6.35e-07 sd=160n sca=21.4774 \
        scb=0.0204117 scc=0.00208844 m=(1)
mp10 (\4\:SEb \5\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.675e-14 ad=3.01e-14 ps=1.33e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=1.4e-07 sd=160n sca=26.5704 \
        scb=0.0277882 scc=0.00223218 m=(1)
ends SDFFRX1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:33:53 2012 )
// Library name: gsclib045
// Cell name: SDFFRX2
// View name: extracted

simulator lang=spectre

subckt SDFFRX2 CK D Q QN RN SE SI VDD VSS
mp56 (\11\:qint \3\:qbint \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=8.305e-14 ad=3.01e-14 ps=1.32e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.45721e-06 sd=160n sca=57.0065 \
        scb=0.0445545 scc=0.00681945 m=(1)
C1 (Q VSS) capacitor c=4.41293e-17
C2 (RN VSS) capacitor c=1.54683e-16
C3 (CK VSS) capacitor c=1.10331e-16
C4 (D VSS) capacitor c=5.63018e-17
C5 (VDD VSS) capacitor c=3.32229e-16
C6 (SI VSS) capacitor c=8.05641e-17
C7 (QN VSS) capacitor c=4.90867e-17
C8 (qbint VSS) capacitor c=3.13432e-17
C9 (qint VSS) capacitor c=1.61177e-16
C10 (CKb VSS) capacitor c=5.69491e-17
C11 (n30 VSS) capacitor c=5.17651e-17
C12 (mout VSS) capacitor c=4.72802e-17
C13 (Ckbb VSS) capacitor c=7.78846e-17
C14 (n20 VSS) capacitor c=2.30881e-17
C15 (n5 VSS) capacitor c=2.08302e-19
C16 (Db VSS) capacitor c=1.0778e-16
C17 (n3 VSS) capacitor c=2.93728e-18
C18 (SEb VSS) capacitor c=6.43712e-17
C19 (n8 VSS) capacitor c=3.9157e-18
C20 (n6 VSS) capacitor c=8.54733e-17
C21 (n4 VSS) capacitor c=1.17072e-18
C22 (n2 VSS) capacitor c=5.77736e-18
C23 (\6\:SE VSS) capacitor c=3.92078e-17
C24 (\1\:D VSS) capacitor c=3.58651e-17
C25 (\1\:SE VSS) capacitor c=2.9742e-17
C26 (\1\:SI VSS) capacitor c=7.62062e-17
C27 (\8\:CKb VSS) capacitor c=4.23289e-17
C28 (\7\:Ckbb VSS) capacitor c=4.91983e-17
C29 (\6\:CKb VSS) capacitor c=3.94686e-17
C30 (\5\:RN VSS) capacitor c=6.90921e-17
C31 (\4\:n20 VSS) capacitor c=4.43178e-17
C32 (\3\:CKb VSS) capacitor c=3.64261e-17
C33 (\12\:qbint VSS) capacitor c=4.28689e-17
C34 (\1\:RN VSS) capacitor c=4.47769e-17
C35 (\3\:n30 VSS) capacitor c=3.71876e-17
C36 (\3\:CK VSS) capacitor c=4.00978e-17
C37 (\4\:qbint VSS) capacitor c=4.51622e-16
C38 (\3\:qbint VSS) capacitor c=1.71802e-17
C39 (\4\:SE VSS) capacitor c=2.67036e-17
C40 (\3\:D VSS) capacitor c=6.78313e-17
C41 (\3\:SEb VSS) capacitor c=7.55335e-17
C42 (\3\:SE VSS) capacitor c=4.97826e-17
C43 (\3\:SI VSS) capacitor c=2.69385e-17
C44 (\10\:CKb VSS) capacitor c=5.10512e-17
C45 (\5\:CKb VSS) capacitor c=4.38779e-17
C46 (\4\:Ckbb VSS) capacitor c=5.75342e-17
C47 (\3\:mout VSS) capacitor c=4.72107e-17
C48 (\4\:RN VSS) capacitor c=8.60105e-17
C49 (\3\:n20 VSS) capacitor c=4.14977e-17
C50 (\2\:Ckbb VSS) capacitor c=4.5142e-17
C51 (\13\:qbint VSS) capacitor c=7.86107e-17
C52 (\3\:RN VSS) capacitor c=6.66377e-17
C53 (\1\:CK VSS) capacitor c=2.40162e-17
C54 (\5\:SE VSS) capacitor c=3.41037e-17
C55 (\2\:D VSS) capacitor c=4.79262e-17
C56 (\4\:SEb VSS) capacitor c=3.24582e-17
C57 (\2\:SE VSS) capacitor c=4.04209e-17
C58 (\2\:SEb VSS) capacitor c=3.65125e-17
C59 (\2\:SI VSS) capacitor c=4.58628e-17
C60 (\9\:CKb VSS) capacitor c=2.32286e-17
C61 (\6\:Ckbb VSS) capacitor c=3.48035e-17
C62 (\7\:CKb VSS) capacitor c=1.94648e-17
C63 (\5\:Ckbb VSS) capacitor c=2.42711e-17
C64 (\2\:mout VSS) capacitor c=4.25366e-17
C65 (\6\:RN VSS) capacitor c=2.90731e-17
C66 (\3\:Ckbb VSS) capacitor c=1.96283e-17
C67 (\4\:CKb VSS) capacitor c=4.32722e-17
C68 (\2\:CKb VSS) capacitor c=2.44702e-17
C69 (\14\:qbint VSS) capacitor c=2.46907e-17
C70 (\2\:RN VSS) capacitor c=4.70934e-17
C71 (\2\:n30 VSS) capacitor c=3.58518e-17
C72 (\2\:CK VSS) capacitor c=2.87764e-17
C73 (\2\:qbint VSS) capacitor c=3.22949e-17
C74 (\5\:SEb VSS) capacitor c=4.75388e-17
C75 (\17\:VDD VSS) capacitor c=9.69132e-18
C76 (\3\:Db VSS) capacitor c=1.25399e-16
C77 (\19\:VDD VSS) capacitor c=1.06639e-17
C78 (\14\:Ckbb VSS) capacitor c=5.65769e-17
C79 (\5\:Db VSS) capacitor c=1.62029e-16
C80 (\8\:n20 VSS) capacitor c=5.64845e-17
C81 (\21\:VDD VSS) capacitor c=3.6411e-17
C82 (\3\:n6 VSS) capacitor c=8.51706e-17
C83 (\23\:VDD VSS) capacitor c=2.3673e-17
C84 (\4\:mout VSS) capacitor c=4.96897e-17
C85 (\4\:n30 VSS) capacitor c=7.48156e-17
C86 (\25\:VDD VSS) capacitor c=1.06479e-17
C87 (\21\:qbint VSS) capacitor c=5.57402e-17
C88 (\27\:VDD VSS) capacitor c=3.07171e-17
C89 (\17\:CKb VSS) capacitor c=6.19777e-17
C90 (\3\:Q VSS) capacitor c=6.57166e-17
C91 (\3\:QN VSS) capacitor c=5.60398e-17
C92 (\11\:qint VSS) capacitor c=4.1181e-17
C93 (\1\:VDD VSS) capacitor c=1.24353e-16
C94 (\7\:SEb VSS) capacitor c=8.3096e-17
C95 (\8\:Ckbb VSS) capacitor c=2.12545e-17
C96 (\7\:Db VSS) capacitor c=6.85986e-17
C97 (\5\:n20 VSS) capacitor c=4.13257e-17
C98 (\7\:mout VSS) capacitor c=2.72695e-17
C99 (\8\:n30 VSS) capacitor c=3.17935e-17
C100 (\15\:qbint VSS) capacitor c=6.87493e-17
C101 (\15\:CKb VSS) capacitor c=1.21052e-16
C102 (\1\:Q VSS) capacitor c=1.57757e-17
C103 (\1\:QN VSS) capacitor c=1.84399e-17
C104 (\9\:qint VSS) capacitor c=4.93298e-17
C105 (\2\:n20 VSS) capacitor c=2.0826e-17
C106 (\8\:qint VSS) capacitor c=6.43206e-17
C107 (\17\:qbint VSS) capacitor c=7.94046e-17
C108 (\20\:qbint VSS) capacitor c=1.01667e-16
C109 (\23\:qbint VSS) capacitor c=6.17106e-17
C110 (\6\:n30 VSS) capacitor c=5.07319e-17
C111 (\7\:n30 VSS) capacitor c=8.32616e-17
C112 (\7\:RN VSS) capacitor c=1.64e-16
C113 (\8\:RN VSS) capacitor c=4.06248e-17
C114 (\6\:mout VSS) capacitor c=5.91768e-17
C115 (\9\:mout VSS) capacitor c=6.88593e-17
C116 (\7\:n20 VSS) capacitor c=8.75932e-17
C117 (\10\:n20 VSS) capacitor c=9.77911e-17
C118 (\10\:Ckbb VSS) capacitor c=2.85339e-17
C119 (\11\:Ckbb VSS) capacitor c=6.4488e-17
C120 (\12\:Ckbb VSS) capacitor c=1.10782e-16
C121 (\13\:Ckbb VSS) capacitor c=8.3884e-17
C122 (\11\:CKb VSS) capacitor c=7.38381e-17
C123 (\12\:CKb VSS) capacitor c=2.09251e-16
C124 (\13\:CKb VSS) capacitor c=2.18707e-16
C125 (\14\:CKb VSS) capacitor c=1.50155e-16
C126 (\4\:SI VSS) capacitor c=3.89271e-17
C127 (\4\:D VSS) capacitor c=5.3699e-17
C128 (\7\:SE VSS) capacitor c=8.73258e-17
C129 (\8\:SE VSS) capacitor c=6.53371e-17
C130 (\9\:SEb VSS) capacitor c=1.08627e-16
C131 (\10\:SEb VSS) capacitor c=2.66229e-17
C132 (\11\:SEb VSS) capacitor c=1.01433e-16
C133 (\3\:VDD VSS) capacitor c=2.73106e-18
C134 (\5\:VDD VSS) capacitor c=6.78928e-18
C135 (\7\:VDD VSS) capacitor c=6.84027e-18
C136 (\8\:VDD VSS) capacitor c=1.85807e-17
C137 (\10\:VDD VSS) capacitor c=2.44564e-17
C138 (\11\:VDD VSS) capacitor c=9.57191e-18
C139 (\13\:VDD VSS) capacitor c=1.20089e-16
Rk5 (\2\:Q Q) resistor r=0.06768 c=0
Rk6 (Q \4\:Q) resistor r=0.1712 c=0
Rk49 (\2\:VSS \4\:VSS) resistor r=0.2366 c=0
Rk50 (\4\:VSS \5\:VSS) resistor r=0.248 c=0
Rk51 (\5\:VSS \6\:VSS) resistor r=0.7551 c=0
Rk52 (\6\:VSS \7\:VSS) resistor r=0.5416 c=0
Rk57 (\8\:VSS VSS) resistor r=0.1875 c=0
Rk53 (\7\:VSS \8\:VSS) resistor r=0.6012 c=0
Rk58 (\5\:VSS \13\:VSS) resistor r=0.28 c=0
Rk59 (\6\:VSS \15\:VSS) resistor r=0.07144 c=0
Rk60 (\7\:VSS \17\:VSS) resistor r=0.1288 c=0
Rk19 (\7\:RN RN) resistor r=1.1013 c=0
Rk20 (RN \8\:RN) resistor r=0.1094 c=0
Rk44 (\8\:SE SE) resistor r=0.005081 c=0
Rk43 (\7\:SE \8\:SE) resistor r=0.3449 c=0
Rk7 (\4\:CK CK) resistor r=0.002516 c=0
Rk42 (D \4\:D) resistor r=0.2151 c=0
Rk64 (\2\:VDD \3\:VDD) resistor r=0.1452 c=0
Rk65 (\3\:VDD \4\:VDD) resistor r=0.1552 c=0
Rk66 (\4\:VDD \5\:VDD) resistor r=0.2179 c=0
Rk67 (\5\:VDD \6\:VDD) resistor r=0.283 c=0
Rk68 (\6\:VDD \7\:VDD) resistor r=0.3056 c=0
Rk69 (\7\:VDD \8\:VDD) resistor r=0.2192 c=0
Rk70 (\8\:VDD \9\:VDD) resistor r=0.1743 c=0
Rk71 (\9\:VDD \10\:VDD) resistor r=0.3683 c=0
Rk72 (\10\:VDD \11\:VDD) resistor r=0.2001 c=0
Rk73 (\11\:VDD \12\:VDD) resistor r=0.2329 c=0
Rk78 (\13\:VDD VDD) resistor r=0.1149 c=0
Rk74 (\12\:VDD \13\:VDD) resistor r=0.1251 c=0
Rk79 (\3\:VDD \18\:VDD) resistor r=0.07358 c=0
Rk80 (\5\:VDD \20\:VDD) resistor r=0.07358 c=0
Rk81 (\7\:VDD \22\:VDD) resistor r=0.1754 c=0
Rk82 (\8\:VDD \24\:VDD) resistor r=0.04328 c=0
Rk83 (\10\:VDD \26\:VDD) resistor r=0.07358 c=0
Rk84 (\11\:VDD \28\:VDD) resistor r=0.2466 c=0
Rk38 (\4\:SI SI) resistor r=0.1283 c=0
Rk3 (\2\:QN QN) resistor r=0.06657 c=0
Rk4 (QN \4\:QN) resistor r=0.1965 c=0
Rk9 (\17\:qbint \4\:qbint) resistor r=0.589 c=0
Rk8 (\16\:qbint \17\:qbint) resistor r=0.3283 c=0
Rk11 (\4\:qbint \20\:qbint) resistor r=0.6832 c=0
Rk12 (\17\:qbint \22\:qbint) resistor r=0.2401 c=0
Rk13 (\22\:qbint \23\:qbint) resistor r=0.3138 c=0
Rk1 (\8\:qint \10\:qint) resistor r=0.3054 c=0
Rk2 (\10\:qint \12\:qint) resistor r=0.3041 c=0
Rk33 (\11\:CKb \12\:CKb) resistor r=0.5151 c=0
Rk34 (\12\:CKb \13\:CKb) resistor r=1.1438 c=0
Rk35 (\13\:CKb \14\:CKb) resistor r=0.698 c=0
Rk36 (\14\:CKb \16\:CKb) resistor r=0.8379 c=0
Rk37 (\16\:CKb \18\:CKb) resistor r=0.3148 c=0
Rk16 (\5\:n30 \6\:n30) resistor r=0.3183 c=0
Rk17 (\6\:n30 \7\:n30) resistor r=0.4182 c=0
Rk18 (\6\:n30 \9\:n30) resistor r=0.09782 c=0
Rk21 (\5\:mout \6\:mout) resistor r=0.2475 c=0
Rk22 (\6\:mout \8\:mout) resistor r=0.09265 c=0
Rk23 (\6\:mout \9\:mout) resistor r=0.3876 c=0
Rk28 (\9\:Ckbb \10\:Ckbb) resistor r=0.1486 c=0
Rk29 (\10\:Ckbb \11\:Ckbb) resistor r=0.09296 c=0
Rk30 (\11\:Ckbb \12\:Ckbb) resistor r=0.6378 c=0
Rk31 (\12\:Ckbb \13\:Ckbb) resistor r=0.5953 c=0
Rk32 (\10\:Ckbb \15\:Ckbb) resistor r=0.2417 c=0
Rk25 (\6\:n20 \7\:n20) resistor r=0.2085 c=0
Rk26 (\7\:n20 \9\:n20) resistor r=0.265 c=0
Rk27 (\7\:n20 \10\:n20) resistor r=0.5262 c=0
Rk39 (\2\:Db \4\:Db) resistor r=0.5576 c=0
Rk40 (\4\:Db \6\:Db) resistor r=0.7767 c=0
Rk41 (\6\:Db \8\:Db) resistor r=0.3995 c=0
Rk45 (\6\:SEb \8\:SEb) resistor r=0.4707 c=0
Rk46 (\8\:SEb \9\:SEb) resistor r=0.4755 c=0
Rk47 (\9\:SEb \10\:SEb) resistor r=0.04287 c=0
Rk48 (\9\:SEb \11\:SEb) resistor r=0.5881 c=0
Rk24 (\2\:n6 \4\:n6) resistor r=0.2607 c=0
Rl30 (\4\:RN \5\:RN) resistor r=136.104 c=0
Rl31 (\5\:RN \6\:RN) resistor r=73.7687 c=0
Rl19 (\1\:RN \2\:RN) resistor r=24.2328 c=0
Rl20 (\2\:RN \3\:RN) resistor r=84.9195 c=0
Rl49 (\5\:SE \6\:SE) resistor r=87.6374 c=0
Rl48 (\4\:SE \5\:SE) resistor r=39.3036 c=0
Rl43 (\1\:SE \2\:SE) resistor r=24.2328 c=0
Rl44 (\2\:SE \3\:SE) resistor r=116.106 c=0
Rl16 (\2\:CK \3\:CK) resistor r=74.1758 c=0
Rl15 (\1\:CK \2\:CK) resistor r=30.7692 c=0
Rl46 (\1\:D \2\:D) resistor r=29.5379 c=0
Rl47 (\2\:D \3\:D) resistor r=96.8456 c=0
Rl40 (\1\:SI \2\:SI) resistor r=85.7713 c=0
Rl41 (\2\:SI \3\:SI) resistor r=37.6944 c=0
Rl21 (\13\:qbint \12\:qbint) resistor r=126.923 c=0
Rl22 (\14\:qbint \12\:qbint) resistor r=29.5379 c=0
Rl1 (\2\:qbint qbint) resistor r=57.6923 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=31.4748 c=0
Rl39 (\8\:CKb \10\:CKb) resistor r=151.923 c=0
Rl35 (\5\:CKb \6\:CKb) resistor r=102.735 c=0
Rl38 (\8\:CKb \9\:CKb) resistor r=56.461 c=0
Rl36 (\6\:CKb \7\:CKb) resistor r=44.9225 c=0
Rl24 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl23 (CKb \2\:CKb) resistor r=81.9251 c=0
Rl17 (n30 \2\:n30) resistor r=38.4615 c=0
Rl18 (\2\:n30 \3\:n30) resistor r=64.5604 c=0
Rl32 (mout \2\:mout) resistor r=69.2107 c=0
Rl33 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl25 (Ckbb \2\:Ckbb) resistor r=224.131 c=0
Rl37 (\6\:Ckbb \7\:Ckbb) resistor r=136.052 c=0
Rl34 (\4\:Ckbb \5\:Ckbb) resistor r=31.9251 c=0
Rl26 (\2\:Ckbb \3\:Ckbb) resistor r=31.9251 c=0
Rl27 (n20 \2\:n20) resistor r=0.5213 c=0
Rl29 (\2\:n20 \4\:n20) resistor r=34.3295 c=0
Rl28 (\2\:n20 \3\:n20) resistor r=84.3295 c=0
Rl45 (\3\:SEb \4\:SEb) resistor r=65.6003 c=0
Rl42 (SEb \2\:SEb) resistor r=46.8456 c=0
Rz3 (\2\:Q \1\:Q) resistor r=75 c=0
Rz13 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz14 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz15 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz16 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz20 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz21 (\4\:VDD \1\:VDD) resistor r=18.75 c=0
Rz22 (\6\:VDD \1\:VDD) resistor r=12.5 c=0
Rz23 (\9\:VDD \1\:VDD) resistor r=9.375 c=0
Rz24 (\12\:VDD \1\:VDD) resistor r=9.375 c=0
Rz25 (\13\:VDD \1\:VDD) resistor r=18.75 c=0
Rz2 (\2\:QN \1\:QN) resistor r=75 c=0
Rz4 (\16\:qbint \15\:qbint) resistor r=75 c=0
Rz1 (\10\:qint \9\:qint) resistor r=75 c=0
Rz9 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz5 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz6 (\7\:mout \8\:mout) resistor r=75 c=0
Rz8 (\8\:Ckbb \9\:Ckbb) resistor r=75 c=0
Rz7 (\5\:n20 \6\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\7\:Db \8\:Db) resistor r=75 c=0
Rz12 (\7\:SEb \8\:SEb) resistor r=75 c=0
Ry3 (\4\:Q \3\:Q) resistor r=62 c=0
Ry15 (\4\:VSS \3\:VSS) resistor r=7.75 c=0
Ry16 (\6\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry17 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry18 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry19 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry20 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry21 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry22 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry23 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry2 (\4\:QN \3\:QN) resistor r=62 c=0
Ry4 (\22\:qbint \21\:qbint) resistor r=31 c=0
Ry1 (\12\:qint \11\:qint) resistor r=62 c=0
Ry11 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry5 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry6 (\4\:mout \5\:mout) resistor r=62 c=0
Ry10 (\14\:Ckbb \15\:Ckbb) resistor r=62 c=0
Ry9 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry12 (\3\:Db \4\:Db) resistor r=62 c=0
Ry13 (\5\:Db \6\:Db) resistor r=62 c=0
Ry14 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry7 (n6 \2\:n6) resistor r=62 c=0
Ry8 (\3\:n6 \4\:n6) resistor r=62 c=0
Rx8 (\6\:RN \7\:RN) resistor r=45 c=0
Rx9 (\2\:RN \8\:RN) resistor r=45 c=0
Rx21 (\2\:SE \7\:SE) resistor r=45 c=0
Rx22 (\5\:SE \8\:SE) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx20 (\2\:D \4\:D) resistor r=45 c=0
Rx19 (\2\:SI \4\:SI) resistor r=45 c=0
Rx3 (\20\:qbint \2\:qbint) resistor r=45 c=0
Rx4 (\23\:qbint \14\:qbint) resistor r=45 c=0
Rx1 (\8\:qint qint) resistor r=45 c=0
Rx15 (\9\:CKb \11\:CKb) resistor r=45 c=0
Rx16 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx17 (\4\:CKb \13\:CKb) resistor r=45 c=0
Rx18 (\2\:CKb \14\:CKb) resistor r=45 c=0
Rx7 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx10 (\2\:mout \9\:mout) resistor r=45 c=0
Rx12 (\6\:Ckbb \11\:Ckbb) resistor r=45 c=0
Rx13 (\5\:Ckbb \12\:Ckbb) resistor r=45 c=0
Rx14 (\3\:Ckbb \13\:Ckbb) resistor r=45 c=0
Rx11 (n20 \10\:n20) resistor r=45 c=0
Rx23 (\4\:SEb \10\:SEb) resistor r=45 c=0
Rx24 (\2\:SEb \11\:SEb) resistor r=45 c=0
mn56 (\9\:qint qbint \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.8e-14 ad=2.03e-14 ps=9.6e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.34293e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn57 (\1\:QN qint \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.48e-14 ad=4.16e-14 ps=9e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.87788e-07 sb=1.02404e-06 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mn55 (\1\:Q \4\:qbint \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.68e-14 ad=4.81e-14 ps=9.4e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.97788e-07 sb=6.14038e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(2)
mn20 (\15\:CKb \1\:CK \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.2e-14 ad=4.133e-14 ps=1.04e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26776e-06 sb=2.85e-07 sd=160n sca=12.5912 \
        scb=0.0129007 scc=0.000589158 m=(1)
mn46 (\15\:qbint n30 n9 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=3.998e-14 ps=5.3e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95e-07 sb=1.49512e-06 sd=160n sca=17.1738 \
        scb=0.0176382 scc=0.00148475 m=(1)
mn45 (n9 \3\:RN \16\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=7.39e-14 ad=1.23e-14 ps=1.38e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3e-07 sb=1.46439e-06 sd=160n sca=17.1738 \
        scb=0.0176382 scc=0.00148475 m=(1)
mn50 (n11 \13\:qbint \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.39e-14 ad=8.7e-15 ps=1.38e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.65e-07 sb=1.825e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn51 (\8\:n30 CKb n11 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=6.38e-14 ps=4.1e-07 pd=1.17e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.7e-07 sb=1.72e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn40 (\7\:mout \2\:Ckbb \8\:n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.38e-14 ad=3.335e-14 ps=1.17e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.155e-06 sb=1.235e-06 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn30 (\7\:mout \3\:n20 \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.17e-14 ad=3.335e-14 ps=1.56e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=9.6e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn35 (n7 \4\:RN \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.17e-14 ad=8.7e-15 ps=1.56e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.695e-06 sb=6.95e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn36 (n5 \3\:mout n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.682e-14 ps=4.1e-07 pd=6.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.8e-06 sb=5.9e-07 sd=160n sca=19.8813 scb=0.0206549 \
        scc=0.00197265 m=(1)
mn37 (\5\:n20 \4\:Ckbb n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.537e-14 ps=6.6e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.6e-07 sd=160n sca=19.8813 scb=0.0206549 \
        scc=0.00197265 m=(1)
mn25 (\7\:Db \5\:CKb \5\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.537e-14 ad=2.03e-14 ps=6.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=19.8813 scb=0.0206549 \
        scc=0.00197265 m=(1)
mn21 (\8\:Ckbb \10\:CKb \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.392e-14 ad=2.03e-14 ps=6.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.25e-06 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn13 (n3 \3\:SI \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.392e-14 ad=4.06e-14 ps=6.2e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.04e-06 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn14 (Db \3\:SE n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=4.06e-14 \
        ad=2.32e-14 ps=8.5e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.75e-07 sb=7.15e-07 sd=160n sca=10.4914 scb=0.00978575 \
        scc=0.000300434 m=(1)
mn12 (Db \3\:SEb n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.8e-07 sb=5.1e-07 sd=160n sca=10.4914 scb=0.00978575 \
        scc=0.000300434 m=(1)
mn11 (n1 \3\:D \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.79e-14 ad=8.7e-15 ps=1.33e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=4.05e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn10 (\7\:SEb \4\:SE \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.79e-14 ad=2.03e-14 ps=1.33e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-06 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp57 (\3\:QN qint \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.742e-14 ad=7.215e-14 ps=1.32e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.99551e-07 sb=1.02833e-06 sd=160n sca=32.8253 \
        scb=0.0223774 scc=0.00336999 m=(2)
mp55 (\3\:Q \4\:qbint \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.376e-14 ad=7.215e-14 ps=1.44e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.94551e-07 sb=5.33333e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(2)
mp20 (\17\:CKb \3\:CK \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.572e-14 ad=4.67e-14 ps=1.56e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=2.17209e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp46 (\21\:qbint \3\:n30 \27\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.39e-14 ad=4.96e-14 ps=1.14e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.06774e-07 sb=1.38347e-06 sd=160n sca=18.5208 \
        scb=0.0170531 scc=0.00159934 m=(1)
mp45 (\21\:qbint \1\:RN \25\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=7.303e-14 ad=4.96e-14 ps=1.81e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.11774e-07 sb=1.17847e-06 sd=160n sca=18.5208 \
        scb=0.0170531 scc=0.00159934 m=(1)
mp50 (n8 \12\:qbint \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.303e-14 ad=4.3e-14 ps=1.81e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=1.435e-06 sd=160n sca=21.9815 \
        scb=0.0208641 scc=0.00225088 m=(1)
mp51 (\4\:n30 Ckbb n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=5.482e-14 ps=8.3e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=1.19e-06 sd=160n sca=21.9815 \
        scb=0.0208641 scc=0.00225088 m=(1)
mp40 (\4\:n30 \3\:CKb \4\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.912e-14 ad=5.483e-14 ps=9.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.07e-06 sb=8.9e-07 sd=160n sca=21.9815 \
        scb=0.0208641 scc=0.00225088 m=(1)
mp30 (\4\:mout \4\:n20 \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.29e-14 ad=5.913e-14 ps=1.76e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.39e-06 sb=5.7e-07 sd=160n sca=21.9815 \
        scb=0.0208641 scc=0.00225088 m=(1)
mp35 (\3\:n6 \5\:RN \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.29e-14 ad=3.44e-14 ps=1.76e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.585e-06 sb=3.75e-07 sd=160n sca=21.9815 \
        scb=0.0208641 scc=0.00225088 m=(1)
mp36 (\3\:n6 mout \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.075e-14 ad=3.44e-14 ps=1.34e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.79e-06 sb=1.7e-07 sd=160n sca=21.9815 \
        scb=0.0208641 scc=0.00225088 m=(1)
mp37 (\8\:n20 \6\:CKb n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=37.431 \
        scb=0.0268495 scc=0.00487383 m=(1)
mp25 (\8\:n20 \7\:Ckbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=37.431 \
        scb=0.0268495 scc=0.00487383 m=(1)
mp21 (\14\:Ckbb \8\:CKb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.042e-14 ad=3.01e-14 ps=1.92e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.2e-06 sd=160n sca=35.2411 \
        scb=0.0263265 scc=0.00456529 m=(1)
mp12 (\3\:Db \1\:SE n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.763e-14 ad=5.698e-14 ps=7.8e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.65e-07 sb=5.75e-07 sd=160n sca=35.7281 \
        scb=0.0264923 scc=0.00456533 m=(1)
mp13 (n4 \1\:SI \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.042e-14 ad=1.29e-14 ps=1.92e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=9.9e-07 sd=160n sca=35.2411 \
        scb=0.0263265 scc=0.00456529 m=(1)
mp14 (\3\:Db SEb n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=5.698e-14 ps=5.5e-07 pd=9.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=4.55e-07 sb=8.85e-07 sd=160n sca=35.2411 scb=0.0263265 \
        scc=0.00456529 m=(1)
mp11 (n2 \1\:D \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.97e-14 ad=3.763e-14 ps=1.9e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=3.55e-07 sd=160n sca=36.9533 \
        scb=0.0276367 scc=0.0045683 m=(1)
mp10 (\5\:SEb \6\:SE \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.97e-14 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2e-06 sb=1.4e-07 sd=160n sca=40.6333 \
        scb=0.0337853 scc=0.00470903 m=(1)
ends SDFFRX2
// End of subcircuit definition.

// Generated for: spectre (May  9 17:34:30 2012 )
// Library name: gsclib045
// Cell name: SDFFRX4
// View name: extracted

simulator lang=spectre

subckt SDFFRX4 CK D Q QN RN SE SI VDD VSS
mp10 (\8\:SEb \1\:SE \42\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.32e-06 sd=160n sca=14.1047 \
        scb=0.0123052 scc=0.000144089 m=(1)
C1 (Q VSS) capacitor c=2.31822e-17
C2 (RN VSS) capacitor c=1.1789e-17
C3 (CK VSS) capacitor c=7.85454e-17
C4 (SI VSS) capacitor c=5.25708e-17
C5 (QN VSS) capacitor c=1.98462e-17
C6 (VDD VSS) capacitor c=4.79394e-16
C7 (D VSS) capacitor c=3.89391e-17
C8 (SEb VSS) capacitor c=6.24312e-17
C9 (n3 VSS) capacitor c=8.64555e-20
C10 (Db VSS) capacitor c=6.91022e-17
C11 (n1 VSS) capacitor c=4.33203e-18
C12 (CKb VSS) capacitor c=1.51749e-17
C13 (Ckbb VSS) capacitor c=5.00399e-17
C14 (n20 VSS) capacitor c=5.92933e-17
C15 (mout VSS) capacitor c=9.39882e-17
C16 (n30 VSS) capacitor c=9.34106e-17
C17 (n11 VSS) capacitor c=9.10397e-19
C18 (qbint VSS) capacitor c=6.16532e-17
C19 (29 VSS) capacitor c=1.18163e-18
C20 (qint VSS) capacitor c=2.86154e-16
C21 (n6 VSS) capacitor c=7.00182e-17
C22 (n8 VSS) capacitor c=2.23881e-18
C23 (\23\:qbint VSS) capacitor c=4.74243e-17
C24 (\4\:qbint VSS) capacitor c=2.65714e-16
C25 (\3\:qbint VSS) capacitor c=3.24131e-17
C26 (\5\:Ckbb VSS) capacitor c=7.6847e-17
C27 (\9\:CKb VSS) capacitor c=5.19175e-17
C28 (\1\:RN VSS) capacitor c=4.56211e-17
C29 (\3\:mout VSS) capacitor c=3.72028e-17
C30 (\6\:CKb VSS) capacitor c=3.6431e-17
C31 (\4\:CKb VSS) capacitor c=2.29215e-17
C32 (\1\:CK VSS) capacitor c=5.4399e-17
C33 (\1\:D VSS) capacitor c=9.01875e-17
C34 (\6\:SE VSS) capacitor c=5.89738e-17
C35 (\3\:SEb VSS) capacitor c=2.81916e-17
C36 (\1\:SI VSS) capacitor c=5.55561e-17
C37 (\1\:SE VSS) capacitor c=5.69424e-17
C38 (\21\:qbint VSS) capacitor c=3.07287e-17
C39 (\9\:RN VSS) capacitor c=4.8411e-17
C40 (\6\:n30 VSS) capacitor c=3.23425e-17
C41 (\5\:n30 VSS) capacitor c=4.25244e-17
C42 (\4\:RN VSS) capacitor c=4.938e-17
C43 (\11\:CKb VSS) capacitor c=5.85869e-17
C44 (\6\:Ckbb VSS) capacitor c=7.97056e-17
C45 (\4\:n20 VSS) capacitor c=3.41986e-17
C46 (\3\:RN VSS) capacitor c=5.42553e-17
C47 (\3\:Ckbb VSS) capacitor c=6.74101e-17
C48 (\8\:CKb VSS) capacitor c=3.78276e-17
C49 (\3\:CK VSS) capacitor c=2.57512e-17
C50 (\3\:D VSS) capacitor c=3.71025e-17
C51 (\4\:SE VSS) capacitor c=6.47092e-17
C52 (\3\:SI VSS) capacitor c=6.46132e-17
C53 (\3\:SE VSS) capacitor c=2.17335e-17
C54 (\22\:qbint VSS) capacitor c=3.11719e-17
C55 (\13\:qbint VSS) capacitor c=2.54756e-17
C56 (\7\:n30 VSS) capacitor c=1.38678e-17
C57 (\5\:RN VSS) capacitor c=4.45275e-16
C58 (\2\:qbint VSS) capacitor c=4.53904e-17
C59 (\12\:CKb VSS) capacitor c=4.5374e-17
C60 (\10\:CKb VSS) capacitor c=2.31268e-17
C61 (\3\:n20 VSS) capacitor c=2.97771e-17
C62 (\7\:Ckbb VSS) capacitor c=4.61819e-17
C63 (\2\:RN VSS) capacitor c=5.70574e-17
C64 (\2\:mout VSS) capacitor c=5.77096e-17
C65 (\4\:Ckbb VSS) capacitor c=2.471e-17
C66 (\7\:CKb VSS) capacitor c=2.53288e-17
C67 (\2\:Ckbb VSS) capacitor c=3.69967e-17
C68 (\5\:CKb VSS) capacitor c=2.52069e-17
C69 (\3\:CKb VSS) capacitor c=7.26224e-18
C70 (\2\:CK VSS) capacitor c=5.11601e-17
C71 (\2\:D VSS) capacitor c=5.47607e-17
C72 (\7\:SE VSS) capacitor c=4.25082e-17
C73 (\2\:SEb VSS) capacitor c=5.40599e-17
C74 (\5\:SE VSS) capacitor c=4.89811e-17
C75 (\2\:SI VSS) capacitor c=6.80419e-17
C76 (\2\:SE VSS) capacitor c=5.89299e-17
C77 (\19\:qint VSS) capacitor c=3.68503e-17
C78 (\1\:QN VSS) capacitor c=1.70236e-16
C79 (\1\:Q VSS) capacitor c=1.74512e-16
C80 (\25\:VDD VSS) capacitor c=3.46948e-17
C81 (\13\:n30 VSS) capacitor c=8.93519e-17
C82 (\8\:mout VSS) capacitor c=2.18491e-17
C83 (\29\:VDD VSS) capacitor c=2.10721e-17
C84 (\3\:n6 VSS) capacitor c=7.21459e-17
C85 (\31\:VDD VSS) capacitor c=1.77303e-17
C86 (\7\:n20 VSS) capacitor c=7.35997e-17
C87 (\3\:Db VSS) capacitor c=2.60155e-16
C88 (\13\:Ckbb VSS) capacitor c=5.04555e-17
C89 (\34\:VDD VSS) capacitor c=4.78114e-17
C90 (\17\:CKb VSS) capacitor c=8.98143e-17
C91 (\38\:VDD VSS) capacitor c=4.26446e-17
C92 (\8\:Db VSS) capacitor c=1.60038e-17
C93 (\42\:VDD VSS) capacitor c=2.8922e-17
C94 (\8\:SEb VSS) capacitor c=1.46711e-17
C95 (\1\:VDD VSS) capacitor c=2.12686e-16
C96 (\15\:qint VSS) capacitor c=4.19871e-17
C97 (\4\:QN VSS) capacitor c=1.15988e-16
C98 (\35\:qbint VSS) capacitor c=1.08513e-16
C99 (\15\:n30 VSS) capacitor c=2.70168e-17
C100 (\4\:mout VSS) capacitor c=8.27078e-17
C101 (\9\:n20 VSS) capacitor c=2.60665e-17
C102 (\11\:Ckbb VSS) capacitor c=3.29927e-17
C103 (\15\:CKb VSS) capacitor c=5.67776e-17
C104 (\6\:Db VSS) capacitor c=1.20838e-16
C105 (\6\:SEb VSS) capacitor c=7.09474e-17
C106 (\2\:CKb VSS) capacitor c=8.40276e-18
C107 (\2\:n20 VSS) capacitor c=2.88763e-17
C108 (\3\:n30 VSS) capacitor c=2.79454e-17
C109 (\4\:n30 VSS) capacitor c=2.87694e-17
C110 (\4\:SI VSS) capacitor c=5.84378e-17
C111 (\4\:SEb VSS) capacitor c=6.57531e-17
C112 (\5\:SEb VSS) capacitor c=8.54787e-17
C113 (\8\:SE VSS) capacitor c=1.88172e-16
C114 (\9\:SE VSS) capacitor c=1.40562e-16
C115 (\10\:SE VSS) capacitor c=3.23456e-17
C116 (\11\:SE VSS) capacitor c=4.46306e-17
C117 (\5\:D VSS) capacitor c=9.38577e-17
C118 (\4\:CK VSS) capacitor c=4.18933e-17
C119 (\13\:CKb VSS) capacitor c=3.36447e-17
C120 (\14\:CKb VSS) capacitor c=7.99407e-17
C121 (\5\:Db VSS) capacitor c=2.70686e-16
C122 (\8\:Ckbb VSS) capacitor c=4.42307e-17
C123 (\9\:Ckbb VSS) capacitor c=9.59489e-17
C124 (\10\:Ckbb VSS) capacitor c=7.68066e-17
C125 (\5\:n20 VSS) capacitor c=7.7597e-17
C126 (\6\:n20 VSS) capacitor c=7.05342e-17
C127 (\6\:mout VSS) capacitor c=1.14139e-16
C128 (\7\:mout VSS) capacitor c=9.56247e-17
C129 (\19\:CKb VSS) capacitor c=1.61108e-16
C130 (\20\:CKb VSS) capacitor c=6.47443e-17
C131 (\21\:CKb VSS) capacitor c=1.60866e-16
C132 (\22\:CKb VSS) capacitor c=1.10819e-16
C133 (\11\:n30 VSS) capacitor c=1.27076e-16
C134 (\12\:n30 VSS) capacitor c=1.42544e-16
C135 (\11\:RN VSS) capacitor c=1.9841e-16
C136 (\12\:RN VSS) capacitor c=8.84374e-17
C137 (\24\:qbint VSS) capacitor c=3.89478e-17
C138 (\25\:qbint VSS) capacitor c=1.84635e-16
C139 (\27\:qbint VSS) capacitor c=6.48246e-17
C140 (\4\:Q VSS) capacitor c=1.23692e-16
C141 (\32\:qbint VSS) capacitor c=1.2772e-16
C142 (\33\:qbint VSS) capacitor c=2.28276e-16
C143 (\34\:qbint VSS) capacitor c=4.06517e-17
C144 (\17\:qint VSS) capacitor c=3.4429e-17
C145 (\18\:qint VSS) capacitor c=3.02705e-17
C146 (\3\:VDD VSS) capacitor c=4.97215e-16
C147 (\13\:VDD VSS) capacitor c=1.5836e-17
C148 (\33\:VDD VSS) capacitor c=2.10037e-17
C149 (\37\:VDD VSS) capacitor c=2.42174e-18
C150 (\41\:VDD VSS) capacitor c=8.09952e-18
Rk47 (\1\:Q Q) resistor r=0.07816 c=0
Rk48 (Q \4\:Q) resistor r=0.2117 c=0
Rk5 (\8\:SE \9\:SE) resistor r=1.2212 c=0
Rk6 (\9\:SE \10\:SE) resistor r=0.0935 c=0
Rk8 (\11\:SE SE) resistor r=0.003679 c=0
Rk7 (\9\:SE \11\:SE) resistor r=0.1995 c=0
Rk40 (\11\:RN RN) resistor r=0.003081 c=0
Rk37 (\5\:RN \11\:RN) resistor r=1.2016 c=0
Rk38 (\11\:RN \12\:RN) resistor r=0.4973 c=0
Rk12 (CK \4\:CK) resistor r=0.1172 c=0
Rk1 (\4\:SI SI) resistor r=0.01562 c=0
Rk53 (\1\:QN QN) resistor r=0.07599 c=0
Rk54 (QN \4\:QN) resistor r=0.2228 c=0
Rk88 (\2\:VDD \3\:VDD) resistor r=0.1127 c=0
Rk97 (\3\:VDD \12\:VDD) resistor r=0.2206 c=0
Rk98 (\12\:VDD \13\:VDD) resistor r=0.2005 c=0
Rk99 (\13\:VDD \14\:VDD) resistor r=0.4023 c=0
Rk105 (\3\:VDD \26\:VDD) resistor r=0.273 c=0
Rk107 (\13\:VDD \30\:VDD) resistor r=0.1029 c=0
Rk108 (\14\:VDD \32\:VDD) resistor r=0.0715 c=0
Rk109 (\14\:VDD \33\:VDD) resistor r=0.3987 c=0
Rk110 (\33\:VDD \35\:VDD) resistor r=0.2398 c=0
Rk111 (\33\:VDD \36\:VDD) resistor r=0.1528 c=0
Rk112 (\36\:VDD \37\:VDD) resistor r=0.1679 c=0
Rk113 (\37\:VDD \39\:VDD) resistor r=0.184 c=0
Rk114 (\37\:VDD \40\:VDD) resistor r=0.1829 c=0
Rk115 (\40\:VDD \41\:VDD) resistor r=0.2482 c=0
Rk116 (\41\:VDD \43\:VDD) resistor r=0.1747 c=0
Rk118 (\44\:VDD VDD) resistor r=0.1001 c=0
Rk117 (\41\:VDD \44\:VDD) resistor r=0.1027 c=0
Rk11 (D \5\:D) resistor r=0.06012 c=0
Rk69 (\1\:VSS \10\:VSS) resistor r=0.4427 c=0
Rk70 (\10\:VSS \11\:VSS) resistor r=0.2507 c=0
Rk71 (\11\:VSS \12\:VSS) resistor r=0.2632 c=0
Rk72 (\12\:VSS \13\:VSS) resistor r=0.188 c=0
Rk73 (\13\:VSS \14\:VSS) resistor r=0.6746 c=0
Rk74 (\14\:VSS \15\:VSS) resistor r=0.1277 c=0
Rk75 (\15\:VSS \16\:VSS) resistor r=0.1353 c=0
Rk76 (\16\:VSS \17\:VSS) resistor r=0.4737 c=0
Rk78 (\18\:VSS VSS) resistor r=0.04992 c=0
Rk77 (\17\:VSS \18\:VSS) resistor r=0.09262 c=0
Rk83 (\10\:VSS \28\:VSS) resistor r=0.1029 c=0
Rk84 (\12\:VSS \30\:VSS) resistor r=0.3271 c=0
Rk85 (\14\:VSS \32\:VSS) resistor r=0.3759 c=0
Rk86 (\16\:VSS \34\:VSS) resistor r=0.2753 c=0
Rk87 (\17\:VSS \36\:VSS) resistor r=0.2756 c=0
Rk2 (\4\:SEb \5\:SEb) resistor r=0.42 c=0
Rk3 (\5\:SEb \7\:SEb) resistor r=0.669 c=0
Rk4 (\5\:SEb \9\:SEb) resistor r=0.04813 c=0
Rk16 (\2\:Db \4\:Db) resistor r=0.4418 c=0
Rk17 (\4\:Db \5\:Db) resistor r=1.6409 c=0
Rk18 (\5\:Db \7\:Db) resistor r=0.7439 c=0
Rk19 (\5\:Db \9\:Db) resistor r=0.0745 c=0
Rk13 (\13\:CKb \14\:CKb) resistor r=0.1766 c=0
Rk14 (\14\:CKb \16\:CKb) resistor r=0.2999 c=0
Rk15 (\14\:CKb \18\:CKb) resistor r=0.4265 c=0
Rk31 (\19\:CKb \20\:CKb) resistor r=0.3441 c=0
Rk32 (\19\:CKb \21\:CKb) resistor r=1.0203 c=0
Rk33 (\21\:CKb \22\:CKb) resistor r=0.6479 c=0
Rk21 (\8\:Ckbb \9\:Ckbb) resistor r=0.2893 c=0
Rk22 (\9\:Ckbb \10\:Ckbb) resistor r=0.7846 c=0
Rk23 (\10\:Ckbb \12\:Ckbb) resistor r=0.1632 c=0
Rk24 (\12\:Ckbb \14\:Ckbb) resistor r=0.2407 c=0
Rk25 (\5\:n20 \6\:n20) resistor r=0.4458 c=0
Rk26 (\6\:n20 \8\:n20) resistor r=0.346 c=0
Rk27 (\6\:n20 \10\:n20) resistor r=0.1277 c=0
Rk28 (\5\:mout \6\:mout) resistor r=0.4669 c=0
Rk29 (\6\:mout \7\:mout) resistor r=0.5867 c=0
Rk30 (\6\:mout \9\:mout) resistor r=0.03287 c=0
Rk34 (\11\:n30 \12\:n30) resistor r=0.7801 c=0
Rk35 (\12\:n30 \14\:n30) resistor r=0.5019 c=0
Rk36 (\12\:n30 \16\:n30) resistor r=0.03063 c=0
Rk41 (\24\:qbint \25\:qbint) resistor r=0.2725 c=0
Rk43 (\25\:qbint \27\:qbint) resistor r=0.3392 c=0
Rk57 (\32\:qbint \33\:qbint) resistor r=1.0529 c=0
Rk58 (\33\:qbint \34\:qbint) resistor r=0.2134 c=0
Rk59 (\33\:qbint \36\:qbint) resistor r=0.9778 c=0
Rk60 (\16\:qint \17\:qint) resistor r=0.2712 c=0
Rk61 (\17\:qint \18\:qint) resistor r=0.1876 c=0
Rk62 (\17\:qint \20\:qint) resistor r=0.1489 c=0
Rk20 (\2\:n6 \4\:n6) resistor r=0.2612 c=0
Rl8 (\6\:SE \7\:SE) resistor r=73.7687 c=0
Rl5 (\4\:SE \5\:SE) resistor r=43.4636 c=0
Rl1 (\1\:SE \2\:SE) resistor r=236.104 c=0
Rl2 (\2\:SE \3\:SE) resistor r=39.5604 c=0
Rl47 (\5\:RN \9\:RN) resistor r=30.5643 c=0
Rl34 (\5\:RN \4\:RN) resistor r=26.9231 c=0
Rl23 (\2\:RN \1\:RN) resistor r=63.4615 c=0
Rl24 (\2\:RN \3\:RN) resistor r=87.9121 c=0
Rl11 (\1\:CK \2\:CK) resistor r=219.923 c=0
Rl12 (\2\:CK \3\:CK) resistor r=46.8456 c=0
Rl3 (\1\:SI \2\:SI) resistor r=148.077 c=0
Rl4 (\2\:SI \3\:SI) resistor r=120.33 c=0
Rl9 (\1\:D \2\:D) resistor r=179.538 c=0
Rl10 (\2\:D \3\:D) resistor r=88.2781 c=0
Rl6 (SEb \2\:SEb) resistor r=236.583 c=0
Rl7 (\2\:SEb \3\:SEb) resistor r=24.2328 c=0
Rl19 (\6\:CKb \8\:CKb) resistor r=125 c=0
Rl31 (\11\:CKb \12\:CKb) resistor r=49.2328 c=0
Rl28 (\9\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl18 (\6\:CKb \7\:CKb) resistor r=29.5379 c=0
Rl16 (\4\:CKb \5\:CKb) resistor r=84.9359 c=0
Rl13 (CKb \2\:CKb) resistor r=36.2526 c=0
Rl15 (\2\:CKb \4\:CKb) resistor r=47.791 c=0
Rl14 (\2\:CKb \3\:CKb) resistor r=1.2666 c=0
Rl29 (\5\:Ckbb \6\:Ckbb) resistor r=201.161 c=0
Rl30 (\6\:Ckbb \7\:Ckbb) resistor r=291.821 c=0
Rl20 (\3\:Ckbb \4\:Ckbb) resistor r=53.079 c=0
Rl17 (Ckbb \2\:Ckbb) resistor r=121.131 c=0
Rl25 (n20 \2\:n20) resistor r=143.464 c=0
Rl27 (\2\:n20 \4\:n20) resistor r=28.0797 c=0
Rl26 (\2\:n20 \3\:n20) resistor r=64.2411 c=0
Rl21 (mout \2\:mout) resistor r=122.31 c=0
Rl22 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl42 (n30 \7\:n30) resistor r=11.572 c=0
Rl37 (\3\:n30 n30) resistor r=95.1951 c=0
Rl40 (\3\:n30 \6\:n30) resistor r=37.6951 c=0
Rl39 (\4\:n30 \5\:n30) resistor r=34.6788 c=0
Rl41 (\4\:n30 \7\:n30) resistor r=20.9149 c=0
Rl38 (\4\:n30 \3\:n30) resistor r=98.4217 c=0
Rl78 (\22\:qbint \23\:qbint) resistor r=78.6412 c=0
Rl77 (\22\:qbint \21\:qbint) resistor r=32.6802 c=0
Rl56 (\4\:qbint \13\:qbint) resistor r=7.553 c=0
Rl32 (\2\:qbint qbint) resistor r=125 c=0
Rl33 (\2\:qbint \3\:qbint) resistor r=26.3736 c=0
Rz25 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz27 (\3\:VDD \1\:VDD) resistor r=5 c=0
Rz28 (\12\:VDD \1\:VDD) resistor r=18.75 c=0
Rz29 (\14\:VDD \1\:VDD) resistor r=9.375 c=0
Rz30 (\36\:VDD \1\:VDD) resistor r=25 c=0
Rz31 (\40\:VDD \1\:VDD) resistor r=18.75 c=0
Rz32 (\44\:VDD \1\:VDD) resistor r=25 c=0
Rz20 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz21 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz22 (\32\:VSS \31\:VSS) resistor r=75 c=0
Rz23 (\34\:VSS \33\:VSS) resistor r=75 c=0
Rz24 (\36\:VSS \35\:VSS) resistor r=75 c=0
Rz1 (\6\:SEb \7\:SEb) resistor r=75 c=0
Rz3 (Db \2\:Db) resistor r=75 c=0
Rz4 (\6\:Db \7\:Db) resistor r=75 c=0
Rz2 (\15\:CKb \16\:CKb) resistor r=75 c=0
Rz5 (\11\:Ckbb \12\:Ckbb) resistor r=75 c=0
Rz6 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz7 (\4\:mout \5\:mout) resistor r=75 c=0
Rz8 (\16\:n30 \15\:n30) resistor r=75 c=0
Rz13 (\36\:qbint \35\:qbint) resistor r=75 c=0
Rz14 (\16\:qint \15\:qint) resistor r=75 c=0
Ry29 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry31 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry32 (\32\:VDD \31\:VDD) resistor r=62 c=0
Ry33 (\35\:VDD \34\:VDD) resistor r=62 c=0
Ry34 (\39\:VDD \38\:VDD) resistor r=62 c=0
Ry35 (\43\:VDD \42\:VDD) resistor r=62 c=0
Ry19 (\1\:VSS \3\:VSS) resistor r=3.875 c=0
Ry20 (\11\:VSS \3\:VSS) resistor r=12.4 c=0
Ry21 (\13\:VSS \3\:VSS) resistor r=15.5 c=0
Ry22 (\15\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry23 (\18\:VSS \3\:VSS) resistor r=31 c=0
Ry1 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry3 (\3\:Db \4\:Db) resistor r=62 c=0
Ry4 (\8\:Db \9\:Db) resistor r=62 c=0
Ry2 (\17\:CKb \18\:CKb) resistor r=62 c=0
Ry7 (\13\:Ckbb \14\:Ckbb) resistor r=62 c=0
Ry8 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry9 (\8\:mout \9\:mout) resistor r=62 c=0
Ry10 (\14\:n30 \13\:n30) resistor r=62 c=0
Ry17 (\20\:qint \19\:qint) resistor r=20.6667 c=0
Ry5 (n6 \2\:n6) resistor r=62 c=0
Ry6 (\3\:n6 \4\:n6) resistor r=62 c=0
Rx3 (\7\:SE \8\:SE) resistor r=45 c=0
Rx4 (\5\:SE \10\:SE) resistor r=45 c=0
Rx5 (\2\:SE \11\:SE) resistor r=45 c=0
Rx20 (\12\:RN \2\:RN) resistor r=45 c=0
Rx7 (\2\:CK \4\:CK) resistor r=45 c=0
Rx1 (\2\:SI \4\:SI) resistor r=45 c=0
Rx6 (\2\:D \5\:D) resistor r=45 c=0
Rx2 (\2\:SEb \4\:SEb) resistor r=45 c=0
Rx8 (\3\:CKb \13\:CKb) resistor r=45 c=0
Rx14 (\7\:CKb \19\:CKb) resistor r=45 c=0
Rx15 (\5\:CKb \20\:CKb) resistor r=45 c=0
Rx16 (\10\:CKb \21\:CKb) resistor r=45 c=0
Rx17 (\12\:CKb \22\:CKb) resistor r=45 c=0
Rx9 (\7\:Ckbb \8\:Ckbb) resistor r=45 c=0
Rx10 (\4\:Ckbb \9\:Ckbb) resistor r=45 c=0
Rx11 (\2\:Ckbb \10\:Ckbb) resistor r=45 c=0
Rx12 (\3\:n20 \5\:n20) resistor r=45 c=0
Rx13 (\2\:mout \7\:mout) resistor r=45 c=0
Rx18 (\11\:n30 \7\:n30) resistor r=45 c=0
Rx22 (\24\:qbint \13\:qbint) resistor r=45 c=0
Rx23 (\27\:qbint \2\:qbint) resistor r=45 c=0
Rx24 (\32\:qbint \22\:qbint) resistor r=45 c=0
Rx25 (\34\:qbint \4\:qbint) resistor r=45 c=0
Rx26 (\18\:qint qint) resistor r=45 c=0
mn10 (\6\:SEb \3\:SE \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.263e-14 ad=2.465e-14 ps=7.4e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.325e-06 sd=160n sca=9.68855 \
        scb=0.00848242 scc=0.000213356 m=(1)
mn14 (\6\:Db \4\:SE n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.45e-07 sb=9.5e-07 sd=160n sca=9.68855 \
        scb=0.00848242 scc=0.000213356 m=(1)
mn13 (n3 \3\:SI \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.263e-14 ad=8.7e-15 ps=7.4e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.4e-07 sb=1.055e-06 sd=160n sca=9.68855 \
        scb=0.00848242 scc=0.000213356 m=(1)
mn12 (\6\:Db SEb n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=4.64e-14 \
        ad=2.32e-14 ps=9.3e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.5e-07 sb=7.45e-07 sd=160n sca=9.68855 scb=0.00848242 \
        scc=0.000213356 m=(1)
mn11 (n1 \3\:D \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.828e-14 ad=4.64e-14 ps=6.8e-07 pd=9.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=3.8e-07 sd=160n sca=9.68855 \
        scb=0.00848242 scc=0.000213356 m=(1)
mn20 (\15\:CKb \3\:CK \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.828e-14 ad=2.03e-14 ps=6.8e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.355e-06 sb=1.4e-07 sd=160n sca=9.68855 \
        scb=0.00848242 scc=0.000213356 m=(1)
mn21 (\11\:Ckbb CKb \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.973e-14 ad=2.03e-14 ps=7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (Db \8\:CKb \9\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.843e-14 ad=2.03e-14 ps=8.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn37 (\9\:n20 \3\:Ckbb n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.843e-14 ps=4.1e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn36 (n5 mout n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=9.43e-15 \
        ad=8.7e-15 ps=4.2e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.55e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn35 (n7 \3\:RN \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.018e-14 ad=9.43e-15 ps=1.12e-06 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65e-07 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn30 (\4\:mout \4\:n20 \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.018e-14 ad=3.625e-14 ps=1.12e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn40 (\4\:mout \6\:Ckbb \15\:n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.48e-14 ad=3.625e-14 ps=7.7e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.42e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn51 (\15\:n30 \11\:CKb n11 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.232e-14 ad=3.48e-14 ps=4.6e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.705e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn50 (n11 qbint \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.923e-14 ad=1.233e-14 ps=1.6e-06 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.835e-06 sb=2e-06 sd=160n sca=13.253 scb=0.0137915 \
        scc=0.000695334 m=(1)
mn45_1__rcx (28 \4\:RN \27\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=8.923e-14 ad=1.23e-14 ps=1.6e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.46439e-06 sb=2e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn46_1__rcx (\35\:qbint \5\:n30 28 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=1.23e-14 ad=6.048e-14 ps=5.3e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.49512e-06 sb=2e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn46 (\35\:qbint \6\:n30 29 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=6.048e-14 ps=6.1e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.59463e-06 sb=2e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn45 (29 \9\:RN \1\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=8.265e-14 ad=2.05e-14 ps=1.43e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.63707e-06 sb=2e-06 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn55_1__rcx (\4\:Q \4\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.471e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38788e-06 sb=2e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(4)
mn57_1__rcx (\4\:QN qint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.54e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.80365e-06 sb=1.1e-06 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(4)
mn56 (\15\:qint \21\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.54e-14 ad=4.16e-14 ps=1.43e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.6e-07 sd=160n sca=10.79 scb=0.0100512 \
        scc=0.000418069 m=(1)
mp13 (n4 \1\:SI \42\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=4.193e-14 ps=7.5e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.115e-06 sd=160n sca=11.6656 \
        scb=0.00859665 scc=9.9547e-05 m=(1)
mp14 (\8\:Db \3\:SEb n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.192e-14 ad=5.697e-14 ps=8.2e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.85e-07 sb=8.75e-07 sd=160n sca=10.6337 \
        scb=0.00785382 scc=9.84653e-05 m=(1)
mp12 (\8\:Db \6\:SE n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.697e-14 ps=5.5e-07 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.95e-07 sb=5.65e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp11 (n2 \1\:D \38\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=1.29e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=4.6e-07 sd=160n sca=10.3756 scb=0.00778655 \
        scc=9.84544e-05 m=(1)
mp20 (\17\:CKb \1\:CK \38\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=5.483e-14 ps=7.5e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.205e-06 sb=2.55e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp21 (\13\:Ckbb \4\:CKb \34\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.98e-14 ad=3.01e-14 ps=1.44e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=45.7906 scb=0.0283307 \
        scc=0.00588417 m=(1)
mp25 (\7\:n20 Ckbb \3\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.8e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp37 (\7\:n20 \6\:CKb n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.762e-14 ad=3.44e-14 ps=7.8e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.75e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp36 (\3\:n6 \3\:mout \31\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.795e-14 ad=3.44e-14 ps=1.81e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.47674e-07 sb=2e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp35 (\3\:n6 \1\:RN \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1823e-13 ad=3.44e-14 ps=1.87e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.52674e-07 sb=2e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp30 (\8\:mout n20 \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1823e-13 ad=3.44e-14 ps=1.87e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.32674e-07 sb=2e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\13\:n30 \9\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.762e-14 ps=7.5e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.37674e-07 sb=2e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp51 (\13\:n30 \5\:Ckbb n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.762e-14 ps=7.6e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15767e-06 sb=2e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp50 (n8 \3\:qbint \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.97e-14 ad=3.548e-14 ps=1.18e-06 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.36767e-06 sb=2e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp45 (\25\:qbint \5\:RN \3\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.47e-14 ad=4.96e-14 ps=1.33e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.2046e-06 sb=2e-06 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(2)
mp46_1__rcx (\25\:qbint n30 \25\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.145e-14 ad=4.96e-14 ps=1.21e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.40073e-06 sb=2e-06 sd=160n sca=13.6224 \
        scb=0.0125368 scc=0.000630866 m=(2)
mp55_1__rcx (\1\:Q \4\:qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.672e-14 ad=6.24e-14 ps=1.195e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.43455e-06 sb=1.82e-06 sd=160n sca=19.0259 \
        scb=0.0163587 scc=0.00171562 m=(4)
mp57_1__rcx (\1\:QN qint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.337e-14 ad=6.825e-14 ps=1.105e-06 pd=1.13e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.78667e-06 sb=1e-06 sd=160n \
        sca=19.0259 scb=0.0163587 scc=0.00171562 m=(4)
mp56 (\19\:qint \23\:qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.63e-14 ad=5.46e-14 ps=1.12e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.96308e-06 sb=1.4e-07 sd=160n sca=25.3022 \
        scb=0.0253386 scc=0.00193759 m=(1)
ends SDFFRX4
// End of subcircuit definition.

// Generated for: spectre (May  9 17:35:08 2012 )
// Library name: gsclib045
// Cell name: SDFFRXL
// View name: extracted

simulator lang=spectre

subckt SDFFRXL CK D Q QN RN SE SI VDD VSS
mp57 (\1\:QN \4\:qint \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=3.01e-14 ps=8.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=50.5874 \
        scb=0.0347407 scc=0.00598541 m=(1)
C1 (QN VSS) capacitor c=2.11743e-17
C2 (RN VSS) capacitor c=6.23722e-17
C3 (SE VSS) capacitor c=3.88963e-17
C4 (CK VSS) capacitor c=8.14255e-17
C5 (SI VSS) capacitor c=1.11445e-16
C6 (VDD VSS) capacitor c=3.72705e-16
C7 (D VSS) capacitor c=7.0526e-17
C8 (Q VSS) capacitor c=6.83209e-17
C9 (qint VSS) capacitor c=2.17139e-17
C10 (qbint VSS) capacitor c=4.87208e-17
C11 (CKb VSS) capacitor c=6.36103e-17
C12 (n9 VSS) capacitor c=1.2869e-18
C13 (n30 VSS) capacitor c=5.14518e-17
C14 (n11 VSS) capacitor c=2.18491e-18
C15 (mout VSS) capacitor c=5.14648e-17
C16 (Ckbb VSS) capacitor c=1.95195e-17
C17 (n20 VSS) capacitor c=3.02213e-17
C18 (n7 VSS) capacitor c=1.5963e-19
C19 (Db VSS) capacitor c=1.31024e-16
C20 (n1 VSS) capacitor c=7.95439e-18
C21 (SEb VSS) capacitor c=3.16354e-17
C22 (n8 VSS) capacitor c=2.31739e-18
C23 (n6 VSS) capacitor c=6.90348e-17
C24 (n2 VSS) capacitor c=4.29239e-18
C25 (\5\:SE VSS) capacitor c=4.07206e-17
C26 (\1\:SI VSS) capacitor c=4.50913e-17
C27 (\1\:SE VSS) capacitor c=4.02787e-17
C28 (\1\:D VSS) capacitor c=6.79003e-17
C29 (\9\:CKb VSS) capacitor c=5.69374e-17
C30 (\8\:Ckbb VSS) capacitor c=5.12662e-17
C31 (\6\:CKb VSS) capacitor c=3.94175e-17
C32 (\6\:RN VSS) capacitor c=7.45642e-17
C33 (\3\:n20 VSS) capacitor c=4.98338e-17
C34 (\3\:CKb VSS) capacitor c=3.6138e-17
C35 (\3\:Ckbb VSS) capacitor c=4.86195e-17
C36 (\8\:qbint VSS) capacitor c=5.61469e-17
C37 (\2\:RN VSS) capacitor c=3.59721e-17
C38 (\1\:CK VSS) capacitor c=4.2034e-17
C39 (\7\:qbint VSS) capacitor c=2.06256e-17
C40 (\4\:qint VSS) capacitor c=2.50547e-17
C41 (\7\:SE VSS) capacitor c=2.09037e-17
C42 (\3\:SI VSS) capacitor c=4.63374e-17
C43 (\3\:SE VSS) capacitor c=6.00305e-17
C44 (\3\:SEb VSS) capacitor c=5.19344e-17
C45 (\4\:D VSS) capacitor c=2.92741e-17
C46 (\8\:CKb VSS) capacitor c=6.99207e-17
C47 (\5\:CKb VSS) capacitor c=4.5252e-17
C48 (\5\:Ckbb VSS) capacitor c=6.8617e-17
C49 (\3\:mout VSS) capacitor c=5.08219e-17
C50 (\5\:RN VSS) capacitor c=8.4029e-17
C51 (\4\:n20 VSS) capacitor c=2.93444e-17
C52 (\10\:qbint VSS) capacitor c=4.9638e-17
C53 (\4\:RN VSS) capacitor c=6.61681e-17
C54 (\2\:n30 VSS) capacitor c=4.98214e-17
C55 (\3\:CK VSS) capacitor c=4.59265e-17
C56 (\5\:qbint VSS) capacitor c=2.33093e-17
C57 (\4\:qbint VSS) capacitor c=2.4775e-17
C58 (\3\:qint VSS) capacitor c=2.96564e-17
C59 (\6\:SE VSS) capacitor c=3.26203e-17
C60 (\2\:SI VSS) capacitor c=5.3938e-17
C61 (\4\:SE VSS) capacitor c=5.51931e-17
C62 (\2\:SEb VSS) capacitor c=8.58573e-17
C63 (\2\:SE VSS) capacitor c=4.43562e-17
C64 (\3\:D VSS) capacitor c=2.44666e-17
C65 (\10\:CKb VSS) capacitor c=2.43548e-17
C66 (\7\:Ckbb VSS) capacitor c=3.83387e-17
C67 (\7\:CKb VSS) capacitor c=2.2334e-17
C68 (\6\:Ckbb VSS) capacitor c=3.09117e-17
C69 (\2\:mout VSS) capacitor c=6.02531e-17
C70 (\7\:RN VSS) capacitor c=2.34091e-17
C71 (\4\:Ckbb VSS) capacitor c=3.2335e-17
C72 (\4\:CKb VSS) capacitor c=3.79614e-17
C73 (\2\:CKb VSS) capacitor c=3.9645e-17
C74 (\9\:qbint VSS) capacitor c=5.11995e-17
C75 (\1\:RN VSS) capacitor c=2.3317e-17
C76 (\3\:RN VSS) capacitor c=4.83798e-17
C77 (\3\:n30 VSS) capacitor c=2.81661e-17
C78 (\2\:CK VSS) capacitor c=5.12156e-17
C79 (\6\:qbint VSS) capacitor c=2.29633e-17
C80 (\4\:SEb VSS) capacitor c=1.05588e-17
C81 (\1\:VDD VSS) capacitor c=3.27607e-17
C82 (\8\:Db VSS) capacitor c=2.2488e-17
C83 (\6\:VDD VSS) capacitor c=1.04e-17
C84 (\13\:Ckbb VSS) capacitor c=8.29153e-17
C85 (\4\:Db VSS) capacitor c=1.4044e-16
C86 (\8\:n20 VSS) capacitor c=4.91982e-17
C87 (\10\:VDD VSS) capacitor c=9.89095e-18
C88 (\3\:n6 VSS) capacitor c=6.69739e-17
C89 (\14\:VDD VSS) capacitor c=1.8129e-17
C90 (\6\:mout VSS) capacitor c=6.26897e-17
C91 (\7\:n30 VSS) capacitor c=8.31662e-17
C92 (\18\:VDD VSS) capacitor c=2.01739e-17
C93 (\11\:qbint VSS) capacitor c=1.01444e-16
C94 (\21\:VDD VSS) capacitor c=3.19321e-17
C95 (\20\:CKb VSS) capacitor c=2.30589e-17
C96 (\25\:VDD VSS) capacitor c=2.61729e-17
C97 (\3\:Q VSS) capacitor c=4.2881e-17
C98 (\9\:qint VSS) capacitor c=3.87488e-17
C99 (\29\:VDD VSS) capacitor c=4.67651e-17
C100 (\1\:QN VSS) capacitor c=2.09331e-17
C101 (\3\:VDD VSS) capacitor c=1.4764e-16
C102 (\8\:SEb VSS) capacitor c=7.61153e-17
C103 (\9\:Ckbb VSS) capacitor c=5.11608e-17
C104 (\6\:Db VSS) capacitor c=5.88176e-17
C105 (\5\:n20 VSS) capacitor c=4.02662e-17
C106 (\8\:mout VSS) capacitor c=2.65153e-17
C107 (\4\:n30 VSS) capacitor c=9.24694e-17
C108 (\14\:qbint VSS) capacitor c=8.74395e-17
C109 (\16\:CKb VSS) capacitor c=1.07153e-16
C110 (\1\:Q VSS) capacitor c=6.30643e-17
C111 (\7\:qint VSS) capacitor c=2.56446e-17
C112 (\3\:QN VSS) capacitor c=2.51189e-17
C113 (\2\:qint VSS) capacitor c=7.65509e-18
C114 (\2\:qbint VSS) capacitor c=3.69076e-17
C115 (\3\:qbint VSS) capacitor c=3.48379e-17
C116 (\2\:Ckbb VSS) capacitor c=4.93658e-17
C117 (\2\:n20 VSS) capacitor c=3.36515e-17
C118 (\2\:D VSS) capacitor c=3.29341e-17
C119 (\5\:qint VSS) capacitor c=2.61331e-17
C120 (\6\:qint VSS) capacitor c=3.40504e-17
C121 (\4\:CK VSS) capacitor c=3.76881e-17
C122 (\13\:qbint VSS) capacitor c=1.05652e-16
C123 (\16\:qbint VSS) capacitor c=8.62871e-17
C124 (\17\:qbint VSS) capacitor c=8.65496e-17
C125 (\8\:RN VSS) capacitor c=7.68042e-17
C126 (\6\:n30 VSS) capacitor c=1.10872e-16
C127 (\9\:RN VSS) capacitor c=1.46755e-16
C128 (\10\:RN VSS) capacitor c=1.4966e-16
C129 (\4\:mout VSS) capacitor c=7.84687e-17
C130 (\5\:mout VSS) capacitor c=8.73997e-17
C131 (\7\:n20 VSS) capacitor c=8.91744e-17
C132 (\10\:n20 VSS) capacitor c=8.28279e-17
C133 (\11\:Ckbb VSS) capacitor c=1.07742e-17
C134 (\12\:Ckbb VSS) capacitor c=1.8821e-16
C135 (\15\:Ckbb VSS) capacitor c=2.77147e-17
C136 (\16\:Ckbb VSS) capacitor c=1.08907e-16
C137 (\11\:CKb VSS) capacitor c=8.09893e-17
C138 (\12\:CKb VSS) capacitor c=1.69867e-16
C139 (\13\:CKb VSS) capacitor c=1.32059e-16
C140 (\14\:CKb VSS) capacitor c=1.34037e-16
C141 (\15\:CKb VSS) capacitor c=1.31385e-16
C142 (\18\:CKb VSS) capacitor c=4.80696e-17
C143 (\19\:CKb VSS) capacitor c=7.75968e-17
C144 (\5\:D VSS) capacitor c=5.67983e-17
C145 (\3\:Db VSS) capacitor c=1.96332e-16
C146 (\8\:SE VSS) capacitor c=5.05797e-17
C147 (\9\:SE VSS) capacitor c=1.08537e-16
C148 (\10\:SE VSS) capacitor c=5.64302e-17
C149 (\11\:SE VSS) capacitor c=2.54154e-17
C150 (\6\:SEb VSS) capacitor c=8.85245e-17
C151 (\7\:SEb VSS) capacitor c=7.74939e-17
C152 (\5\:VDD VSS) capacitor c=3.12686e-17
C153 (\9\:VDD VSS) capacitor c=8.75992e-18
C154 (\13\:VDD VSS) capacitor c=1.46515e-17
C155 (\17\:VDD VSS) capacitor c=1.46726e-17
C156 (\20\:VDD VSS) capacitor c=7.76929e-18
C157 (\24\:VDD VSS) capacitor c=1.41389e-17
C158 (\28\:VDD VSS) capacitor c=9.05116e-18
Rk2 (\4\:QN QN) resistor r=0.07352 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2248 c=0
Rk13 (\8\:RN RN) resistor r=0.09899 c=0
Rk16 (\9\:RN \10\:RN) resistor r=0.9727 c=0
Rk43 (SE \8\:SE) resistor r=0.1056 c=0
Rk44 (\8\:SE \9\:SE) resistor r=0.4136 c=0
Rk45 (\9\:SE \10\:SE) resistor r=0.4637 c=0
Rk46 (\9\:SE \11\:SE) resistor r=0.101 c=0
Rk8 (\4\:CK CK) resistor r=0.1052 c=0
Rk42 (\4\:SI SI) resistor r=0.004561 c=0
Rk50 (\2\:VDD \4\:VDD) resistor r=0.3781 c=0
Rk51 (\4\:VDD \5\:VDD) resistor r=0.3885 c=0
Rk52 (\5\:VDD \7\:VDD) resistor r=0.07393 c=0
Rk53 (\5\:VDD \8\:VDD) resistor r=0.2631 c=0
Rk54 (\8\:VDD \9\:VDD) resistor r=0.2957 c=0
Rk55 (\9\:VDD \11\:VDD) resistor r=0.07393 c=0
Rk56 (\9\:VDD \12\:VDD) resistor r=0.1051 c=0
Rk57 (\12\:VDD \13\:VDD) resistor r=0.09415 c=0
Rk58 (\13\:VDD \15\:VDD) resistor r=0.04331 c=0
Rk59 (\13\:VDD \16\:VDD) resistor r=0.355 c=0
Rk60 (\16\:VDD \17\:VDD) resistor r=0.1242 c=0
Rk61 (\17\:VDD \19\:VDD) resistor r=0.04331 c=0
Rk62 (\17\:VDD \20\:VDD) resistor r=0.2344 c=0
Rk63 (\20\:VDD \22\:VDD) resistor r=0.1808 c=0
Rk64 (\20\:VDD \23\:VDD) resistor r=0.09009 c=0
Rk65 (\23\:VDD \24\:VDD) resistor r=0.1428 c=0
Rk66 (\24\:VDD \26\:VDD) resistor r=0.1742 c=0
Rk67 (\24\:VDD \27\:VDD) resistor r=0.2581 c=0
Rk70 (\28\:VDD VDD) resistor r=0.1952 c=0
Rk68 (\27\:VDD \28\:VDD) resistor r=0.05498 c=0
Rk69 (\28\:VDD \30\:VDD) resistor r=0.4181 c=0
Rk37 (D \5\:D) resistor r=0.1792 c=0
Rk6 (Q \2\:Q) resistor r=0.3685 c=0
Rk7 (Q \4\:Q) resistor r=0.1681 c=0
Rk71 (\2\:VSS \3\:VSS) resistor r=0.2882 c=0
Rk72 (\3\:VSS \4\:VSS) resistor r=0.3634 c=0
Rk73 (\4\:VSS \5\:VSS) resistor r=0.05748 c=0
Rk74 (\5\:VSS \6\:VSS) resistor r=0.6883 c=0
Rk75 (\6\:VSS \7\:VSS) resistor r=0.4553 c=0
Rk76 (\7\:VSS \8\:VSS) resistor r=0.1327 c=0
Rk77 (\8\:VSS \9\:VSS) resistor r=0.4585 c=0
Rk78 (\9\:VSS \10\:VSS) resistor r=0.1603 c=0
Rk79 (\10\:VSS \11\:VSS) resistor r=0.1051 c=0
Rk81 (\12\:VSS VSS) resistor r=0.04991 c=0
Rk80 (\11\:VSS \12\:VSS) resistor r=0.1453 c=0
Rk82 (\3\:VSS \14\:VSS) resistor r=0.1995 c=0
Rk83 (\5\:VSS \16\:VSS) resistor r=0.2091 c=0
Rk84 (\6\:VSS \18\:VSS) resistor r=0.04331 c=0
Rk85 (\8\:VSS \20\:VSS) resistor r=0.2222 c=0
Rk86 (\9\:VSS \22\:VSS) resistor r=0.07393 c=0
Rk87 (\11\:VSS \24\:VSS) resistor r=0.07393 c=0
Rk3 (\5\:qint \6\:qint) resistor r=0.1328 c=0
Rk4 (\6\:qint \8\:qint) resistor r=0.09313 c=0
Rk5 (\6\:qint \10\:qint) resistor r=0.1309 c=0
Rk9 (\12\:qbint \13\:qbint) resistor r=0.5286 c=0
Rk10 (\13\:qbint \15\:qbint) resistor r=0.09595 c=0
Rk11 (\13\:qbint \16\:qbint) resistor r=0.3845 c=0
Rk12 (\15\:qbint \17\:qbint) resistor r=0.665 c=0
Rk29 (\11\:CKb \12\:CKb) resistor r=0.5978 c=0
Rk30 (\12\:CKb \13\:CKb) resistor r=0.8991 c=0
Rk31 (\13\:CKb \14\:CKb) resistor r=0.3104 c=0
Rk32 (\14\:CKb \15\:CKb) resistor r=0.661 c=0
Rk33 (\15\:CKb \17\:CKb) resistor r=0.5176 c=0
Rk34 (\13\:CKb \18\:CKb) resistor r=0.2445 c=0
Rk35 (\14\:CKb \19\:CKb) resistor r=0.3498 c=0
Rk36 (\15\:CKb \21\:CKb) resistor r=0.08144 c=0
Rk14 (\5\:n30 \6\:n30) resistor r=0.6214 c=0
Rk15 (\5\:n30 \8\:n30) resistor r=0.3881 c=0
Rk17 (\4\:mout \5\:mout) resistor r=0.4455 c=0
Rk18 (\5\:mout \7\:mout) resistor r=0.405 c=0
Rk19 (\5\:mout \9\:mout) resistor r=0.05684 c=0
Rk24 (\10\:Ckbb \11\:Ckbb) resistor r=0.08701 c=0
Rk25 (\11\:Ckbb \12\:Ckbb) resistor r=0.4681 c=0
Rk26 (\10\:Ckbb \14\:Ckbb) resistor r=0.5517 c=0
Rk27 (\11\:Ckbb \15\:Ckbb) resistor r=0.1831 c=0
Rk28 (\12\:Ckbb \16\:Ckbb) resistor r=0.8746 c=0
Rk21 (\6\:n20 \7\:n20) resistor r=0.2028 c=0
Rk22 (\7\:n20 \9\:n20) resistor r=0.2131 c=0
Rk23 (\7\:n20 \10\:n20) resistor r=0.5012 c=0
Rk38 (\2\:Db \3\:Db) resistor r=0.8212 c=0
Rk39 (\3\:Db \5\:Db) resistor r=0.8111 c=0
Rk40 (\5\:Db \7\:Db) resistor r=0.3734 c=0
Rk41 (\3\:Db \9\:Db) resistor r=0.1388 c=0
Rk47 (\5\:SEb \6\:SEb) resistor r=0.04795 c=0
Rk48 (\6\:SEb \7\:SEb) resistor r=0.5048 c=0
Rk49 (\6\:SEb \9\:SEb) resistor r=0.6954 c=0
Rk20 (\2\:n6 \4\:n6) resistor r=0.2147 c=0
Rl27 (\5\:RN \6\:RN) resistor r=163.027 c=0
Rl28 (\6\:RN \7\:RN) resistor r=69.9225 c=0
Rl14 (\1\:RN \2\:RN) resistor r=69.9225 c=0
Rl15 (\2\:RN \3\:RN) resistor r=26.1806 c=0
Rl16 (\3\:RN \4\:RN) resistor r=87.7867 c=0
Rl46 (\5\:SE \6\:SE) resistor r=193 c=0
Rl47 (\6\:SE \7\:SE) resistor r=29.5379 c=0
Rl43 (\3\:SE \4\:SE) resistor r=81.461 c=0
Rl40 (\1\:SE \2\:SE) resistor r=66.4826 c=0
Rl10 (\1\:CK \2\:CK) resistor r=130.002 c=0
Rl11 (\2\:CK \3\:CK) resistor r=101.156 c=0
Rl44 (\1\:SI \2\:SI) resistor r=143.464 c=0
Rl45 (\2\:SI \3\:SI) resistor r=76.1559 c=0
Rl37 (\1\:D \2\:D) resistor r=191.187 c=0
Rl39 (\2\:D \4\:D) resistor r=46.9565 c=0
Rl38 (\2\:D \3\:D) resistor r=3.1183 c=0
Rl1 (qint \2\:qint) resistor r=5.915 c=0
Rl3 (\2\:qint \4\:qint) resistor r=49.7141 c=0
Rl2 (\2\:qint \3\:qint) resistor r=34.3295 c=0
Rl17 (\8\:qbint \9\:qbint) resistor r=80.7563 c=0
Rl18 (\9\:qbint \10\:qbint) resistor r=26.098 c=0
Rl4 (qbint \2\:qbint) resistor r=205.359 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=32.4355 c=0
Rl8 (\2\:qbint \6\:qbint) resistor r=7.2648 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=49.521 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=48.048 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=147.001 c=0
Rl35 (\8\:CKb \9\:CKb) resistor r=245.637 c=0
Rl32 (\5\:CKb \6\:CKb) resistor r=120.043 c=0
Rl36 (\9\:CKb \10\:CKb) resistor r=52.1723 c=0
Rl33 (\6\:CKb \7\:CKb) resistor r=29.5379 c=0
Rl20 (\3\:CKb \4\:CKb) resistor r=24.2328 c=0
Rl19 (CKb \2\:CKb) resistor r=39.6174 c=0
Rl12 (n30 \2\:n30) resistor r=139.611 c=0
Rl13 (\2\:n30 \3\:n30) resistor r=26.1559 c=0
Rl29 (mout \2\:mout) resistor r=89.6174 c=0
Rl30 (\2\:mout \3\:mout) resistor r=24.2328 c=0
Rl34 (\7\:Ckbb \8\:Ckbb) resistor r=141.821 c=0
Rl31 (\5\:Ckbb \6\:Ckbb) resistor r=35.7713 c=0
Rl21 (Ckbb \2\:Ckbb) resistor r=32.3738 c=0
Rl22 (\2\:Ckbb \3\:Ckbb) resistor r=141.851 c=0
Rl23 (\2\:Ckbb \4\:Ckbb) resistor r=92.233 c=0
Rl24 (n20 \2\:n20) resistor r=11.5001 c=0
Rl25 (\2\:n20 \3\:n20) resistor r=87.0953 c=0
Rl26 (\2\:n20 \4\:n20) resistor r=49.7141 c=0
Rl41 (SEb \2\:SEb) resistor r=25.0391 c=0
Rl42 (\2\:SEb \3\:SEb) resistor r=195.65 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz13 (\3\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz14 (\3\:VDD \8\:VDD) resistor r=12.5 c=0
Rz15 (\3\:VDD \12\:VDD) resistor r=37.5 c=0
Rz16 (\3\:VDD \16\:VDD) resistor r=10.7143 c=0
Rz17 (\3\:VDD \23\:VDD) resistor r=37.5 c=0
Rz18 (\3\:VDD \27\:VDD) resistor r=12.5 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz19 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz20 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz21 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz22 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz23 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz24 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz2 (\7\:qint \8\:qint) resistor r=75 c=0
Rz4 (\14\:qbint \15\:qbint) resistor r=75 c=0
Rz9 (\16\:CKb \17\:CKb) resistor r=75 c=0
Rz5 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz6 (\8\:mout \9\:mout) resistor r=75 c=0
Rz8 (\9\:Ckbb \10\:Ckbb) resistor r=75 c=0
Rz7 (\5\:n20 \6\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\6\:Db \7\:Db) resistor r=75 c=0
Rz12 (\8\:SEb \9\:SEb) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry15 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry16 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry17 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry18 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry19 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry20 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry21 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry22 (\29\:VDD \30\:VDD) resistor r=62 c=0
Ry3 (\3\:Q \4\:Q) resistor r=62 c=0
Ry23 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry24 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry25 (\1\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry26 (\1\:VSS \10\:VSS) resistor r=20.6667 c=0
Ry27 (\1\:VSS \12\:VSS) resistor r=31 c=0
Ry2 (\9\:qint \10\:qint) resistor r=62 c=0
Ry4 (\11\:qbint \12\:qbint) resistor r=62 c=0
Ry11 (\20\:CKb \21\:CKb) resistor r=62 c=0
Ry5 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry6 (\6\:mout \7\:mout) resistor r=62 c=0
Ry10 (\13\:Ckbb \14\:Ckbb) resistor r=62 c=0
Ry9 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry12 (\4\:Db \5\:Db) resistor r=62 c=0
Ry13 (\8\:Db \9\:Db) resistor r=62 c=0
Ry14 (\4\:SEb \5\:SEb) resistor r=62 c=0
Ry7 (n6 \2\:n6) resistor r=62 c=0
Ry8 (\3\:n6 \4\:n6) resistor r=62 c=0
Rx5 (\3\:RN \8\:RN) resistor r=45 c=0
Rx7 (\7\:RN \9\:RN) resistor r=45 c=0
Rx8 (\1\:RN \10\:RN) resistor r=45 c=0
Rx20 (\6\:SE \8\:SE) resistor r=45 c=0
Rx21 (\2\:SE \10\:SE) resistor r=45 c=0
Rx22 (\4\:SE \11\:SE) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx19 (\2\:SI \4\:SI) resistor r=45 c=0
Rx18 (\3\:D \5\:D) resistor r=45 c=0
Rx1 (qint \5\:qint) resistor r=45 c=0
Rx3 (\9\:qbint \16\:qbint) resistor r=45 c=0
Rx4 (\6\:qbint \17\:qbint) resistor r=45 c=0
Rx14 (\10\:CKb \11\:CKb) resistor r=45 c=0
Rx15 (\7\:CKb \12\:CKb) resistor r=45 c=0
Rx16 (\4\:CKb \18\:CKb) resistor r=45 c=0
Rx17 (\2\:CKb \19\:CKb) resistor r=45 c=0
Rx6 (\3\:n30 \6\:n30) resistor r=45 c=0
Rx9 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\6\:Ckbb \12\:Ckbb) resistor r=45 c=0
Rx12 (\7\:Ckbb \15\:Ckbb) resistor r=45 c=0
Rx13 (\4\:Ckbb \16\:Ckbb) resistor r=45 c=0
Rx10 (n20 \10\:n20) resistor r=45 c=0
Rx23 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.697e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.7e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn56 (\7\:qint \4\:qbint \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.697e-14 ad=2.03e-14 ps=1.67e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\1\:Q \5\:qbint \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.695e-14 ad=2.03e-14 ps=1.59e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.85e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn20 (\16\:CKb \3\:CK \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.695e-14 ad=2.32e-14 ps=1.59e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.6e-07 sd=160n sca=14.3814 \
        scb=0.0152134 scc=0.00088947 m=(1)
mn46 (\14\:qbint \2\:n30 n9 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.263e-14 ps=4.1e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.25e-07 sb=2e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn45 (n9 \4\:RN \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=8.7e-15 ps=9.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.3e-07 sb=2e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn50 (n11 \10\:qbint \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.75e-14 ad=8.7e-15 ps=9.9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.95e-07 sb=1.87e-06 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn36 (n5 \3\:mout n7 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=1.958e-14 ps=4.1e-07 pd=5.6e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.845e-06 sb=6.2e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn51 (\4\:n30 CKb n11 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.698e-14 ps=4.1e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=1.765e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn40 (\8\:mout Ckbb \4\:n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.698e-14 ad=6.235e-14 ps=8e-07 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=1.465e-06 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn30 (\8\:mout \4\:n20 \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.45e-14 ad=6.235e-14 ps=1.44e-06 pd=1.15e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=9.9e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn35 (n7 \5\:RN \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.45e-14 ad=8.7e-15 ps=1.44e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.74e-06 sb=7.25e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn37 (\5\:n20 \5\:Ckbb n5 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.958e-14 ad=2.32e-14 ps=5.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.4e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn25 (\6\:Db \5\:CKb \5\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=3.408e-14 ps=6.1e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2.35e-07 sd=160n sca=13.6097 scb=0.014254 \
        scc=0.000755054 m=(1)
mn21 (\9\:Ckbb \8\:CKb \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=1.395e-06 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn11 (n1 \4\:D \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=4.205e-14 ps=6.1e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.19e-06 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn12 (Db \3\:SEb n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.205e-14 ad=2.32e-14 ps=8.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7e-07 sb=8.55e-07 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn14 (Db \3\:SE n3 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=1.16e-14 \
        ad=2.32e-14 ps=4.5e-07 pd=6.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.05e-07 sb=6.5e-07 sd=160n sca=7.37439 scb=0.00450456 \
        scc=4.82709e-05 m=(1)
mn13 (n3 \3\:SI \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.93e-14 ad=1.16e-14 ps=9.7e-07 pd=4.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=5.25e-07 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mn10 (\8\:SEb \7\:SE \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.93e-14 ad=2.03e-14 ps=9.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.415e-06 sb=1.4e-07 sd=160n sca=7.37439 \
        scb=0.00450456 scc=4.82709e-05 m=(1)
mp56 (\9\:qint \7\:qbint \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.73e-14 ad=3.01e-14 ps=8.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=46.9828 \
        scb=0.0290392 scc=0.00588499 m=(1)
mp55 (\3\:Q qbint \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.65e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp20 (\20\:CKb \1\:CK \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.6e-07 sd=160n sca=10.3756 \
        scb=0.00778655 scc=9.84544e-05 m=(1)
mp46 (\11\:qbint n30 \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.315e-14 ad=3.44e-14 ps=1.38e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.735e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp45 (\11\:qbint \2\:RN \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.39e-14 ad=3.44e-14 ps=1.8e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.53e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp50 (n8 \8\:qbint \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.39e-14 ad=3.655e-14 ps=1.8e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=1.335e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp51 (\7\:n30 \3\:Ckbb n8 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=5.483e-14 ps=7.7e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.85e-07 sb=1.12e-06 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp40 (\7\:n30 \3\:CKb \6\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.912e-14 ad=5.483e-14 ps=9.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.085e-06 sb=8.2e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp30 (\6\:mout \3\:n20 \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.39e-14 ad=5.913e-14 ps=1.8e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.405e-06 sb=5e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp35 (\3\:n6 \6\:RN \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.39e-14 ad=3.44e-14 ps=1.8e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-06 sb=3.05e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp36 (\3\:n6 mout \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.315e-14 ad=3.44e-14 ps=1.7e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.805e-06 sb=1e-07 sd=160n sca=25.9192 \
        scb=0.0230503 scc=0.00301683 m=(1)
mp37 (\8\:n20 \6\:CKb n6 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.118e-14 ad=3.44e-14 ps=7.2e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-07 sb=3.45e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp25 (\8\:n20 \8\:Ckbb \4\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp21 (\13\:Ckbb \9\:CKb \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.815e-14 ad=3.01e-14 ps=1.57e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.385e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp11 (n2 \1\:D \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.815e-14 ad=3.655e-14 ps=1.57e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.19e-06 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp12 (\8\:Db \1\:SE n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.44e-14 ps=7.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=9.75e-07 sd=160n sca=13.1637 \
        scb=0.0123476 scc=0.000501177 m=(1)
mp14 (\8\:Db SEb n4 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=4.3e-14 \
        ad=3.44e-14 ps=8.3e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=7.55e-07 sb=7.7e-07 sd=160n sca=13.1637 scb=0.0123476 \
        scc=0.000501177 m=(1)
mp13 (n4 \1\:SI \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.31e-14 ad=4.3e-14 ps=1.11e-06 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=5.25e-07 sd=160n sca=13.7416 scb=0.0125632 \
        scc=0.000501256 m=(1)
mp10 (\4\:SEb \5\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.31e-14 ad=3.01e-14 ps=1.11e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=1.4e-07 sd=160n sca=17.8247 \
        scb=0.018517 scc=0.000593893 m=(1)
ends SDFFRXL
// End of subcircuit definition.

// Generated for: spectre (May  9 17:35:46 2012 )
// Library name: gsclib045
// Cell name: SDFFSHQX1
// View name: extracted

simulator lang=spectre

subckt SDFFSHQX1 CK D Q SE SI SN VDD VSS
mp55 (\1\:Q \3\:qbint \28\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.8e-14 ps=1.06e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.23077e-07 sd=160n sca=34.9044 \
        scb=0.0259128 scc=0.00343869 m=(1)
C1 (D VSS) capacitor c=5.86425e-17
C2 (CK VSS) capacitor c=4.66879e-17
C3 (Q VSS) capacitor c=3.92158e-17
C4 (SE VSS) capacitor c=9.45695e-17
C5 (SN VSS) capacitor c=1.48919e-16
C6 (SI VSS) capacitor c=7.13751e-17
C7 (VDD VSS) capacitor c=3.25961e-16
C8 (qbint VSS) capacitor c=2.17059e-17
C9 (n30 VSS) capacitor c=3.52291e-17
C10 (net459 VSS) capacitor c=2.23493e-18
C11 (net467 VSS) capacitor c=1.76019e-18
C12 (CKb VSS) capacitor c=4.25993e-17
C13 (mout VSS) capacitor c=5.06444e-17
C14 (CKbb VSS) capacitor c=4.92551e-17
C15 (n20 VSS) capacitor c=1.70602e-17
C16 (net427 VSS) capacitor c=1.82309e-18
C17 (Db VSS) capacitor c=4.36019e-17
C18 (net443 VSS) capacitor c=5.17867e-18
C19 (SEb VSS) capacitor c=3.98991e-17
C20 (net455 VSS) capacitor c=2.6916e-18
C21 (net355 VSS) capacitor c=6.3719e-17
C22 (net378 VSS) capacitor c=1.94844e-18
C23 (net390 VSS) capacitor c=7.41841e-18
C24 (net398 VSS) capacitor c=1.65861e-18
C25 (\4\:SE VSS) capacitor c=2.67309e-17
C26 (\1\:SI VSS) capacitor c=7.223e-17
C27 (\3\:SEb VSS) capacitor c=7.05374e-17
C28 (\3\:SE VSS) capacitor c=5.19888e-17
C29 (\1\:D VSS) capacitor c=5.57169e-17
C30 (\1\:CK VSS) capacitor c=3.46121e-17
C31 (\7\:CKb VSS) capacitor c=1.88232e-17
C32 (\4\:CKbb VSS) capacitor c=2.23706e-17
C33 (\5\:CKb VSS) capacitor c=5.35704e-17
C34 (\3\:mout VSS) capacitor c=7.80128e-17
C35 (\4\:n20 VSS) capacitor c=4.11907e-17
C36 (\5\:SN VSS) capacitor c=3.89572e-17
C37 (\4\:CKb VSS) capacitor c=5.91248e-17
C38 (\4\:qbint VSS) capacitor c=5.77275e-17
C39 (\1\:SN VSS) capacitor c=4.0552e-17
C40 (\3\:n30 VSS) capacitor c=6.04977e-17
C41 (\3\:qbint VSS) capacitor c=3.16784e-17
C42 (\6\:SE VSS) capacitor c=2.09632e-17
C43 (\3\:SI VSS) capacitor c=5.834e-17
C44 (\1\:SE VSS) capacitor c=4.66732e-17
C45 (\4\:D VSS) capacitor c=4.67764e-17
C46 (\3\:CK VSS) capacitor c=5.5716e-17
C47 (\12\:CKb VSS) capacitor c=1.20848e-17
C48 (\11\:CKb VSS) capacitor c=2.46757e-17
C49 (\6\:CKbb VSS) capacitor c=9.41969e-17
C50 (\3\:n20 VSS) capacitor c=6.65611e-17
C51 (\8\:SN VSS) capacitor c=6.60339e-17
C52 (\2\:CKbb VSS) capacitor c=4.52838e-17
C53 (\6\:qbint VSS) capacitor c=4.32212e-17
C54 (\4\:SN VSS) capacitor c=6.40547e-17
C55 (\5\:SE VSS) capacitor c=2.28465e-17
C56 (\2\:SI VSS) capacitor c=5.92125e-17
C57 (\4\:SEb VSS) capacitor c=4.49068e-17
C58 (\2\:SE VSS) capacitor c=7.10786e-17
C59 (\2\:SEb VSS) capacitor c=4.1362e-17
C60 (\3\:D VSS) capacitor c=2.80478e-17
C61 (\2\:CK VSS) capacitor c=3.74102e-17
C62 (\7\:CKbb VSS) capacitor c=1.2852e-17
C63 (\10\:CKb VSS) capacitor c=4.40924e-17
C64 (\6\:CKb VSS) capacitor c=4.50428e-17
C65 (\2\:mout VSS) capacitor c=5.48064e-17
C66 (\7\:SN VSS) capacitor c=4.31497e-17
C67 (\3\:CKb VSS) capacitor c=4.00918e-17
C68 (\3\:CKbb VSS) capacitor c=2.69588e-17
C69 (\2\:CKb VSS) capacitor c=3.96134e-17
C70 (\5\:qbint VSS) capacitor c=5.73514e-17
C71 (\3\:SN VSS) capacitor c=3.35432e-17
C72 (\2\:n30 VSS) capacitor c=5.14295e-17
C73 (\2\:qbint VSS) capacitor c=1.7022e-17
C74 (\1\:VDD VSS) capacitor c=1.21674e-17
C75 (\9\:SEb VSS) capacitor c=7.93743e-17
C76 (\5\:VDD VSS) capacitor c=2.86967e-17
C77 (\6\:Db VSS) capacitor c=1.093e-16
C78 (\8\:VDD VSS) capacitor c=3.97701e-17
C79 (\23\:CKb VSS) capacitor c=7.93709e-17
C80 (\11\:VDD VSS) capacitor c=6.52169e-17
C81 (\10\:CKbb VSS) capacitor c=9.46164e-17
C82 (\8\:Db VSS) capacitor c=1.22758e-16
C83 (\7\:n20 VSS) capacitor c=1.08167e-16
C84 (\15\:VDD VSS) capacitor c=2.88022e-17
C85 (\12\:mout VSS) capacitor c=5.84186e-17
C86 (\18\:VDD VSS) capacitor c=2.35291e-17
C87 (\14\:mout VSS) capacitor c=3.56799e-17
C88 (\8\:n30 VSS) capacitor c=3.98696e-17
C89 (\21\:VDD VSS) capacitor c=1.39693e-17
C90 (\3\:net355 VSS) capacitor c=6.93533e-17
C91 (\25\:VDD VSS) capacitor c=1.37509e-17
C92 (\11\:qbint VSS) capacitor c=6.20586e-17
C93 (\1\:Q VSS) capacitor c=2.08314e-17
C94 (\28\:VDD VSS) capacitor c=3.21843e-17
C95 (\3\:VDD VSS) capacitor c=8.93339e-17
C96 (\5\:SEb VSS) capacitor c=1.14135e-16
C97 (\19\:CKb VSS) capacitor c=5.64347e-17
C98 (\13\:CKbb VSS) capacitor c=5.74601e-17
C99 (\4\:Db VSS) capacitor c=2.12612e-16
C100 (\5\:n20 VSS) capacitor c=9.58531e-17
C101 (\10\:mout VSS) capacitor c=3.38824e-17
C102 (\8\:mout VSS) capacitor c=5.96425e-17
C103 (\4\:n30 VSS) capacitor c=6.75553e-17
C104 (\9\:qbint VSS) capacitor c=6.39558e-17
C105 (\4\:Q VSS) capacitor c=5.095e-17
C106 (\2\:SN VSS) capacitor c=3.24923e-17
C107 (\2\:n20 VSS) capacitor c=4.12258e-17
C108 (\5\:CKbb VSS) capacitor c=3.59988e-17
C109 (\9\:CKb VSS) capacitor c=2.86713e-17
C110 (\2\:D VSS) capacitor c=2.7491e-17
C111 (\3\:Q VSS) capacitor c=2.32044e-17
C112 (\7\:qbint VSS) capacitor c=7.1156e-17
C113 (\8\:qbint VSS) capacitor c=7.72557e-17
C114 (\13\:qbint VSS) capacitor c=7.32561e-17
C115 (\6\:n30 VSS) capacitor c=9.5872e-17
C116 (\7\:n30 VSS) capacitor c=9.97836e-17
C117 (\9\:SN VSS) capacitor c=2.21688e-17
C118 (\10\:SN VSS) capacitor c=1.77891e-16
C119 (\4\:mout VSS) capacitor c=4.67292e-17
C120 (\6\:mout VSS) capacitor c=6.75486e-17
C121 (\7\:mout VSS) capacitor c=6.15756e-17
C122 (\9\:n20 VSS) capacitor c=7.33258e-17
C123 (\13\:CKb VSS) capacitor c=1.12876e-16
C124 (\14\:CKb VSS) capacitor c=1.93267e-16
C125 (\15\:CKb VSS) capacitor c=1.44984e-16
C126 (\16\:CKb VSS) capacitor c=1.05227e-16
C127 (\17\:CKb VSS) capacitor c=5.03203e-17
C128 (\18\:CKb VSS) capacitor c=3.40041e-17
C129 (\8\:CKbb VSS) capacitor c=7.63369e-17
C130 (\9\:CKbb VSS) capacitor c=1.86098e-16
C131 (\12\:CKbb VSS) capacitor c=1.4944e-16
C132 (\21\:CKb VSS) capacitor c=6.59729e-17
C133 (\22\:CKb VSS) capacitor c=2.36833e-17
C134 (\4\:CK VSS) capacitor c=8.59076e-17
C135 (\5\:D VSS) capacitor c=4.51203e-17
C136 (\3\:Db VSS) capacitor c=2.60314e-16
C137 (\4\:SI VSS) capacitor c=3.76201e-17
C138 (\7\:SEb VSS) capacitor c=1.46675e-16
C139 (\8\:SEb VSS) capacitor c=1.18459e-16
C140 (\7\:SE VSS) capacitor c=1.14235e-16
C141 (\7\:VDD VSS) capacitor c=2.20841e-17
C142 (\10\:VDD VSS) capacitor c=2.78845e-17
C143 (\14\:VDD VSS) capacitor c=3.23692e-17
C144 (\17\:VDD VSS) capacitor c=3.14441e-17
C145 (\20\:VDD VSS) capacitor c=2.47636e-17
C146 (\24\:VDD VSS) capacitor c=9.76415e-18
C147 (\27\:VDD VSS) capacitor c=8.49572e-18
Rk36 (D \5\:D) resistor r=0.0269 c=0
Rk35 (CK \4\:CK) resistor r=0.06218 c=0
Rk3 (\3\:Q Q) resistor r=0.08203 c=0
Rk1 (\2\:Q \3\:Q) resistor r=0.08182 c=0
Rk2 (\3\:Q \5\:Q) resistor r=0.1375 c=0
Rk66 (\2\:VSS \4\:VSS) resistor r=0.6318 c=0
Rk67 (\4\:VSS \5\:VSS) resistor r=0.4017 c=0
Rk68 (\5\:VSS \6\:VSS) resistor r=0.2005 c=0
Rk69 (\6\:VSS \7\:VSS) resistor r=0.202 c=0
Rk70 (\7\:VSS \8\:VSS) resistor r=0.2472 c=0
Rk71 (\8\:VSS \9\:VSS) resistor r=0.2456 c=0
Rk72 (\9\:VSS \10\:VSS) resistor r=0.1553 c=0
Rk73 (\10\:VSS \11\:VSS) resistor r=0.1754 c=0
Rk74 (\11\:VSS \12\:VSS) resistor r=0.5767 c=0
Rk75 (\12\:VSS \13\:VSS) resistor r=0.04495 c=0
Rk77 (\14\:VSS VSS) resistor r=0.0151 c=0
Rk76 (\13\:VSS \14\:VSS) resistor r=0.4912 c=0
Rk78 (\4\:VSS \16\:VSS) resistor r=0.2376 c=0
Rk79 (\5\:VSS \18\:VSS) resistor r=0.1879 c=0
Rk80 (\7\:VSS \20\:VSS) resistor r=0.04332 c=0
Rk81 (\9\:VSS \22\:VSS) resistor r=0.2752 c=0
Rk82 (\11\:VSS \24\:VSS) resistor r=0.1276 c=0
Rk83 (\13\:VSS \26\:VSS) resistor r=0.2601 c=0
Rk84 (\14\:VSS \28\:VSS) resistor r=0.285 c=0
Rk45 (\7\:SE SE) resistor r=0.4738 c=0
Rk46 (SE \8\:SE) resistor r=0.01427 c=0
Rk12 (\9\:SN SN) resistor r=0.07197 c=0
Rk13 (SN \10\:SN) resistor r=1.2748 c=0
Rk41 (SI \4\:SI) resistor r=0.06296 c=0
Rk47 (\2\:VDD \4\:VDD) resistor r=0.65 c=0
Rk48 (\4\:VDD \6\:VDD) resistor r=0.271 c=0
Rk49 (\4\:VDD \7\:VDD) resistor r=0.4162 c=0
Rk50 (\7\:VDD \9\:VDD) resistor r=0.2832 c=0
Rk51 (\7\:VDD \10\:VDD) resistor r=0.3382 c=0
Rk52 (\10\:VDD \12\:VDD) resistor r=0.4529 c=0
Rk53 (\10\:VDD \13\:VDD) resistor r=0.2481 c=0
Rk54 (\13\:VDD \14\:VDD) resistor r=0.3626 c=0
Rk55 (\14\:VDD \16\:VDD) resistor r=0.04332 c=0
Rk56 (\14\:VDD \17\:VDD) resistor r=0.251 c=0
Rk57 (\17\:VDD \19\:VDD) resistor r=0.04332 c=0
Rk58 (\17\:VDD \20\:VDD) resistor r=0.394 c=0
Rk59 (\20\:VDD \22\:VDD) resistor r=0.04332 c=0
Rk60 (\20\:VDD \23\:VDD) resistor r=0.1895 c=0
Rk61 (\23\:VDD \24\:VDD) resistor r=0.044 c=0
Rk62 (\24\:VDD \26\:VDD) resistor r=0.04332 c=0
Rk65 (\27\:VDD VDD) resistor r=0.08483 c=0
Rk63 (\24\:VDD \27\:VDD) resistor r=0.42 c=0
Rk64 (\27\:VDD \29\:VDD) resistor r=0.3852 c=0
Rk4 (\7\:qbint \8\:qbint) resistor r=0.4185 c=0
Rk5 (\8\:qbint \10\:qbint) resistor r=0.0632 c=0
Rk6 (\8\:qbint \12\:qbint) resistor r=0.3929 c=0
Rk7 (\10\:qbint \13\:qbint) resistor r=0.6428 c=0
Rk9 (\5\:n30 \6\:n30) resistor r=0.2753 c=0
Rk10 (\6\:n30 \7\:n30) resistor r=0.6455 c=0
Rk11 (\6\:n30 \9\:n30) resistor r=0.1578 c=0
Rk23 (\13\:CKb \14\:CKb) resistor r=0.7225 c=0
Rk24 (\14\:CKb \15\:CKb) resistor r=0.7874 c=0
Rk25 (\15\:CKb \16\:CKb) resistor r=0.7368 c=0
Rk26 (\14\:CKb \17\:CKb) resistor r=0.2372 c=0
Rk27 (\15\:CKb \18\:CKb) resistor r=0.1246 c=0
Rk32 (\20\:CKb \21\:CKb) resistor r=0.2855 c=0
Rk33 (\21\:CKb \22\:CKb) resistor r=0.135 c=0
Rk34 (\21\:CKb \24\:CKb) resistor r=0.5006 c=0
Rk14 (\4\:mout \5\:mout) resistor r=0.2213 c=0
Rk15 (\5\:mout \6\:mout) resistor r=0.05931 c=0
Rk16 (\6\:mout \7\:mout) resistor r=0.3259 c=0
Rk17 (\7\:mout \9\:mout) resistor r=0.3117 c=0
Rk18 (\5\:mout \11\:mout) resistor r=0.1012 c=0
Rk19 (\6\:mout \13\:mout) resistor r=0.2547 c=0
Rk20 (\7\:mout \15\:mout) resistor r=0.1196 c=0
Rk28 (\8\:CKbb \9\:CKbb) resistor r=0.3224 c=0
Rk29 (\9\:CKbb \11\:CKbb) resistor r=0.6265 c=0
Rk30 (\9\:CKbb \12\:CKbb) resistor r=1.0964 c=0
Rk31 (\11\:CKbb \14\:CKbb) resistor r=0.2948 c=0
Rk21 (\6\:n20 \8\:n20) resistor r=0.4863 c=0
Rk22 (\8\:n20 \9\:n20) resistor r=0.4589 c=0
Rk37 (\2\:Db \3\:Db) resistor r=0.2547 c=0
Rk38 (\3\:Db \5\:Db) resistor r=1.1126 c=0
Rk39 (\3\:Db \7\:Db) resistor r=0.8681 c=0
Rk40 (\5\:Db \9\:Db) resistor r=0.6024 c=0
Rk42 (\6\:SEb \7\:SEb) resistor r=0.8008 c=0
Rk43 (\7\:SEb \8\:SEb) resistor r=0.3798 c=0
Rk44 (\8\:SEb \10\:SEb) resistor r=0.6659 c=0
Rk8 (\2\:net355 \4\:net355) resistor r=0.2136 c=0
Rl33 (\1\:D \2\:D) resistor r=134.329 c=0
Rl35 (\2\:D \4\:D) resistor r=49.7141 c=0
Rl34 (\2\:D \3\:D) resistor r=8.3038 c=0
Rl31 (\1\:CK \2\:CK) resistor r=26.911 c=0
Rl32 (\2\:CK \3\:CK) resistor r=132.487 c=0
Rl42 (\4\:SE \5\:SE) resistor r=74.2328 c=0
Rl43 (\5\:SE \6\:SE) resistor r=30.0021 c=0
Rl38 (\2\:SE \3\:SE) resistor r=125.789 c=0
Rl37 (\1\:SE \2\:SE) resistor r=43.4636 c=0
Rl5 (\1\:SN \2\:SN) resistor r=37.3411 c=0
Rl7 (\2\:SN \4\:SN) resistor r=135.418 c=0
Rl6 (\2\:SN \3\:SN) resistor r=10.9341 c=0
Rl14 (\5\:SN \6\:SN) resistor r=49.7185 c=0
Rl16 (\6\:SN \8\:SN) resistor r=111.257 c=0
Rl15 (\6\:SN \7\:SN) resistor r=3.3229 c=0
Rl40 (\1\:SI \2\:SI) resistor r=41.0764 c=0
Rl41 (\2\:SI \3\:SI) resistor r=144.488 c=0
Rl8 (\4\:qbint \5\:qbint) resistor r=131.81 c=0
Rl9 (\5\:qbint \6\:qbint) resistor r=26.3736 c=0
Rl1 (qbint \2\:qbint) resistor r=24.2328 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=39.6174 c=0
Rl3 (n30 \2\:n30) resistor r=53.079 c=0
Rl4 (\2\:n30 \3\:n30) resistor r=116.862 c=0
Rl26 (\7\:CKb \8\:CKb) resistor r=55.0021 c=0
Rl29 (\10\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl22 (\5\:CKb \6\:CKb) resistor r=47.3097 c=0
Rl13 (\3\:CKb \4\:CKb) resistor r=122.977 c=0
Rl10 (CKb \2\:CKb) resistor r=29.5379 c=0
Rl30 (\9\:CKb \12\:CKb) resistor r=23.4163 c=0
Rl27 (\8\:CKb \9\:CKb) resistor r=12.6847 c=0
Rl28 (\9\:CKb \10\:CKb) resistor r=157.901 c=0
Rl20 (mout \2\:mout) resistor r=92.2849 c=0
Rl21 (\2\:mout \3\:mout) resistor r=97.872 c=0
Rl11 (CKbb \2\:CKbb) resistor r=126.923 c=0
Rl12 (CKbb \3\:CKbb) resistor r=64.1533 c=0
Rl23 (\4\:CKbb \5\:CKbb) resistor r=23.7402 c=0
Rl24 (\5\:CKbb \6\:CKbb) resistor r=197.951 c=0
Rl25 (\5\:CKbb \7\:CKbb) resistor r=5.1011 c=0
Rl17 (n20 \2\:n20) resistor r=0.6084 c=0
Rl19 (\2\:n20 \4\:n20) resistor r=37.3411 c=0
Rl18 (\2\:n20 \3\:n20) resistor r=152.291 c=0
Rl39 (\3\:SEb \4\:SEb) resistor r=24.2328 c=0
Rl36 (SEb \2\:SEb) resistor r=49.2328 c=0
Rz1 (\4\:Q \5\:Q) resistor r=75 c=0
Rz15 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz16 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz17 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz18 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz19 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz20 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz21 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz22 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz12 (\3\:VDD \4\:VDD) resistor r=9.375 c=0
Rz13 (\3\:VDD \13\:VDD) resistor r=6.25 c=0
Rz14 (\3\:VDD \23\:VDD) resistor r=6.25 c=0
Rz2 (\9\:qbint \10\:qbint) resistor r=75 c=0
Rz3 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz8 (\19\:CKb \20\:CKb) resistor r=75 c=0
Rz4 (\8\:mout \9\:mout) resistor r=75 c=0
Rz5 (\10\:mout \11\:mout) resistor r=75 c=0
Rz7 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz6 (\5\:n20 \6\:n20) resistor r=75 c=0
Rz9 (Db \2\:Db) resistor r=75 c=0
Rz10 (\4\:Db \5\:Db) resistor r=75 c=0
Rz11 (\5\:SEb \6\:SEb) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=62 c=0
Ry23 (\3\:VSS \4\:VSS) resistor r=7.75 c=0
Ry24 (\3\:VSS \6\:VSS) resistor r=15.5 c=0
Ry25 (\3\:VSS \8\:VSS) resistor r=12.4 c=0
Ry26 (\3\:VSS \10\:VSS) resistor r=20.6667 c=0
Ry27 (\3\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry14 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry15 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry16 (\8\:VDD \9\:VDD) resistor r=31 c=0
Ry17 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry18 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry19 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry20 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry21 (\25\:VDD \26\:VDD) resistor r=62 c=0
Ry22 (\28\:VDD \29\:VDD) resistor r=20.6667 c=0
Ry2 (\11\:qbint \12\:qbint) resistor r=62 c=0
Ry5 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry10 (\23\:CKb \24\:CKb) resistor r=62 c=0
Ry6 (\12\:mout \13\:mout) resistor r=62 c=0
Ry7 (\14\:mout \15\:mout) resistor r=62 c=0
Ry9 (\10\:CKbb \11\:CKbb) resistor r=62 c=0
Ry8 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry11 (\6\:Db \7\:Db) resistor r=62 c=0
Ry12 (\8\:Db \9\:Db) resistor r=62 c=0
Ry13 (\9\:SEb \10\:SEb) resistor r=62 c=0
Ry3 (net355 \2\:net355) resistor r=62 c=0
Ry4 (\3\:net355 \4\:net355) resistor r=62 c=0
Rx16 (\3\:D \5\:D) resistor r=45 c=0
Rx15 (\2\:CK \4\:CK) resistor r=45 c=0
Rx20 (\2\:SE \7\:SE) resistor r=45 c=0
Rx21 (\5\:SE \8\:SE) resistor r=45 c=0
Rx4 (\3\:SN \9\:SN) resistor r=45 c=0
Rx5 (\7\:SN \10\:SN) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\5\:qbint \7\:qbint) resistor r=45 c=0
Rx2 (\2\:qbint \13\:qbint) resistor r=45 c=0
Rx3 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx8 (\10\:CKb \13\:CKb) resistor r=45 c=0
Rx9 (\2\:CKb \16\:CKb) resistor r=45 c=0
Rx10 (\6\:CKb \17\:CKb) resistor r=45 c=0
Rx11 (\3\:CKb \18\:CKb) resistor r=45 c=0
Rx14 (\8\:CKb \22\:CKb) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx12 (\7\:CKbb \8\:CKbb) resistor r=45 c=0
Rx13 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx7 (n20 \9\:n20) resistor r=45 c=0
Rx18 (\2\:SEb \7\:SEb) resistor r=45 c=0
Rx19 (\4\:SEb \8\:SEb) resistor r=45 c=0
mn55 (\4\:Q qbint \27\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.89e-14 ad=4.94e-14 ps=1.05e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.65e-07 sb=1.9e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn45 (\9\:qbint n30 \25\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.87e-14 ps=7.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-06 sd=160n sca=11.535 scb=0.0112489 \
        scc=0.00047927 m=(1)
mn50 (net459 \4\:SN \25\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.28e-14 ad=2.152e-14 ps=7.3e-07 pd=6.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=7.95e-07 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn51 (net467 \6\:qbint net459 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.153e-14 ad=2.768e-14 ps=6.2e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.95e-07 sb=6.45e-07 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn52 (\4\:n30 CKb net467 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.767e-14 ad=5.432e-14 ps=6.8e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=4.65e-07 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn40 (\4\:n30 \2\:CKbb \8\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.177e-14 ad=5.432e-14 ps=7.2e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=1.55e-07 sd=160n sca=11.535 \
        scb=0.0112489 scc=0.00047927 m=(1)
mn30 (net435 \8\:SN \23\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=1.23e-14 ps=1.34e-06 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=2.45e-07 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn31 (\10\:mout \3\:n20 net435 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.87e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.4e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn35 (net427 mout \21\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=1.435e-14 ps=6.9e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.75e-07 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn36 (\5\:n20 \6\:CKbb net427 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.435e-14 ad=3.69e-14 ps=5.5e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=4.6e-07 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn25 (\5\:n20 \11\:CKb \4\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.818e-14 ad=3.69e-14 ps=8.8e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.8e-07 sb=2.35e-07 sd=160n sca=11.2689 \
        scb=0.0108709 scc=0.000440973 m=(1)
mn21 (\13\:CKbb \12\:CKb \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.48e-14 ad=2.03e-14 ps=1.45e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=16.7245 scb=0.0178071 \
        scc=0.00133148 m=(1)
mn20 (\19\:CKb \3\:CK \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=3.988e-14 ps=9.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.75e-07 sb=9.65e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn11 (net443 \4\:D \17\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=4.29e-14 ps=9.2e-07 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.51923e-07 sb=7.2e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(1)
mn12 (Db SEb net443 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.29e-14 \
        ad=4.16e-14 ps=8.5e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.61923e-07 sb=5.1e-07 sd=160n sca=8.51051 scb=0.00656948 \
        scc=0.000151659 m=(1)
mn14 (Db \1\:SE net455 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.12e-14 ad=4.16e-14 ps=7.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.66923e-07 sb=3.05e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(1)
mn13 (net455 \3\:SI \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.12e-14 ps=8e-07 pd=7.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.31923e-07 sb=1.4e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(1)
mn10 (\5\:SEb \6\:SE \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.4e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mp45 (\11\:qbint \3\:n30 \25\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.012e-13 ad=4.34e-14 ps=1.61e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.7e-07 sd=160n sca=12.9031 \
        scb=0.0116454 scc=0.000496931 m=(1)
mp50 (\3\:net355 \1\:SN \25\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.012e-13 ad=4.96e-14 ps=1.61e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=3.05e-07 sd=160n sca=12.9031 \
        scb=0.0116454 scc=0.000496931 m=(1)
mp51 (\3\:net355 \4\:qbint \21\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.315e-14 ad=4.96e-14 ps=1.51e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.1e-07 sb=1e-07 sd=160n sca=12.9031 scb=0.0116454 \
        scc=0.000496931 m=(1)
mp52 (\8\:n30 CKbb net355 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.52e-14 ad=4.96e-14 ps=1.04e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78065e-07 sb=3.20484e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp40 (\8\:n30 \4\:CKb \14\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.58e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.83065e-07 sb=1.15484e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\12\:mout \5\:SN \18\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=6.045e-14 ps=1.46e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.14339e-06 sd=160n sca=11.9807 \
        scb=0.0103871 scc=0.000334607 m=(1)
mp31 (\12\:mout \4\:n20 \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.82e-14 ad=6.045e-14 ps=1.56e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.4e-07 sb=9.03387e-07 sd=160n sca=11.9807 \
        scb=0.0103871 scc=0.000334607 m=(1)
mp35 (net378 \3\:mout \15\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.82e-14 ad=2.48e-14 ps=1.56e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=6.38387e-07 sd=160n sca=11.9807 \
        scb=0.0103871 scc=0.000334607 m=(1)
mp36 (\7\:n20 \5\:CKb net378 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=2.48e-14 ad=7.905e-14 ps=7.8e-07 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=5.13387e-07 sd=160n sca=11.9807 \
        scb=0.0103871 scc=0.000334607 m=(1)
mp25 (\7\:n20 \4\:CKbb \8\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.615e-14 ad=7.905e-14 ps=1.19e-06 pd=1.13e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.03e-06 sb=2.13387e-07 sd=160n sca=11.9807 \
        scb=0.0103871 scc=0.000334607 m=(1)
mp21 (\10\:CKbb \7\:CKb \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.333e-14 ad=4.97e-14 ps=7.4e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.31163e-07 sb=1.55e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\23\:CKb \1\:CK \8\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.01e-06 sd=160n sca=16.4667 \
        scb=0.0163489 scc=0.00112485 m=(1)
mp11 (net390 \1\:D \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=1.248e-13 ps=1.16e-06 pd=1.42e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=7.87308e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp12 (\6\:Db \3\:SE net390 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.248e-13 ad=6.24e-14 ps=1.42e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.34551e-07 sb=4.22308e-07 sd=160n sca=13.5671 \
        scb=0.012183 scc=0.000647513 m=(1)
mp14 (\6\:Db \3\:SEb net398 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.39551e-07 sb=2.17308e-07 sd=160n sca=13.5765 \
        scb=0.0121847 scc=0.000647513 m=(1)
mp13 (net398 \1\:SI \5\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.38e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.44551e-07 sb=1.12308e-07 sd=160n sca=13.8119 \
        scb=0.0122457 scc=0.000647522 m=(1)
mp10 (\9\:SEb \4\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.89e-14 ad=3.01e-14 ps=1.13e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=56.5915 scb=0.0440321 \
        scc=0.00674534 m=(1)
ends SDFFSHQX1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:36:31 2012 )
// Library name: gsclib045
// Cell name: SDFFSHQX2
// View name: extracted

simulator lang=spectre

subckt SDFFSHQX2 CK D Q SE SI SN VDD VSS
mp55_1__rcx (\1\:Q qbint \29\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.998e-14 ad=6.24e-14 ps=1.105e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.19615e-07 sd=160n sca=35.0309 \
        scb=0.0261374 scc=0.00344587 m=(2)
C1 (D VSS) capacitor c=5.31618e-17
C2 (CK VSS) capacitor c=3.87431e-17
C3 (Q VSS) capacitor c=2.63621e-17
C4 (VDD VSS) capacitor c=3.21759e-16
C5 (SN VSS) capacitor c=1.85109e-16
C6 (SI VSS) capacitor c=8.03093e-17
C7 (qbint VSS) capacitor c=1.35175e-16
C8 (n30 VSS) capacitor c=5.23203e-17
C9 (net459 VSS) capacitor c=2.63748e-18
C10 (net467 VSS) capacitor c=1.87807e-18
C11 (CKb VSS) capacitor c=4.51669e-17
C12 (mout VSS) capacitor c=4.97955e-17
C13 (CKbb VSS) capacitor c=5.10168e-17
C14 (net435 VSS) capacitor c=3.39619e-19
C15 (n20 VSS) capacitor c=4.89451e-17
C16 (net427 VSS) capacitor c=1.92109e-18
C17 (Db VSS) capacitor c=1.11859e-16
C18 (net443 VSS) capacitor c=1.80112e-18
C19 (SEb VSS) capacitor c=6.60912e-17
C20 (net455 VSS) capacitor c=4.78098e-18
C21 (net355 VSS) capacitor c=7.7866e-17
C22 (net378 VSS) capacitor c=4.33373e-18
C23 (net390 VSS) capacitor c=4.16904e-18
C24 (net398 VSS) capacitor c=1.95393e-18
C25 (\8\:SE VSS) capacitor c=3.32516e-17
C26 (\1\:SI VSS) capacitor c=7.25338e-17
C27 (\3\:SEb VSS) capacitor c=6.52133e-17
C28 (\3\:SE VSS) capacitor c=5.9175e-17
C29 (\1\:D VSS) capacitor c=5.26984e-17
C30 (\1\:CK VSS) capacitor c=2.58322e-17
C31 (\12\:CKb VSS) capacitor c=1.95192e-17
C32 (\4\:CKbb VSS) capacitor c=3.14483e-17
C33 (\5\:CKb VSS) capacitor c=4.85914e-17
C34 (\4\:mout VSS) capacitor c=6.52101e-17
C35 (\5\:SN VSS) capacitor c=3.95976e-17
C36 (\4\:CKb VSS) capacitor c=5.94582e-17
C37 (\9\:qbint VSS) capacitor c=5.69446e-17
C38 (\1\:SN VSS) capacitor c=3.30876e-17
C39 (\7\:SE VSS) capacitor c=2.44352e-17
C40 (\3\:SI VSS) capacitor c=5.15267e-17
C41 (\4\:SE VSS) capacitor c=4.03057e-17
C42 (\4\:D VSS) capacitor c=7.09366e-17
C43 (\3\:CK VSS) capacitor c=3.70053e-17
C44 (\7\:CKb VSS) capacitor c=1.56778e-17
C45 (\11\:CKb VSS) capacitor c=2.22452e-17
C46 (\6\:CKbb VSS) capacitor c=7.39056e-17
C47 (\3\:n20 VSS) capacitor c=7.63671e-17
C48 (\7\:SN VSS) capacitor c=6.853e-17
C49 (\2\:CKbb VSS) capacitor c=4.13156e-17
C50 (\11\:qbint VSS) capacitor c=4.64007e-17
C51 (\4\:SN VSS) capacitor c=5.64523e-17
C52 (\3\:n30 VSS) capacitor c=3.46796e-17
C53 (\5\:SE VSS) capacitor c=1.52676e-17
C54 (\2\:SI VSS) capacitor c=5.33434e-17
C55 (\4\:SEb VSS) capacitor c=3.94592e-17
C56 (\1\:SE VSS) capacitor c=3.57752e-17
C57 (\2\:SEb VSS) capacitor c=4.73641e-17
C58 (\3\:D VSS) capacitor c=3.37381e-17
C59 (\2\:CK VSS) capacitor c=4.38532e-17
C60 (\10\:CKb VSS) capacitor c=3.85692e-17
C61 (\5\:CKbb VSS) capacitor c=4.30479e-17
C62 (\6\:CKb VSS) capacitor c=4.90913e-17
C63 (\3\:mout VSS) capacitor c=1.84812e-17
C64 (\2\:n20 VSS) capacitor c=6.01186e-17
C65 (\6\:SN VSS) capacitor c=5.20301e-17
C66 (\3\:CKb VSS) capacitor c=4.21805e-17
C67 (\3\:CKbb VSS) capacitor c=2.66728e-17
C68 (\2\:CKb VSS) capacitor c=4.14007e-17
C69 (\10\:qbint VSS) capacitor c=5.2908e-17
C70 (\3\:SN VSS) capacitor c=2.34137e-17
C71 (\4\:n30 VSS) capacitor c=3.79376e-17
C72 (\6\:qbint VSS) capacitor c=2.24367e-17
C73 (\1\:VDD VSS) capacitor c=3.22757e-17
C74 (\10\:SEb VSS) capacitor c=8.46453e-17
C75 (\15\:VDD VSS) capacitor c=2.78059e-17
C76 (\17\:VDD VSS) capacitor c=6.10972e-17
C77 (\22\:CKb VSS) capacitor c=7.21588e-17
C78 (\19\:VDD VSS) capacitor c=6.77665e-17
C79 (\10\:CKbb VSS) capacitor c=1.05284e-16
C80 (\6\:Db VSS) capacitor c=1.19089e-16
C81 (\4\:n20 VSS) capacitor c=3.96636e-17
C82 (\21\:VDD VSS) capacitor c=1.76787e-17
C83 (\13\:mout VSS) capacitor c=5.71176e-17
C84 (\23\:VDD VSS) capacitor c=1.99371e-17
C85 (\15\:mout VSS) capacitor c=2.7037e-17
C86 (\7\:n30 VSS) capacitor c=6.20047e-17
C87 (\25\:VDD VSS) capacitor c=1.2135e-17
C88 (\3\:net355 VSS) capacitor c=7.83116e-17
C89 (\27\:VDD VSS) capacitor c=9.80889e-18
C90 (\17\:qbint VSS) capacitor c=6.50784e-17
C91 (\1\:Q VSS) capacitor c=9.23012e-17
C92 (\3\:VDD VSS) capacitor c=1.09068e-16
C93 (\8\:SEb VSS) capacitor c=9.86982e-17
C94 (\8\:Db VSS) capacitor c=4.24039e-17
C95 (\18\:CKb VSS) capacitor c=8.02818e-17
C96 (\12\:CKbb VSS) capacitor c=6.41761e-17
C97 (\4\:Db VSS) capacitor c=1.99634e-16
C98 (\8\:n20 VSS) capacitor c=8.30624e-17
C99 (\11\:mout VSS) capacitor c=5.44076e-17
C100 (\9\:mout VSS) capacitor c=6.32265e-17
C101 (\9\:n30 VSS) capacitor c=7.08695e-17
C102 (\13\:qbint VSS) capacitor c=7.68709e-17
C103 (\4\:Q VSS) capacitor c=1.18848e-17
C104 (\2\:n30 VSS) capacitor c=3.48201e-17
C105 (\2\:SN VSS) capacitor c=2.76386e-17
C106 (\2\:mout VSS) capacitor c=4.21745e-17
C107 (\9\:CKb VSS) capacitor c=2.36073e-17
C108 (\2\:D VSS) capacitor c=3.68623e-17
C109 (\3\:Q VSS) capacitor c=2.19121e-17
C110 (\2\:SE VSS) capacitor c=5.5758e-17
C111 (\6\:SE VSS) capacitor c=1.42305e-17
C112 (\12\:qbint VSS) capacitor c=8.12931e-17
C113 (\15\:qbint VSS) capacitor c=3.24015e-17
C114 (\16\:qbint VSS) capacitor c=2.91967e-17
C115 (\5\:n30 VSS) capacitor c=1.13776e-16
C116 (\6\:n30 VSS) capacitor c=1.10868e-16
C117 (\9\:SN VSS) capacitor c=2.0402e-16
C118 (\5\:mout VSS) capacitor c=4.13786e-17
C119 (\7\:mout VSS) capacitor c=8.50272e-17
C120 (\8\:mout VSS) capacitor c=7.09661e-17
C121 (\6\:n20 VSS) capacitor c=8.37868e-17
C122 (\7\:n20 VSS) capacitor c=6.4458e-17
C123 (\13\:CKb VSS) capacitor c=1.09113e-16
C124 (\14\:CKb VSS) capacitor c=2.00363e-16
C125 (\15\:CKb VSS) capacitor c=2.56297e-16
C126 (\16\:CKb VSS) capacitor c=1.49077e-16
C127 (\17\:CKb VSS) capacitor c=4.23022e-17
C128 (\7\:CKbb VSS) capacitor c=5.8843e-17
C129 (\8\:CKbb VSS) capacitor c=1.68952e-16
C130 (\9\:CKbb VSS) capacitor c=1.84119e-16
C131 (\20\:CKb VSS) capacitor c=7.62441e-17
C132 (\21\:CKb VSS) capacitor c=2.76718e-17
C133 (\4\:CK VSS) capacitor c=7.79851e-17
C134 (\5\:D VSS) capacitor c=6.70286e-17
C135 (\3\:Db VSS) capacitor c=2.34981e-16
C136 (\5\:SEb VSS) capacitor c=2.19406e-17
C137 (\6\:SEb VSS) capacitor c=7.77116e-17
C138 (\7\:SEb VSS) capacitor c=9.72265e-17
C139 (\4\:SI VSS) capacitor c=4.66921e-17
C140 (\9\:SE VSS) capacitor c=8.62544e-17
C141 (\10\:SE VSS) capacitor c=1.00084e-16
C142 (\5\:VDD VSS) capacitor c=1.70051e-17
C143 (\6\:VDD VSS) capacitor c=1.30816e-17
C144 (\8\:VDD VSS) capacitor c=1.72069e-17
C145 (\10\:VDD VSS) capacitor c=4.4218e-18
C146 (\12\:VDD VSS) capacitor c=2.00919e-17
C147 (\13\:VDD VSS) capacitor c=2.69181e-17
C148 (\29\:VDD VSS) capacitor c=1.52374e-16
Rk36 (\5\:D D) resistor r=0.1605 c=0
Rk71 (\2\:VSS \4\:VSS) resistor r=0.376 c=0
Rk72 (\4\:VSS \5\:VSS) resistor r=0.1353 c=0
Rk73 (\5\:VSS \6\:VSS) resistor r=0.2658 c=0
Rk74 (\6\:VSS \7\:VSS) resistor r=0.1127 c=0
Rk75 (\7\:VSS \8\:VSS) resistor r=0.3976 c=0
Rk76 (\8\:VSS \9\:VSS) resistor r=0.3401 c=0
Rk77 (\9\:VSS \10\:VSS) resistor r=0.2281 c=0
Rk78 (\10\:VSS \11\:VSS) resistor r=0.3509 c=0
Rk79 (\11\:VSS \12\:VSS) resistor r=0.6246 c=0
Rk80 (\12\:VSS \13\:VSS) resistor r=0.03744 c=0
Rk83 (\14\:VSS VSS) resistor r=0.08235 c=0
Rk81 (\13\:VSS \14\:VSS) resistor r=0.2129 c=0
Rk84 (\5\:VSS \17\:VSS) resistor r=0.1917 c=0
Rk85 (\7\:VSS \19\:VSS) resistor r=0.1884 c=0
Rk86 (\8\:VSS \21\:VSS) resistor r=0.04334 c=0
Rk87 (\10\:VSS \23\:VSS) resistor r=0.2977 c=0
Rk88 (\11\:VSS \25\:VSS) resistor r=0.2925 c=0
Rk89 (\13\:VSS \27\:VSS) resistor r=0.2205 c=0
Rk35 (CK \4\:CK) resistor r=0.03865 c=0
Rk2 (\3\:Q Q) resistor r=0.07426 c=0
Rk1 (\2\:Q \3\:Q) resistor r=0.2624 c=0
Rk3 (\3\:Q \5\:Q) resistor r=0.06087 c=0
Rk46 (SE \9\:SE) resistor r=0.005081 c=0
Rk47 (\9\:SE \10\:SE) resistor r=0.4235 c=0
Rk48 (\2\:VDD \4\:VDD) resistor r=0.5246 c=0
Rk49 (\4\:VDD \5\:VDD) resistor r=0.1353 c=0
Rk50 (\5\:VDD \6\:VDD) resistor r=0.3785 c=0
Rk51 (\6\:VDD \7\:VDD) resistor r=0.03744 c=0
Rk52 (\7\:VDD \8\:VDD) resistor r=0.3962 c=0
Rk53 (\8\:VDD \9\:VDD) resistor r=0.3059 c=0
Rk54 (\9\:VDD \10\:VDD) resistor r=0.2999 c=0
Rk55 (\10\:VDD \11\:VDD) resistor r=0.1494 c=0
Rk56 (\11\:VDD \12\:VDD) resistor r=0.08416 c=0
Rk57 (\12\:VDD \13\:VDD) resistor r=0.4519 c=0
Rk58 (\13\:VDD \14\:VDD) resistor r=0.2121 c=0
Rk59 (\5\:VDD \16\:VDD) resistor r=0.2454 c=0
Rk60 (\6\:VDD \18\:VDD) resistor r=0.336 c=0
Rk61 (\8\:VDD \20\:VDD) resistor r=0.4615 c=0
Rk62 (\10\:VDD \22\:VDD) resistor r=0.04334 c=0
Rk63 (\12\:VDD \24\:VDD) resistor r=0.04334 c=0
Rk64 (\13\:VDD \26\:VDD) resistor r=0.04334 c=0
Rk65 (\14\:VDD \28\:VDD) resistor r=0.07151 c=0
Rk70 (\29\:VDD VDD) resistor r=0.08235 c=0
Rk66 (\14\:VDD \29\:VDD) resistor r=0.2643 c=0
Rk12 (SN \8\:SN) resistor r=0.02276 c=0
Rk13 (\8\:SN \9\:SN) resistor r=1.4232 c=0
Rk45 (SI \4\:SI) resistor r=0.07182 c=0
Rk4 (\12\:qbint \14\:qbint) resistor r=0.5082 c=0
Rk5 (\14\:qbint \15\:qbint) resistor r=0.182 c=0
Rk6 (\15\:qbint \16\:qbint) resistor r=0.1523 c=0
Rk7 (\15\:qbint \18\:qbint) resistor r=0.2507 c=0
Rk9 (\5\:n30 \6\:n30) resistor r=0.6647 c=0
Rk10 (\6\:n30 \8\:n30) resistor r=0.2376 c=0
Rk11 (\6\:n30 \10\:n30) resistor r=0.2901 c=0
Rk24 (\13\:CKb \14\:CKb) resistor r=0.719 c=0
Rk25 (\14\:CKb \15\:CKb) resistor r=1.0761 c=0
Rk26 (\15\:CKb \16\:CKb) resistor r=1.038 c=0
Rk27 (\14\:CKb \17\:CKb) resistor r=0.1713 c=0
Rk32 (\19\:CKb \20\:CKb) resistor r=0.3871 c=0
Rk33 (\20\:CKb \21\:CKb) resistor r=0.1422 c=0
Rk34 (\20\:CKb \23\:CKb) resistor r=0.5243 c=0
Rk14 (\5\:mout \6\:mout) resistor r=0.229 c=0
Rk15 (\6\:mout \7\:mout) resistor r=0.04688 c=0
Rk16 (\7\:mout \8\:mout) resistor r=0.4107 c=0
Rk17 (\8\:mout \10\:mout) resistor r=0.3424 c=0
Rk18 (\6\:mout \12\:mout) resistor r=0.1863 c=0
Rk19 (\7\:mout \14\:mout) resistor r=0.278 c=0
Rk20 (\8\:mout \16\:mout) resistor r=0.07544 c=0
Rk28 (\7\:CKbb \8\:CKbb) resistor r=0.2563 c=0
Rk29 (\8\:CKbb \9\:CKbb) resistor r=1.2996 c=0
Rk30 (\8\:CKbb \11\:CKbb) resistor r=0.5365 c=0
Rk31 (\11\:CKbb \13\:CKbb) resistor r=0.324 c=0
Rk21 (\5\:n20 \6\:n20) resistor r=0.113 c=0
Rk22 (\6\:n20 \7\:n20) resistor r=0.3854 c=0
Rk23 (\6\:n20 \9\:n20) resistor r=0.3773 c=0
Rk37 (\2\:Db \3\:Db) resistor r=0.7304 c=0
Rk38 (\3\:Db \5\:Db) resistor r=1.1244 c=0
Rk39 (\5\:Db \7\:Db) resistor r=0.5304 c=0
Rk40 (\3\:Db \9\:Db) resistor r=0.27 c=0
Rk41 (\5\:SEb \6\:SEb) resistor r=0.04823 c=0
Rk42 (\6\:SEb \7\:SEb) resistor r=0.3083 c=0
Rk43 (\6\:SEb \9\:SEb) resistor r=0.557 c=0
Rk44 (\7\:SEb \11\:SEb) resistor r=0.5177 c=0
Rk8 (\2\:net355 \4\:net355) resistor r=0.2316 c=0
Rl37 (\1\:D \2\:D) resistor r=84.8746 c=0
Rl39 (\2\:D \4\:D) resistor r=97.7584 c=0
Rl38 (\2\:D \3\:D) resistor r=73.0022 c=0
Rl35 (\1\:CK \2\:CK) resistor r=51.1559 c=0
Rl36 (\2\:CK \3\:CK) resistor r=141.541 c=0
Rl43 (\2\:SE \3\:SE) resistor r=133.211 c=0
Rl44 (\2\:SE \4\:SE) resistor r=48.5834 c=0
Rl42 (\1\:SE \2\:SE) resistor r=12.4379 c=0
Rl49 (\6\:SE \8\:SE) resistor r=88.1757 c=0
Rl48 (\6\:SE \7\:SE) resistor r=47.791 c=0
Rl47 (\5\:SE \6\:SE) resistor r=6.7128 c=0
Rl20 (\5\:SN \6\:SN) resistor r=41.4941 c=0
Rl21 (\6\:SN \7\:SN) resistor r=147.31 c=0
Rl11 (\1\:SN \2\:SN) resistor r=34.3295 c=0
Rl13 (\2\:SN \4\:SN) resistor r=111.253 c=0
Rl12 (\2\:SN \3\:SN) resistor r=16.2825 c=0
Rl45 (\1\:SI \2\:SI) resistor r=26.098 c=0
Rl46 (\2\:SI \3\:SI) resistor r=122.252 c=0
Rl14 (\10\:qbint \9\:qbint) resistor r=103.846 c=0
Rl15 (\10\:qbint \11\:qbint) resistor r=26.3736 c=0
Rl5 (\6\:qbint qbint) resistor r=5.1512 c=0
Rl8 (n30 \2\:n30) resistor r=93.4643 c=0
Rl9 (\2\:n30 \3\:n30) resistor r=28.0797 c=0
Rl10 (\2\:n30 \4\:n30) resistor r=91.222 c=0
Rl30 (\7\:CKb \8\:CKb) resistor r=22.0693 c=0
Rl33 (\10\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl27 (\5\:CKb \6\:CKb) resistor r=78.079 c=0
Rl19 (\3\:CKb \4\:CKb) resistor r=143.744 c=0
Rl16 (CKb \2\:CKb) resistor r=29.5379 c=0
Rl34 (\9\:CKb \12\:CKb) resistor r=47.1143 c=0
Rl31 (\8\:CKb \9\:CKb) resistor r=10.2272 c=0
Rl32 (\9\:CKb \10\:CKb) resistor r=144.788 c=0
Rl24 (mout \2\:mout) resistor r=100.368 c=0
Rl26 (\2\:mout \4\:mout) resistor r=110.418 c=0
Rl25 (\2\:mout \3\:mout) resistor r=3.7301 c=0
Rl17 (CKbb \2\:CKbb) resistor r=125 c=0
Rl28 (\4\:CKbb \5\:CKbb) resistor r=24.2328 c=0
Rl29 (\5\:CKbb \6\:CKbb) resistor r=191.428 c=0
Rl18 (CKbb \3\:CKbb) resistor r=50.6918 c=0
Rl22 (n20 \2\:n20) resistor r=29.5379 c=0
Rl23 (\2\:n20 \3\:n20) resistor r=194.488 c=0
Rl41 (\3\:SEb \4\:SEb) resistor r=24.2328 c=0
Rl40 (SEb \2\:SEb) resistor r=39.6174 c=0
Rz17 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz18 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz19 (\19\:VSS \18\:VSS) resistor r=75 c=0
Rz20 (\21\:VSS \20\:VSS) resistor r=75 c=0
Rz21 (\23\:VSS \22\:VSS) resistor r=75 c=0
Rz22 (\25\:VSS \24\:VSS) resistor r=75 c=0
Rz23 (\27\:VSS \26\:VSS) resistor r=75 c=0
Rz1 (\5\:Q \4\:Q) resistor r=75 c=0
Rz12 (\4\:VDD \3\:VDD) resistor r=25 c=0
Rz13 (\7\:VDD \3\:VDD) resistor r=9.375 c=0
Rz14 (\9\:VDD \3\:VDD) resistor r=12.5 c=0
Rz15 (\11\:VDD \3\:VDD) resistor r=25 c=0
Rz16 (\14\:VDD \3\:VDD) resistor r=6.25 c=0
Rz2 (\14\:qbint \13\:qbint) resistor r=75 c=0
Rz3 (\9\:n30 \10\:n30) resistor r=75 c=0
Rz8 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz4 (\9\:mout \10\:mout) resistor r=75 c=0
Rz5 (\11\:mout \12\:mout) resistor r=75 c=0
Rz7 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz6 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz9 (\4\:Db \5\:Db) resistor r=75 c=0
Rz10 (\8\:Db \9\:Db) resistor r=75 c=0
Rz11 (\8\:SEb \9\:SEb) resistor r=75 c=0
Ry24 (\4\:VSS \3\:VSS) resistor r=20.6667 c=0
Ry25 (\6\:VSS \3\:VSS) resistor r=12.4 c=0
Ry26 (\9\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry27 (\12\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry1 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry14 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry15 (\16\:VDD \15\:VDD) resistor r=62 c=0
Ry16 (\18\:VDD \17\:VDD) resistor r=20.6667 c=0
Ry17 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry18 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry19 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry20 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry21 (\28\:VDD \27\:VDD) resistor r=62 c=0
Ry2 (\18\:qbint \17\:qbint) resistor r=31 c=0
Ry5 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry10 (\22\:CKb \23\:CKb) resistor r=62 c=0
Ry6 (\13\:mout \14\:mout) resistor r=62 c=0
Ry7 (\15\:mout \16\:mout) resistor r=62 c=0
Ry9 (\10\:CKbb \11\:CKbb) resistor r=62 c=0
Ry8 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry11 (Db \2\:Db) resistor r=20.6667 c=0
Ry12 (\6\:Db \7\:Db) resistor r=62 c=0
Ry13 (\10\:SEb \11\:SEb) resistor r=62 c=0
Ry3 (net355 \2\:net355) resistor r=62 c=0
Ry4 (\3\:net355 \4\:net355) resistor r=62 c=0
Rx16 (\3\:D \5\:D) resistor r=45 c=0
Rx15 (\2\:CK \4\:CK) resistor r=45 c=0
Rx20 (\5\:SE \9\:SE) resistor r=45 c=0
Rx21 (\1\:SE \10\:SE) resistor r=45 c=0
Rx4 (\3\:SN \8\:SN) resistor r=45 c=0
Rx5 (\6\:SN \9\:SN) resistor r=45 c=0
Rx19 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\12\:qbint \10\:qbint) resistor r=45 c=0
Rx2 (\16\:qbint \6\:qbint) resistor r=45 c=0
Rx3 (\4\:n30 \5\:n30) resistor r=45 c=0
Rx8 (\10\:CKb \13\:CKb) resistor r=45 c=0
Rx9 (\3\:CKb \15\:CKb) resistor r=45 c=0
Rx10 (\2\:CKb \16\:CKb) resistor r=45 c=0
Rx11 (\6\:CKb \17\:CKb) resistor r=45 c=0
Rx14 (\8\:CKb \21\:CKb) resistor r=45 c=0
Rx6 (\3\:mout \5\:mout) resistor r=45 c=0
Rx12 (\5\:CKbb \7\:CKbb) resistor r=45 c=0
Rx13 (\3\:CKbb \9\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx17 (\2\:SEb \5\:SEb) resistor r=45 c=0
Rx18 (\4\:SEb \7\:SEb) resistor r=45 c=0
mn55 (\4\:Q qbint \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.735e-14 ad=4.81e-14 ps=8.2e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.23173e-07 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(2)
mn45 (\13\:qbint \3\:n30 \14\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.83e-14 ad=2.87e-14 ps=8.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=1.4e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn50 (net459 \4\:SN \26\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.215e-14 ad=1.742e-14 ps=8.8e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.1878e-07 sb=7.3e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn51 (net467 \11\:qbint net459 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.742e-14 ad=2.767e-14 ps=5.8e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.4878e-07 sb=6e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn52 (\9\:n30 CKb net467 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.767e-14 ad=4.817e-14 ps=6.8e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.2878e-07 sb=4.2e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn40 (\9\:n30 \2\:CKbb \9\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=4.817e-14 ps=6.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.0878e-07 sb=1.4e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn30 (net435 \7\:SN \24\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.587e-14 ad=1.332e-14 ps=7.6e-07 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=2.5e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn31 (\11\:mout \3\:n20 net435 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.332e-14 ad=2.87e-14 ps=5.4e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.4e-07 sd=160n sca=11.814 \
        scb=0.0116374 scc=0.000520744 m=(1)
mn35 (net427 mout \22\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=2.05e-14 ps=6.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.35e-07 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn36 (\8\:n20 \6\:CKbb net427 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=4.305e-14 ps=6.1e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=4.9e-07 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn25 (\8\:n20 \11\:CKb \4\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.817e-14 ad=4.305e-14 ps=8.8e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=2.35e-07 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn21 (\12\:CKbb \7\:CKb \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.445e-14 ad=2.03e-14 ps=1.46e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=19.8813 \
        scb=0.0206549 scc=0.00197265 m=(1)
mn20 (\18\:CKb \3\:CK \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.322e-14 ad=2.175e-14 ps=1.17e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=1.09e-06 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn11 (net443 \4\:D \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.322e-14 ad=1.82e-14 ps=1.17e-06 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.51923e-07 sb=7.2e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(1)
mn12 (\8\:Db SEb net443 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.82e-14 ad=4.16e-14 ps=6.6e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.66923e-07 sb=6.05e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(1)
mn14 (\8\:Db \4\:SE net455 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.59e-14 ad=4.16e-14 ps=9.5e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.71923e-07 sb=4e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(1)
mn13 (net455 \3\:SI \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=5.59e-14 ps=8e-07 pd=9.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.31923e-07 sb=1.4e-07 sd=160n sca=8.51051 \
        scb=0.00656948 scc=0.000151659 m=(1)
mn10 (\8\:SEb \7\:SE \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.972e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp45 (\17\:qbint n30 \29\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=4.34e-14 ps=1.15e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.75e-07 sb=1.4e-07 sd=160n sca=36.0877 \
        scb=0.0235247 scc=0.00420471 m=(1)
mp50 (\3\:net355 \1\:SN \27\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.665e-14 ad=4.96e-14 ps=1.65e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=3.05e-07 sd=160n sca=17.9343 scb=0.0166254 \
        scc=0.0014837 m=(1)
mp51 (\3\:net355 \9\:qbint \25\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=5.665e-14 ad=4.96e-14 ps=1.65e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=1e-07 sd=160n sca=17.9343 scb=0.0166254 \
        scc=0.0014837 m=(1)
mp52 (\7\:n30 CKbb net355 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.20484e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp40 (\7\:n30 \4\:CKb \15\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.58e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.15484e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\13\:mout \5\:SN \23\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.065e-14 ad=4.96e-14 ps=1.41e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.16e-06 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp31 (\13\:mout n20 \21\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.52e-14 ad=4.96e-14 ps=1.51e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=9.55e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp35 (net378 \4\:mout \21\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.52e-14 ad=4.185e-14 ps=1.51e-06 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=6.9e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp36 (\4\:n20 \5\:CKb net378 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.185e-14 ad=7.13e-14 ps=8.9e-07 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.5e-07 sb=5.1e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp25 (\4\:n20 \4\:CKbb \6\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=7.13e-14 ps=1.09e-06 pd=1.08e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.025e-06 sb=2.35e-07 sd=160n sca=11.3312 \
        scb=0.00941412 scc=0.000228915 m=(1)
mp21 (\10\:CKbb \12\:CKb \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\22\:CKb \1\:CK \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.0082e-13 ad=3.01e-14 ps=1.49e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.0593e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp11 (net390 \1\:D \17\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.0082e-13 ad=5.07e-14 ps=1.49e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.60513e-07 sb=6.62308e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp12 (Db \3\:SE net390 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.07e-14 ad=8.775e-14 ps=1.04e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.35513e-07 sb=4.87308e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp13 (net398 \1\:SI \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.38e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.10513e-07 sb=1.12308e-07 sd=160n sca=16.3434 \
        scb=0.0143715 scc=0.00102303 m=(1)
mp14 (Db \3\:SEb net398 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=8.775e-14 ps=9e-07 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.05513e-07 sb=2.17308e-07 sd=160n sca=15.9046 \
        scb=0.0140803 scc=0.00102275 m=(1)
mp10 (\10\:SEb \8\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=59.4536 \
        scb=0.0473468 scc=0.00729053 m=(1)
ends SDFFSHQX2
// End of subcircuit definition.

// Generated for: spectre (May  9 17:37:09 2012 )
// Library name: gsclib045
// Cell name: SDFFSHQX4
// View name: extracted

simulator lang=spectre

subckt SDFFSHQX4 CK D Q SE SI SN VDD VSS
mp55_1__rcx (Q qbint \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.789e-14 ad=6.338e-14 ps=1.2825e-06 pd=1.105e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.52679e-06 sd=160n sca=21.8995 \
        scb=0.021439 scc=0.00147164 m=(4)
C1 (D VSS) capacitor c=4.40265e-17
C2 (CK VSS) capacitor c=7.96771e-17
C3 (Q VSS) capacitor c=2.54549e-16
C4 (SE VSS) capacitor c=1.11047e-16
C5 (VDD VSS) capacitor c=3.4961e-16
C6 (SN VSS) capacitor c=1.86535e-16
C7 (SI VSS) capacitor c=8.41597e-17
C8 (qbint VSS) capacitor c=2.34738e-16
C9 (n30 VSS) capacitor c=1.90031e-16
C10 (net459 VSS) capacitor c=6.39422e-18
C11 (net467 VSS) capacitor c=1.0206e-18
C12 (CKb VSS) capacitor c=5.4141e-17
C13 (mout VSS) capacitor c=5.56883e-17
C14 (CKbb VSS) capacitor c=4.87371e-17
C15 (net435 VSS) capacitor c=3.53849e-19
C16 (n20 VSS) capacitor c=4.89306e-17
C17 (net427 VSS) capacitor c=1.92109e-18
C18 (Db VSS) capacitor c=4.06039e-17
C19 (net443 VSS) capacitor c=4.30151e-18
C20 (SEb VSS) capacitor c=5.0785e-17
C21 (net455 VSS) capacitor c=3.40554e-18
C22 (net355 VSS) capacitor c=8.61683e-17
C23 (net378 VSS) capacitor c=3.84145e-18
C24 (net390 VSS) capacitor c=1.50856e-17
C25 (net398 VSS) capacitor c=1.70955e-18
C26 (\5\:SE VSS) capacitor c=3.03291e-17
C27 (\1\:SI VSS) capacitor c=7.09426e-17
C28 (\3\:SEb VSS) capacitor c=7.076e-17
C29 (\3\:SE VSS) capacitor c=5.63965e-17
C30 (\1\:D VSS) capacitor c=4.24526e-17
C31 (\1\:CK VSS) capacitor c=3.4027e-17
C32 (\12\:CKb VSS) capacitor c=1.97132e-17
C33 (\4\:CKbb VSS) capacitor c=2.84146e-17
C34 (\5\:CKb VSS) capacitor c=5.11664e-17
C35 (\3\:mout VSS) capacitor c=7.99143e-17
C36 (\5\:SN VSS) capacitor c=3.80981e-17
C37 (\4\:CKb VSS) capacitor c=5.38704e-17
C38 (\13\:qbint VSS) capacitor c=4.57501e-17
C39 (\4\:SN VSS) capacitor c=3.65445e-17
C40 (\7\:SE VSS) capacitor c=1.99655e-17
C41 (\3\:SI VSS) capacitor c=5.51437e-17
C42 (\4\:SE VSS) capacitor c=4.43382e-17
C43 (\4\:D VSS) capacitor c=4.9787e-17
C44 (\4\:CK VSS) capacitor c=3.40922e-17
C45 (\7\:CKb VSS) capacitor c=1.59942e-17
C46 (\11\:CKb VSS) capacitor c=2.26108e-17
C47 (\6\:CKbb VSS) capacitor c=6.26565e-17
C48 (\3\:n20 VSS) capacitor c=7.66751e-17
C49 (\7\:SN VSS) capacitor c=6.84565e-17
C50 (\2\:CKbb VSS) capacitor c=4.01936e-17
C51 (\15\:qbint VSS) capacitor c=4.19728e-17
C52 (\1\:SN VSS) capacitor c=4.64156e-17
C53 (\6\:SE VSS) capacitor c=2.10948e-17
C54 (\2\:SI VSS) capacitor c=5.84873e-17
C55 (\4\:SEb VSS) capacitor c=4.8433e-17
C56 (\1\:SE VSS) capacitor c=2.76013e-17
C57 (\2\:SEb VSS) capacitor c=3.58803e-17
C58 (\3\:D VSS) capacitor c=2.86367e-17
C59 (\3\:CK VSS) capacitor c=2.56693e-17
C60 (\8\:CKb VSS) capacitor c=9.28807e-18
C61 (\10\:CKb VSS) capacitor c=3.47636e-17
C62 (\5\:CKbb VSS) capacitor c=5.26251e-17
C63 (\6\:CKb VSS) capacitor c=4.33842e-17
C64 (\2\:mout VSS) capacitor c=5.00648e-17
C65 (\2\:n20 VSS) capacitor c=6.6118e-17
C66 (\6\:SN VSS) capacitor c=5.07847e-17
C67 (\3\:CKb VSS) capacitor c=3.50135e-17
C68 (\3\:CKbb VSS) capacitor c=2.56599e-17
C69 (\2\:CKb VSS) capacitor c=3.3747e-17
C70 (\14\:qbint VSS) capacitor c=3.96132e-17
C71 (\3\:SN VSS) capacitor c=4.68646e-17
C72 (\20\:VDD VSS) capacitor c=2.91902e-17
C73 (\8\:SEb VSS) capacitor c=1.05137e-16
C74 (\22\:VDD VSS) capacitor c=2.58186e-17
C75 (\8\:Db VSS) capacitor c=1.20986e-16
C76 (\24\:VDD VSS) capacitor c=6.16177e-17
C77 (\22\:CKb VSS) capacitor c=6.14763e-17
C78 (\26\:VDD VSS) capacitor c=5.35876e-17
C79 (\9\:CKbb VSS) capacitor c=1.12809e-16
C80 (\6\:Db VSS) capacitor c=1.10532e-16
C81 (\4\:n20 VSS) capacitor c=3.9013e-17
C82 (\28\:VDD VSS) capacitor c=2.78969e-17
C83 (\12\:mout VSS) capacitor c=5.7707e-17
C84 (\30\:VDD VSS) capacitor c=2.52176e-17
C85 (\14\:mout VSS) capacitor c=2.26694e-17
C86 (\11\:n30 VSS) capacitor c=4.48e-17
C87 (\32\:VDD VSS) capacitor c=3.04524e-17
C88 (\3\:net355 VSS) capacitor c=8.2377e-17
C89 (\21\:qbint VSS) capacitor c=6.3054e-17
C90 (\1\:VDD VSS) capacitor c=1.11038e-16
C91 (\10\:SEb VSS) capacitor c=1.07583e-16
C92 (\18\:CKb VSS) capacitor c=9.23383e-17
C93 (\7\:CKbb VSS) capacitor c=7.58208e-17
C94 (\4\:Db VSS) capacitor c=2.09192e-16
C95 (\8\:n20 VSS) capacitor c=8.26948e-17
C96 (\10\:mout VSS) capacitor c=5.25602e-17
C97 (\8\:mout VSS) capacitor c=7.53658e-17
C98 (\7\:n30 VSS) capacitor c=6.35432e-17
C99 (\17\:qbint VSS) capacitor c=9.72218e-17
C100 (\9\:CKb VSS) capacitor c=1.75686e-17
C101 (\2\:CK VSS) capacitor c=3.78941e-17
C102 (\2\:D VSS) capacitor c=3.30737e-17
C103 (\2\:SE VSS) capacitor c=4.17375e-17
C104 (\16\:qbint VSS) capacitor c=8.91577e-17
C105 (\19\:qbint VSS) capacitor c=3.65066e-17
C106 (\20\:qbint VSS) capacitor c=2.58773e-17
C107 (\9\:n30 VSS) capacitor c=1.34106e-16
C108 (\10\:n30 VSS) capacitor c=1.38462e-16
C109 (\8\:SN VSS) capacitor c=5.91318e-17
C110 (\9\:SN VSS) capacitor c=1.8505e-16
C111 (\4\:mout VSS) capacitor c=3.90026e-17
C112 (\5\:mout VSS) capacitor c=2.29841e-17
C113 (\6\:mout VSS) capacitor c=6.78262e-17
C114 (\7\:mout VSS) capacitor c=7.37532e-17
C115 (\6\:n20 VSS) capacitor c=8.61853e-17
C116 (\7\:n20 VSS) capacitor c=6.72244e-17
C117 (\13\:CKb VSS) capacitor c=1.08321e-16
C118 (\14\:CKb VSS) capacitor c=2.04828e-16
C119 (\15\:CKb VSS) capacitor c=2.37255e-16
C120 (\16\:CKb VSS) capacitor c=4.47735e-17
C121 (\17\:CKb VSS) capacitor c=1.2628e-16
C122 (\11\:CKbb VSS) capacitor c=1.88147e-16
C123 (\12\:CKbb VSS) capacitor c=1.84822e-16
C124 (\13\:CKbb VSS) capacitor c=5.92221e-17
C125 (\20\:CKb VSS) capacitor c=8.37999e-17
C126 (\21\:CKb VSS) capacitor c=2.42198e-17
C127 (\5\:CK VSS) capacitor c=4.93603e-17
C128 (\5\:D VSS) capacitor c=6.60596e-17
C129 (\3\:Db VSS) capacitor c=2.94551e-16
C130 (\4\:SI VSS) capacitor c=4.12134e-17
C131 (\5\:SEb VSS) capacitor c=2.82594e-17
C132 (\6\:SEb VSS) capacitor c=1.00949e-16
C133 (\7\:SEb VSS) capacitor c=1.1208e-16
C134 (\8\:SE VSS) capacitor c=1.10453e-16
C135 (\3\:VDD VSS) capacitor c=7.77067e-19
C136 (\7\:VDD VSS) capacitor c=1.03638e-17
C137 (\9\:VDD VSS) capacitor c=4.08217e-17
C138 (\10\:VDD VSS) capacitor c=4.86702e-17
C139 (\11\:VDD VSS) capacitor c=1.29741e-17
C140 (\13\:VDD VSS) capacitor c=2.3205e-17
C141 (\14\:VDD VSS) capacitor c=1.82115e-16
Rk38 (D \5\:D) resistor r=0.1321 c=0
Rk79 (\2\:VSS \3\:VSS) resistor r=0.05748 c=0
Rk80 (\3\:VSS \4\:VSS) resistor r=0.344 c=0
Rk81 (\3\:VSS \6\:VSS) resistor r=0.2745 c=0
Rk82 (\4\:VSS \7\:VSS) resistor r=0.3634 c=0
Rk83 (\7\:VSS \8\:VSS) resistor r=0.03742 c=0
Rk84 (\8\:VSS \9\:VSS) resistor r=0.3098 c=0
Rk85 (\9\:VSS \10\:VSS) resistor r=0.3399 c=0
Rk86 (\10\:VSS \11\:VSS) resistor r=0.2706 c=0
Rk87 (\11\:VSS \12\:VSS) resistor r=0.3507 c=0
Rk88 (\12\:VSS \13\:VSS) resistor r=0.3308 c=0
Rk94 (\14\:VSS VSS) resistor r=0.0798 c=0
Rk89 (\13\:VSS \14\:VSS) resistor r=0.3659 c=0
Rk95 (\4\:VSS \20\:VSS) resistor r=0.2506 c=0
Rk96 (\7\:VSS \22\:VSS) resistor r=0.201 c=0
Rk97 (\9\:VSS \24\:VSS) resistor r=0.04331 c=0
Rk98 (\11\:VSS \26\:VSS) resistor r=0.3354 c=0
Rk99 (\12\:VSS \28\:VSS) resistor r=0.3387 c=0
Rk37 (CK \5\:CK) resistor r=0.0974 c=0
Rk48 (\8\:SE SE) resistor r=0.6485 c=0
Rk49 (SE \9\:SE) resistor r=0.009436 c=0
Rk50 (\2\:VDD \3\:VDD) resistor r=0.05748 c=0
Rk51 (\3\:VDD \4\:VDD) resistor r=0.1428 c=0
Rk52 (\4\:VDD \5\:VDD) resistor r=0.1402 c=0
Rk53 (\5\:VDD \6\:VDD) resistor r=0.2105 c=0
Rk54 (\6\:VDD \7\:VDD) resistor r=0.213 c=0
Rk55 (\7\:VDD \8\:VDD) resistor r=0.3885 c=0
Rk56 (\8\:VDD \9\:VDD) resistor r=0.03742 c=0
Rk57 (\9\:VDD \10\:VDD) resistor r=0.603 c=0
Rk58 (\10\:VDD \11\:VDD) resistor r=0.2334 c=0
Rk59 (\11\:VDD \12\:VDD) resistor r=0.1242 c=0
Rk60 (\12\:VDD \13\:VDD) resistor r=0.3359 c=0
Rk67 (\14\:VDD VDD) resistor r=0.0798 c=0
Rk61 (\13\:VDD \14\:VDD) resistor r=0.2654 c=0
Rk68 (\3\:VDD \21\:VDD) resistor r=0.4212 c=0
Rk69 (\5\:VDD \23\:VDD) resistor r=0.2443 c=0
Rk70 (\7\:VDD \25\:VDD) resistor r=0.3375 c=0
Rk71 (\9\:VDD \27\:VDD) resistor r=0.4463 c=0
Rk72 (\10\:VDD \29\:VDD) resistor r=0.04331 c=0
Rk73 (\11\:VDD \31\:VDD) resistor r=0.04331 c=0
Rk74 (\13\:VDD \33\:VDD) resistor r=0.1708 c=0
Rk14 (\8\:SN SN) resistor r=0.318 c=0
Rk15 (SN \9\:SN) resistor r=1.3607 c=0
Rk43 (SI \4\:SI) resistor r=0.09255 c=0
Rk6 (\16\:qbint \18\:qbint) resistor r=0.5802 c=0
Rk7 (\18\:qbint \19\:qbint) resistor r=0.2315 c=0
Rk8 (\19\:qbint \20\:qbint) resistor r=0.1315 c=0
Rk9 (\19\:qbint \22\:qbint) resistor r=0.3026 c=0
Rk11 (\8\:n30 \9\:n30) resistor r=0.2263 c=0
Rk12 (\9\:n30 \10\:n30) resistor r=0.8421 c=0
Rk13 (\9\:n30 \12\:n30) resistor r=0.2043 c=0
Rk26 (\13\:CKb \14\:CKb) resistor r=0.7159 c=0
Rk27 (\14\:CKb \15\:CKb) resistor r=1.0979 c=0
Rk28 (\14\:CKb \16\:CKb) resistor r=0.1706 c=0
Rk29 (\15\:CKb \17\:CKb) resistor r=0.9198 c=0
Rk34 (\19\:CKb \20\:CKb) resistor r=0.4256 c=0
Rk35 (\20\:CKb \21\:CKb) resistor r=0.1014 c=0
Rk36 (\20\:CKb \23\:CKb) resistor r=0.4627 c=0
Rk16 (\4\:mout \5\:mout) resistor r=0.1875 c=0
Rk17 (\5\:mout \6\:mout) resistor r=0.07842 c=0
Rk18 (\6\:mout \7\:mout) resistor r=0.42 c=0
Rk19 (\7\:mout \9\:mout) resistor r=0.3594 c=0
Rk20 (\5\:mout \11\:mout) resistor r=0.1744 c=0
Rk21 (\6\:mout \13\:mout) resistor r=0.2542 c=0
Rk22 (\7\:mout \15\:mout) resistor r=0.05463 c=0
Rk30 (\8\:CKbb \10\:CKbb) resistor r=0.4306 c=0
Rk31 (\10\:CKbb \11\:CKbb) resistor r=0.5444 c=0
Rk32 (\11\:CKbb \12\:CKbb) resistor r=1.2262 c=0
Rk33 (\11\:CKbb \13\:CKbb) resistor r=0.2551 c=0
Rk23 (\5\:n20 \6\:n20) resistor r=0.1125 c=0
Rk24 (\6\:n20 \7\:n20) resistor r=0.38 c=0
Rk25 (\6\:n20 \9\:n20) resistor r=0.3757 c=0
Rk39 (\2\:Db \3\:Db) resistor r=0.2713 c=0
Rk40 (\3\:Db \5\:Db) resistor r=1.1944 c=0
Rk41 (\5\:Db \7\:Db) resistor r=0.5325 c=0
Rk42 (\3\:Db \9\:Db) resistor r=0.8556 c=0
Rk44 (\5\:SEb \6\:SEb) resistor r=0.1874 c=0
Rk45 (\6\:SEb \7\:SEb) resistor r=0.1635 c=0
Rk46 (\6\:SEb \9\:SEb) resistor r=0.8334 c=0
Rk47 (\7\:SEb \11\:SEb) resistor r=0.7053 c=0
Rk10 (\2\:net355 \4\:net355) resistor r=0.2778 c=0
Rl43 (\1\:D \2\:D) resistor r=113.023 c=0
Rl45 (\2\:D \4\:D) resistor r=53.5603 c=0
Rl44 (\2\:D \3\:D) resistor r=13.091 c=0
Rl40 (\1\:CK \2\:CK) resistor r=141.541 c=0
Rl42 (\2\:CK \4\:CK) resistor r=28.0797 c=0
Rl41 (\2\:CK \3\:CK) resistor r=93.1451 c=0
Rl53 (\5\:SE \6\:SE) resistor r=72.3097 c=0
Rl54 (\6\:SE \7\:SE) resistor r=43.4636 c=0
Rl48 (\2\:SE \3\:SE) resistor r=108.645 c=0
Rl49 (\2\:SE \4\:SE) resistor r=48.5834 c=0
Rl47 (\1\:SE \2\:SE) resistor r=2.257 c=0
Rl26 (\5\:SN \6\:SN) resistor r=57.2464 c=0
Rl27 (\6\:SN \7\:SN) resistor r=131.925 c=0
Rl19 (\2\:SN \4\:SN) resistor r=23.7402 c=0
Rl17 (\1\:SN \2\:SN) resistor r=108.001 c=0
Rl18 (\2\:SN \3\:SN) resistor r=4.3511 c=0
Rl51 (\1\:SI \2\:SI) resistor r=29.5379 c=0
Rl52 (\2\:SI \3\:SI) resistor r=134.873 c=0
Rl20 (\14\:qbint \13\:qbint) resistor r=85.7713 c=0
Rl21 (\14\:qbint \15\:qbint) resistor r=24.2328 c=0
Rl35 (\7\:CKb \8\:CKb) resistor r=26.9231 c=0
Rl38 (\10\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl32 (\5\:CKb \6\:CKb) resistor r=79.5379 c=0
Rl25 (\3\:CKb \4\:CKb) resistor r=111.516 c=0
Rl22 (CKb \2\:CKb) resistor r=29.5379 c=0
Rl39 (\9\:CKb \12\:CKb) resistor r=39.1248 c=0
Rl36 (\8\:CKb \9\:CKb) resistor r=9.4946 c=0
Rl37 (\9\:CKb \10\:CKb) resistor r=145.249 c=0
Rl30 (mout \2\:mout) resistor r=111.796 c=0
Rl31 (\2\:mout \3\:mout) resistor r=106.027 c=0
Rl23 (CKbb \2\:CKbb) resistor r=113.462 c=0
Rl33 (\4\:CKbb \5\:CKbb) resistor r=24.2328 c=0
Rl34 (\5\:CKbb \6\:CKbb) resistor r=191.428 c=0
Rl24 (CKbb \3\:CKbb) resistor r=58.3841 c=0
Rl28 (n20 \2\:n20) resistor r=29.5379 c=0
Rl29 (\2\:n20 \3\:n20) resistor r=190.642 c=0
Rl50 (\3\:SEb \4\:SEb) resistor r=30.2349 c=0
Rl46 (SEb \2\:SEb) resistor r=31.9251 c=0
Rz20 (\6\:VSS \5\:VSS) resistor r=75 c=0
Rz21 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz22 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz23 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz24 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz25 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz13 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz14 (\4\:VDD \1\:VDD) resistor r=25 c=0
Rz15 (\6\:VDD \1\:VDD) resistor r=18.75 c=0
Rz16 (\8\:VDD \1\:VDD) resistor r=9.375 c=0
Rz17 (\12\:VDD \1\:VDD) resistor r=6.25 c=0
Rz18 (\14\:VDD \1\:VDD) resistor r=9.375 c=0
Rz3 (\18\:qbint \17\:qbint) resistor r=75 c=0
Rz4 (\8\:n30 \7\:n30) resistor r=75 c=0
Rz9 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz5 (\8\:mout \9\:mout) resistor r=75 c=0
Rz6 (\10\:mout \11\:mout) resistor r=75 c=0
Rz8 (\7\:CKbb \8\:CKbb) resistor r=75 c=0
Rz7 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz10 (Db \2\:Db) resistor r=75 c=0
Rz11 (\4\:Db \5\:Db) resistor r=75 c=0
Rz12 (\10\:SEb \11\:SEb) resistor r=75 c=0
Ry26 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry27 (\4\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry28 (\8\:VSS \1\:VSS) resistor r=62 c=0
Ry29 (\10\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry30 (\13\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry31 (\14\:VSS \1\:VSS) resistor r=7.75 c=0
Ry15 (\21\:VDD \20\:VDD) resistor r=62 c=0
Ry16 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry17 (\25\:VDD \24\:VDD) resistor r=20.6667 c=0
Ry18 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry19 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry20 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry21 (\33\:VDD \32\:VDD) resistor r=62 c=0
Ry3 (\22\:qbint \21\:qbint) resistor r=31 c=0
Ry6 (\12\:n30 \11\:n30) resistor r=62 c=0
Ry11 (\22\:CKb \23\:CKb) resistor r=62 c=0
Ry7 (\12\:mout \13\:mout) resistor r=62 c=0
Ry8 (\14\:mout \15\:mout) resistor r=62 c=0
Ry10 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry9 (\4\:n20 \5\:n20) resistor r=62 c=0
Ry12 (\6\:Db \7\:Db) resistor r=62 c=0
Ry13 (\8\:Db \9\:Db) resistor r=62 c=0
Ry14 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry4 (net355 \2\:net355) resistor r=62 c=0
Ry5 (\3\:net355 \4\:net355) resistor r=62 c=0
Rx16 (\3\:D \5\:D) resistor r=45 c=0
Rx15 (\3\:CK \5\:CK) resistor r=45 c=0
Rx20 (\1\:SE \8\:SE) resistor r=45 c=0
Rx21 (\6\:SE \9\:SE) resistor r=45 c=0
Rx4 (\3\:SN \8\:SN) resistor r=45 c=0
Rx5 (\6\:SN \9\:SN) resistor r=45 c=0
Rx17 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\16\:qbint \14\:qbint) resistor r=45 c=0
Rx2 (\20\:qbint qbint) resistor r=45 c=0
Rx3 (\10\:n30 n30) resistor r=45 c=0
Rx8 (\10\:CKb \13\:CKb) resistor r=45 c=0
Rx9 (\3\:CKb \15\:CKb) resistor r=45 c=0
Rx10 (\6\:CKb \16\:CKb) resistor r=45 c=0
Rx11 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx14 (\8\:CKb \21\:CKb) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx12 (\3\:CKbb \12\:CKbb) resistor r=45 c=0
Rx13 (\5\:CKbb \13\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \7\:n20) resistor r=45 c=0
Rx18 (\4\:SEb \5\:SEb) resistor r=45 c=0
Rx19 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn55_1__rcx (Q qbint \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.178e-14 ad=4.16e-14 ps=8.525e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.72817e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn45 (\17\:qbint n30 \14\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.081e-14 ad=3.997e-14 ps=9.65e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=1.34e-06 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(2)
mn50 (net459 \1\:SN \14\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.41e-14 ad=4.51e-14 ps=1e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.51e-06 sb=8.35e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn51 (net467 \15\:qbint net459 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.51e-14 ad=1.64e-14 ps=8.5e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.775e-06 sb=5.7e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn52 (\7\:n30 CKb net467 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.64e-14 ad=5.023e-14 ps=5.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-06 sb=4.45e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn40 (\7\:n30 \2\:CKbb \8\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.178e-14 ad=5.023e-14 ps=7.2e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.55e-07 sd=160n sca=13.8179 scb=0.0141903 \
        scc=0.000851218 m=(1)
mn30 (net435 \7\:SN \27\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.69e-14 ad=1.23e-14 ps=7.7e-07 pd=5.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=2.45e-07 sd=160n sca=18.43 scb=0.0187068 \
        scc=0.00173343 m=(1)
mn31 (\10\:mout \3\:n20 net435 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.23e-14 ad=2.87e-14 ps=5.3e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.4e-07 sd=160n sca=18.43 scb=0.0187068 \
        scc=0.00173343 m=(1)
mn35 (net427 mout \25\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=2.05e-14 ps=6.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.35e-07 sd=160n sca=18.43 scb=0.0187068 \
        scc=0.00173343 m=(1)
mn36 (\8\:n20 \6\:CKbb net427 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=4.305e-14 ps=6.1e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=4.9e-07 sd=160n sca=18.43 scb=0.0187068 \
        scc=0.00173343 m=(1)
mn25 (\8\:n20 \11\:CKb \4\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.817e-14 ad=4.305e-14 ps=8.8e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=2.35e-07 sd=160n sca=18.43 scb=0.0187068 \
        scc=0.00173343 m=(1)
mn21 (\7\:CKbb \7\:CKb \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.685e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.7e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\18\:CKb \4\:CK \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=3.552e-14 ps=9.8e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=9.95e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn11 (net443 \4\:D \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.945e-14 ad=3.51e-14 ps=9.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.51923e-07 sb=7.2e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn12 (Db SEb net443 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=3.51e-14 \
        ad=4.16e-14 ps=7.9e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.31923e-07 sb=5.4e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn14 (Db \4\:SE net455 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.9e-14 ad=4.16e-14 ps=8.2e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.36923e-07 sb=3.35e-07 sd=160n sca=9.14564 \
        scb=0.00759168 scc=0.000213449 m=(1)
mn13 (net455 \3\:SI \19\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.9e-14 ps=8e-07 pd=8.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=9.31923e-07 sb=1.4e-07 sd=160n sca=9.14564 scb=0.00759168 \
        scc=0.000213449 m=(1)
mn10 (\10\:SEb \7\:SE \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.973e-14 ps=5.7e-07 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.05e-07 sb=1.4e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mp45 (\21\:qbint n30 \14\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.24e-14 ad=6.045e-14 ps=1.82e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.005e-06 sb=8.7e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(2)
mp50 (\3\:net355 \4\:SN \14\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=7.265e-14 ad=8.99e-14 ps=1.77e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.44e-06 sb=4.35e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp51 (\3\:net355 \13\:qbint \32\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.99e-14 ad=8.99e-14 ps=1.38e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.775e-06 sb=1e-07 sd=160n sca=19.1541 \
        scb=0.0174883 scc=0.00172295 m=(1)
mp52 (\11\:n30 CKbb net355 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.035e-14 ad=4.96e-14 ps=1e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.62419e-07 sb=3.45e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp40 (\11\:n30 \4\:CKb \14\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.34e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.67419e-07 sb=1.4e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\12\:mout \5\:SN \30\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.25e-14 ad=4.96e-14 ps=1.29e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=1.155e-06 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp31 (\12\:mout n20 \28\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.8e-14 ad=4.96e-14 ps=1.39e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=9.5e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp35 (net378 \3\:mout \28\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=8.8e-14 ad=3.72e-14 ps=1.39e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.4e-07 sb=6.85e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp36 (\4\:n20 \5\:CKb net378 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.72e-14 ad=7.44e-14 ps=8.6e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=5.2e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp25 (\4\:n20 \4\:CKbb \6\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=7.44e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.09e-06 sb=2.35e-07 sd=160n sca=10.6008 \
        scb=0.00822388 scc=0.000121216 m=(1)
mp21 (\9\:CKbb \12\:CKb \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\22\:CKb \1\:CK \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.04e-14 ad=3.01e-14 ps=1.3e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.045e-06 sd=160n sca=19.7413 \
        scb=0.019281 scc=0.00179464 m=(1)
mp11 (net390 \1\:D \24\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.04e-14 ad=1.1115e-13 ps=1.3e-06 pd=1.35e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.08141e-07 sb=7.52308e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp12 (\8\:Db \3\:SE net390 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.1115e-13 ad=6.24e-14 ps=1.35e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.38141e-07 sb=4.22308e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp14 (\8\:Db \3\:SEb net398 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.43141e-07 sb=2.17308e-07 sd=160n sca=15.4348 \
        scb=0.0139233 scc=0.00102271 m=(1)
mp13 (net398 \1\:SI \22\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.38e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.48141e-07 sb=1.12308e-07 sd=160n sca=15.6043 \
        scb=0.0139625 scc=0.00102271 m=(1)
mp10 (\8\:SEb \5\:SE \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=51.8759 \
        scb=0.0369865 scc=0.00608773 m=(1)
ends SDFFSHQX4
// End of subcircuit definition.

// Generated for: spectre (May  9 17:37:47 2012 )
// Library name: gsclib045
// Cell name: SDFFSHQX8
// View name: extracted

simulator lang=spectre

subckt SDFFSHQX8 CK D Q SE SI SN VDD VSS
mp55_1__rcx (Q qbint VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=6.824e-14 ps=1.20429e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.34348e-06 sd=160n \
        sca=41.6034 scb=0.0375368 scc=0.00435732 m=(7)
C1 (D VSS) capacitor c=6.76121e-17
C2 (VDD VSS) capacitor c=7.45838e-16
C3 (CK VSS) capacitor c=5.71254e-17
C4 (Q VSS) capacitor c=5.53734e-16
C5 (SN VSS) capacitor c=2.14352e-17
C6 (SI VSS) capacitor c=7.63735e-17
C7 (qbint VSS) capacitor c=3.16042e-16
C8 (n30 VSS) capacitor c=1.96029e-16
C9 (net459 VSS) capacitor c=3.46215e-18
C10 (net467 VSS) capacitor c=1.98903e-18
C11 (CKb VSS) capacitor c=4.13481e-17
C12 (mout VSS) capacitor c=3.71667e-17
C13 (CKbb VSS) capacitor c=4.89495e-17
C14 (net435 VSS) capacitor c=3.71162e-19
C15 (n20 VSS) capacitor c=4.70181e-17
C16 (net427 VSS) capacitor c=1.83791e-18
C17 (Db VSS) capacitor c=5.02706e-17
C18 (net443 VSS) capacitor c=9.03466e-18
C19 (SEb VSS) capacitor c=3.98989e-17
C20 (net455 VSS) capacitor c=1.40273e-18
C21 (net355 VSS) capacitor c=9.44002e-17
C22 (net378 VSS) capacitor c=5.94322e-18
C23 (net390 VSS) capacitor c=9.73053e-18
C24 (net398 VSS) capacitor c=1.63377e-18
C25 (\7\:SE VSS) capacitor c=3.54477e-17
C26 (\1\:SI VSS) capacitor c=7.41332e-17
C27 (\3\:SEb VSS) capacitor c=7.13264e-17
C28 (\3\:SE VSS) capacitor c=5.70352e-17
C29 (\1\:D VSS) capacitor c=3.97983e-17
C30 (\1\:CK VSS) capacitor c=2.50299e-17
C31 (\7\:CKb VSS) capacitor c=2.2129e-17
C32 (\4\:CKbb VSS) capacitor c=3.12982e-17
C33 (\5\:CKb VSS) capacitor c=4.76923e-17
C34 (\4\:mout VSS) capacitor c=6.64914e-17
C35 (\4\:SN VSS) capacitor c=4.91416e-17
C36 (\3\:CKb VSS) capacitor c=5.2582e-17
C37 (\2\:CKbb VSS) capacitor c=4.67039e-17
C38 (\23\:qbint VSS) capacitor c=5.37462e-17
C39 (\3\:SN VSS) capacitor c=3.74867e-17
C40 (\6\:SE VSS) capacitor c=2.30577e-17
C41 (\3\:SI VSS) capacitor c=7.71393e-17
C42 (\1\:SE VSS) capacitor c=6.40024e-17
C43 (\4\:D VSS) capacitor c=3.66339e-17
C44 (\4\:CK VSS) capacitor c=2.23374e-17
C45 (\12\:CKb VSS) capacitor c=2.21467e-17
C46 (\10\:CKb VSS) capacitor c=2.13405e-17
C47 (\6\:CKbb VSS) capacitor c=7.12928e-17
C48 (\3\:n20 VSS) capacitor c=9.33231e-17
C49 (\6\:SN VSS) capacitor c=6.78548e-17
C50 (\25\:qbint VSS) capacitor c=3.84562e-17
C51 (\1\:SN VSS) capacitor c=5.89415e-17
C52 (\4\:SE VSS) capacitor c=1.42158e-17
C53 (\2\:SI VSS) capacitor c=6.05979e-17
C54 (\4\:SEb VSS) capacitor c=5.05088e-17
C55 (\2\:SE VSS) capacitor c=7.23627e-17
C56 (\2\:SEb VSS) capacitor c=5.11051e-17
C57 (\3\:D VSS) capacitor c=1.19089e-17
C58 (\3\:CK VSS) capacitor c=1.56371e-17
C59 (\11\:CKb VSS) capacitor c=2.48474e-17
C60 (\5\:CKbb VSS) capacitor c=5.1928e-17
C61 (\9\:CKb VSS) capacitor c=3.21068e-17
C62 (\6\:CKb VSS) capacitor c=4.68092e-17
C63 (\3\:mout VSS) capacitor c=5.39491e-17
C64 (\2\:n20 VSS) capacitor c=5.81965e-17
C65 (\5\:SN VSS) capacitor c=4.94477e-17
C66 (\4\:CKb VSS) capacitor c=3.49479e-17
C67 (\3\:CKbb VSS) capacitor c=2.74968e-17
C68 (\2\:CKb VSS) capacitor c=4.37982e-17
C69 (\24\:qbint VSS) capacitor c=5.09826e-17
C70 (\2\:SN VSS) capacitor c=4.48486e-17
C71 (\1\:VDD VSS) capacitor c=1.08845e-17
C72 (\5\:SEb VSS) capacitor c=7.76207e-17
C73 (\22\:VDD VSS) capacitor c=2.83184e-17
C74 (\6\:Db VSS) capacitor c=1.18187e-16
C75 (\24\:VDD VSS) capacitor c=4.2276e-17
C76 (\22\:CKb VSS) capacitor c=7.06936e-17
C77 (\26\:VDD VSS) capacitor c=6.08313e-17
C78 (\9\:CKbb VSS) capacitor c=1.08902e-16
C79 (\8\:Db VSS) capacitor c=1.05915e-16
C80 (\6\:n20 VSS) capacitor c=1.17384e-16
C81 (\28\:VDD VSS) capacitor c=2.01389e-17
C82 (\12\:mout VSS) capacitor c=5.63635e-17
C83 (\30\:VDD VSS) capacitor c=2.43714e-17
C84 (\14\:mout VSS) capacitor c=2.61539e-17
C85 (\15\:n30 VSS) capacitor c=4.216e-17
C86 (\32\:VDD VSS) capacitor c=3.14672e-17
C87 (\3\:net355 VSS) capacitor c=9.90794e-17
C88 (\4\:VDD VSS) capacitor c=1.12915e-16
C89 (\9\:SEb VSS) capacitor c=1.00081e-16
C90 (\18\:CKb VSS) capacitor c=5.27115e-17
C91 (\12\:CKbb VSS) capacitor c=7.98424e-17
C92 (\4\:Db VSS) capacitor c=2.88039e-16
C93 (\4\:n20 VSS) capacitor c=1.00327e-16
C94 (\10\:mout VSS) capacitor c=5.54811e-17
C95 (\8\:mout VSS) capacitor c=6.73964e-17
C96 (\13\:n30 VSS) capacitor c=7.441e-17
C97 (\27\:qbint VSS) capacitor c=3.76682e-16
C98 (\2\:CK VSS) capacitor c=1.71214e-17
C99 (\2\:D VSS) capacitor c=2.4669e-17
C100 (\26\:qbint VSS) capacitor c=7.6312e-17
C101 (\33\:qbint VSS) capacitor c=6.87368e-17
C102 (\5\:SE VSS) capacitor c=1.59973e-17
C103 (\11\:n30 VSS) capacitor c=1.28052e-16
C104 (\12\:n30 VSS) capacitor c=1.26886e-16
C105 (\7\:SN VSS) capacitor c=2.08692e-16
C106 (\8\:SN VSS) capacitor c=1.79493e-16
C107 (\5\:mout VSS) capacitor c=5.48869e-17
C108 (\6\:mout VSS) capacitor c=6.79381e-17
C109 (\7\:mout VSS) capacitor c=5.84518e-17
C110 (\8\:n20 VSS) capacitor c=8.02351e-17
C111 (\13\:CKb VSS) capacitor c=1.22676e-16
C112 (\14\:CKb VSS) capacitor c=2.25653e-16
C113 (\15\:CKb VSS) capacitor c=2.2355e-16
C114 (\16\:CKb VSS) capacitor c=1.24853e-16
C115 (\17\:CKb VSS) capacitor c=4.4501e-17
C116 (\7\:CKbb VSS) capacitor c=6.48934e-17
C117 (\8\:CKbb VSS) capacitor c=1.52158e-16
C118 (\11\:CKbb VSS) capacitor c=2.04876e-16
C119 (\20\:CKb VSS) capacitor c=8.29319e-17
C120 (\21\:CKb VSS) capacitor c=5.38561e-17
C121 (\5\:CK VSS) capacitor c=6.04056e-17
C122 (\5\:D VSS) capacitor c=3.34955e-17
C123 (\3\:Db VSS) capacitor c=2.59828e-16
C124 (\7\:SEb VSS) capacitor c=1.01387e-16
C125 (\8\:SEb VSS) capacitor c=1.46095e-16
C126 (\5\:SI VSS) capacitor c=4.12222e-17
C127 (\8\:SE VSS) capacitor c=1.10847e-16
C128 (\9\:SE VSS) capacitor c=7.91421e-17
C129 (\3\:VDD VSS) capacitor c=1.14612e-17
C130 (\6\:VDD VSS) capacitor c=2.21519e-17
C131 (\8\:VDD VSS) capacitor c=2.66096e-17
C132 (\9\:VDD VSS) capacitor c=3.73441e-17
C133 (\10\:VDD VSS) capacitor c=1.29433e-17
C134 (\12\:VDD VSS) capacitor c=2.00905e-17
C135 (\13\:VDD VSS) capacitor c=1.26802e-16
Rk43 (\5\:D D) resistor r=0.1389 c=0
Rk85 (\2\:VSS \3\:VSS) resistor r=0.03493 c=0
Rk86 (\3\:VSS \4\:VSS) resistor r=0.2404 c=0
Rk87 (\4\:VSS \5\:VSS) resistor r=0.07506 c=0
Rk88 (\5\:VSS \6\:VSS) resistor r=0.3034 c=0
Rk89 (\6\:VSS \7\:VSS) resistor r=0.4386 c=0
Rk90 (\7\:VSS \8\:VSS) resistor r=0.1102 c=0
Rk91 (\8\:VSS \9\:VSS) resistor r=0.5467 c=0
Rk92 (\9\:VSS \10\:VSS) resistor r=0.1553 c=0
Rk93 (\10\:VSS \11\:VSS) resistor r=0.1955 c=0
Rk94 (\11\:VSS \12\:VSS) resistor r=0.3059 c=0
Rk97 (\13\:VSS VSS) resistor r=0.3784 c=0
Rk95 (\12\:VSS \13\:VSS) resistor r=0.3084 c=0
Rk103 (\3\:VSS \22\:VSS) resistor r=0.07416 c=0
Rk104 (\4\:VSS \24\:VSS) resistor r=0.2551 c=0
Rk105 (\6\:VSS \26\:VSS) resistor r=0.2519 c=0
Rk106 (\7\:VSS \28\:VSS) resistor r=0.18 c=0
Rk107 (\9\:VSS \30\:VSS) resistor r=0.3145 c=0
Rk108 (\11\:VSS \32\:VSS) resistor r=0.2723 c=0
Rk56 (\2\:VDD \3\:VDD) resistor r=0.4077 c=0
Rk57 (\3\:VDD \5\:VDD) resistor r=0.07757 c=0
Rk58 (\5\:VDD \6\:VDD) resistor r=0.3686 c=0
Rk59 (\6\:VDD \7\:VDD) resistor r=0.4338 c=0
Rk60 (\7\:VDD \8\:VDD) resistor r=0.08761 c=0
Rk61 (\8\:VDD \9\:VDD) resistor r=0.5807 c=0
Rk62 (\9\:VDD \10\:VDD) resistor r=0.2335 c=0
Rk63 (\10\:VDD \11\:VDD) resistor r=0.1469 c=0
Rk64 (\11\:VDD \12\:VDD) resistor r=0.336 c=0
Rk68 (\13\:VDD VDD) resistor r=0.3257 c=0
Rk65 (\12\:VDD \13\:VDD) resistor r=0.2705 c=0
Rk74 (\3\:VDD \23\:VDD) resistor r=0.178 c=0
Rk75 (\6\:VDD \25\:VDD) resistor r=0.2685 c=0
Rk76 (\8\:VDD \27\:VDD) resistor r=0.442 c=0
Rk77 (\9\:VDD \29\:VDD) resistor r=0.04333 c=0
Rk78 (\10\:VDD \31\:VDD) resistor r=0.04333 c=0
Rk79 (\12\:VDD \33\:VDD) resistor r=0.1297 c=0
Rk42 (CK \5\:CK) resistor r=0.1283 c=0
Rk55 (\9\:SE SE) resistor r=0.003494 c=0
Rk54 (\8\:SE \9\:SE) resistor r=0.6233 c=0
Rk22 (\8\:SN SN) resistor r=0.01161 c=0
Rk21 (\7\:SN \8\:SN) resistor r=1.4486 c=0
Rk51 (\4\:SI \5\:SI) resistor r=0.00514 c=0
Rk52 (\6\:SI SI) resistor r=0.00514 c=0
Rk53 (\5\:SI \6\:SI) resistor r=0.05165 c=0
Rk10 (\26\:qbint \27\:qbint) resistor r=0.5082 c=0
Rk14 (\27\:qbint \33\:qbint) resistor r=0.5317 c=0
Rk18 (\11\:n30 \12\:n30) resistor r=0.755 c=0
Rk19 (\12\:n30 \14\:n30) resistor r=0.3055 c=0
Rk20 (\12\:n30 \16\:n30) resistor r=0.1792 c=0
Rk31 (\13\:CKb \14\:CKb) resistor r=0.7837 c=0
Rk32 (\14\:CKb \15\:CKb) resistor r=1.1282 c=0
Rk33 (\15\:CKb \16\:CKb) resistor r=0.8407 c=0
Rk34 (\14\:CKb \17\:CKb) resistor r=0.2527 c=0
Rk39 (\19\:CKb \20\:CKb) resistor r=0.1609 c=0
Rk40 (\20\:CKb \21\:CKb) resistor r=0.3243 c=0
Rk41 (\20\:CKb \23\:CKb) resistor r=0.5233 c=0
Rk23 (\5\:mout \6\:mout) resistor r=0.3103 c=0
Rk24 (\6\:mout \7\:mout) resistor r=0.3325 c=0
Rk25 (\7\:mout \9\:mout) resistor r=0.3617 c=0
Rk26 (\6\:mout \11\:mout) resistor r=0.2149 c=0
Rk27 (\6\:mout \13\:mout) resistor r=0.2613 c=0
Rk28 (\7\:mout \15\:mout) resistor r=0.07997 c=0
Rk35 (\7\:CKbb \8\:CKbb) resistor r=0.2559 c=0
Rk36 (\8\:CKbb \10\:CKbb) resistor r=0.5548 c=0
Rk37 (\8\:CKbb \11\:CKbb) resistor r=1.2865 c=0
Rk38 (\10\:CKbb \13\:CKbb) resistor r=0.3613 c=0
Rk29 (\5\:n20 \7\:n20) resistor r=0.501 c=0
Rk30 (\7\:n20 \8\:n20) resistor r=0.4791 c=0
Rk44 (\2\:Db \3\:Db) resistor r=0.3024 c=0
Rk45 (\3\:Db \5\:Db) resistor r=1.5361 c=0
Rk46 (\3\:Db \7\:Db) resistor r=0.8675 c=0
Rk47 (\5\:Db \9\:Db) resistor r=0.5347 c=0
Rk48 (\6\:SEb \7\:SEb) resistor r=0.5201 c=0
Rk49 (\7\:SEb \8\:SEb) resistor r=0.2961 c=0
Rk50 (\8\:SEb \10\:SEb) resistor r=0.7424 c=0
Rk17 (\2\:net355 \4\:net355) resistor r=0.3066 c=0
Rl57 (\1\:D \2\:D) resistor r=90.0987 c=0
Rl59 (\2\:D \4\:D) resistor r=84.3295 c=0
Rl58 (\2\:D \3\:D) resistor r=10.6974 c=0
Rl54 (\1\:CK \2\:CK) resistor r=113.176 c=0
Rl56 (\2\:CK \4\:CK) resistor r=63.1757 c=0
Rl55 (\2\:CK \3\:CK) resistor r=7.5059 c=0
Rl62 (\2\:SE \3\:SE) resistor r=135.031 c=0
Rl61 (\1\:SE \2\:SE) resistor r=43.4636 c=0
Rl68 (\5\:SE \7\:SE) resistor r=99.7141 c=0
Rl67 (\5\:SE \6\:SE) resistor r=45.868 c=0
Rl66 (\4\:SE \5\:SE) resistor r=11.5001 c=0
Rl39 (\4\:SN \5\:SN) resistor r=48.3726 c=0
Rl40 (\5\:SN \6\:SN) resistor r=147.31 c=0
Rl32 (\2\:SN \3\:SN) resistor r=24.7951 c=0
Rl31 (\1\:SN \2\:SN) resistor r=128.823 c=0
Rl64 (\1\:SI \2\:SI) resistor r=29.5379 c=0
Rl65 (\2\:SI \3\:SI) resistor r=150.257 c=0
Rl33 (\24\:qbint \23\:qbint) resistor r=116.54 c=0
Rl34 (\24\:qbint \25\:qbint) resistor r=24.2328 c=0
Rl53 (\11\:CKb \12\:CKb) resistor r=24.848 c=0
Rl51 (\9\:CKb \10\:CKb) resistor r=24.2328 c=0
Rl46 (\5\:CKb \6\:CKb) resistor r=48.7687 c=0
Rl38 (\3\:CKb \4\:CKb) resistor r=78.079 c=0
Rl35 (CKb \2\:CKb) resistor r=37.2302 c=0
Rl49 (\7\:CKb \8\:CKb) resistor r=80.8559 c=0
Rl52 (\8\:CKb \11\:CKb) resistor r=14.0381 c=0
Rl50 (\8\:CKb \9\:CKb) resistor r=162.618 c=0
Rl43 (mout \2\:mout) resistor r=77.3751 c=0
Rl45 (\2\:mout \4\:mout) resistor r=102.375 c=0
Rl44 (\2\:mout \3\:mout) resistor r=5.376 c=0
Rl36 (CKbb \2\:CKbb) resistor r=93.7964 c=0
Rl47 (\4\:CKbb \5\:CKbb) resistor r=24.2328 c=0
Rl48 (\5\:CKbb \6\:CKbb) resistor r=202.966 c=0
Rl37 (\2\:CKbb \3\:CKbb) resistor r=91.0764 c=0
Rl41 (n20 \2\:n20) resistor r=29.5379 c=0
Rl42 (\2\:n20 \3\:n20) resistor r=232.95 c=0
Rl63 (\3\:SEb \4\:SEb) resistor r=30.2349 c=0
Rl60 (SEb \2\:SEb) resistor r=74.2328 c=0
Rz22 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz23 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz24 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz25 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz26 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz27 (\32\:VSS \31\:VSS) resistor r=75 c=0
Rz20 (VDD \4\:VDD) resistor r=7.5 c=0
Rz16 (\5\:VDD \4\:VDD) resistor r=10.7143 c=0
Rz17 (\7\:VDD \4\:VDD) resistor r=8.3333 c=0
Rz18 (\11\:VDD \4\:VDD) resistor r=6.25 c=0
Rz19 (\13\:VDD \4\:VDD) resistor r=37.5 c=0
Rz7 (\14\:n30 \13\:n30) resistor r=75 c=0
Rz12 (\18\:CKb \19\:CKb) resistor r=75 c=0
Rz8 (\8\:mout \9\:mout) resistor r=75 c=0
Rz9 (\10\:mout \11\:mout) resistor r=75 c=0
Rz11 (\12\:CKbb \13\:CKbb) resistor r=75 c=0
Rz10 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz13 (Db \2\:Db) resistor r=75 c=0
Rz14 (\4\:Db \5\:Db) resistor r=75 c=0
Rz15 (\9\:SEb \10\:SEb) resistor r=75 c=0
Ry36 (VSS \1\:VSS) resistor r=5.1667 c=0
Ry31 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry32 (\5\:VSS \1\:VSS) resistor r=10.3333 c=0
Ry33 (\8\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry34 (\10\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry35 (\12\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry18 (\2\:VDD \1\:VDD) resistor r=62 c=0
Ry20 (\23\:VDD \22\:VDD) resistor r=62 c=0
Ry21 (\25\:VDD \24\:VDD) resistor r=20.6667 c=0
Ry22 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry23 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry24 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry25 (\33\:VDD \32\:VDD) resistor r=62 c=0
Ry9 (\16\:n30 \15\:n30) resistor r=62 c=0
Ry14 (\22\:CKb \23\:CKb) resistor r=62 c=0
Ry10 (\12\:mout \13\:mout) resistor r=62 c=0
Ry11 (\14\:mout \15\:mout) resistor r=62 c=0
Ry13 (\9\:CKbb \10\:CKbb) resistor r=62 c=0
Ry12 (\6\:n20 \7\:n20) resistor r=62 c=0
Ry15 (\6\:Db \7\:Db) resistor r=62 c=0
Ry16 (\8\:Db \9\:Db) resistor r=62 c=0
Ry17 (\5\:SEb \6\:SEb) resistor r=62 c=0
Ry7 (net355 \2\:net355) resistor r=62 c=0
Ry8 (\3\:net355 \4\:net355) resistor r=62 c=0
Rx16 (\3\:D \5\:D) resistor r=45 c=0
Rx15 (\3\:CK \5\:CK) resistor r=45 c=0
Rx20 (\2\:SE \8\:SE) resistor r=45 c=0
Rx21 (\4\:SE \9\:SE) resistor r=45 c=0
Rx4 (\5\:SN \7\:SN) resistor r=45 c=0
Rx5 (\2\:SN \8\:SN) resistor r=45 c=0
Rx19 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\26\:qbint \24\:qbint) resistor r=45 c=0
Rx2 (\33\:qbint qbint) resistor r=45 c=0
Rx3 (\11\:n30 n30) resistor r=45 c=0
Rx8 (\9\:CKb \13\:CKb) resistor r=45 c=0
Rx9 (\4\:CKb \15\:CKb) resistor r=45 c=0
Rx10 (\2\:CKb \16\:CKb) resistor r=45 c=0
Rx11 (\6\:CKb \17\:CKb) resistor r=45 c=0
Rx14 (\11\:CKb \21\:CKb) resistor r=45 c=0
Rx6 (\3\:mout \5\:mout) resistor r=45 c=0
Rx12 (\5\:CKbb \7\:CKbb) resistor r=45 c=0
Rx13 (\3\:CKbb \11\:CKbb) resistor r=45 c=0
Rx7 (\2\:n20 \8\:n20) resistor r=45 c=0
Rx17 (\4\:SEb \7\:SEb) resistor r=45 c=0
Rx18 (\2\:SEb \8\:SEb) resistor r=45 c=0
mn55_1__rcx (Q qbint VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.889e-14 ad=4.994e-14 ps=9.2143e-07 pd=9.2857e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.485e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
mn45_1__rcx (\27\:qbint n30 \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.328e-14 ad=4.333e-14 ps=8.6e-07 pd=8.5333e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.2599e-06 sd=160n \
        sca=17.5885 scb=0.0172826 scc=0.00162584 m=(3)
mn50 (net459 \1\:SN \13\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.665e-14 ad=2.768e-14 ps=9e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.05e-07 sb=7.8e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn51 (net467 \25\:qbint net459 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.768e-14 ad=2.768e-14 ps=6.8e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=6e-07 sd=160n sca=19.867 scb=0.0198061 \
        scc=0.00201945 m=(1)
mn52 (\13\:n30 CKb net467 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.768e-14 ad=4.818e-14 ps=6.8e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=4.2e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn40 (\13\:n30 CKbb \8\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=4.818e-14 ps=6.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.445e-06 sb=1.4e-07 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn30 (net435 \6\:SN \31\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.485e-14 ad=1.435e-14 ps=7.5e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2.55e-07 sd=160n sca=11.015 \
        scb=0.0105032 scc=0.000405626 m=(1)
mn31 (\10\:mout \3\:n20 net435 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=1.435e-14 ad=2.87e-14 ps=5.5e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.4e-07 sd=160n sca=11.015 \
        scb=0.0105032 scc=0.000405626 m=(1)
mn35 (net427 mout \29\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.87e-14 ad=2.05e-14 ps=6.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=6.35e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn36 (\4\:n20 \6\:CKbb net427 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.05e-14 ad=4.305e-14 ps=6.1e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=4.9e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn25 (\4\:n20 \10\:CKb \4\:Db VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.818e-14 ad=4.305e-14 ps=8.8e-07 pd=8.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.4e-07 sb=2.35e-07 sd=160n sca=13.8179 \
        scb=0.0141903 scc=0.000851218 m=(1)
mn21 (\12\:CKbb \12\:CKb \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.043e-14 ad=2.175e-14 ps=1.17e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.5e-07 sb=3.05e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn20 (\18\:CKb \4\:CK \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.135e-14 ad=2.03e-14 ps=1.42e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.215e-06 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn11 (net443 \4\:D \25\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.135e-14 ad=5.85e-14 ps=1.42e-06 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.16058e-07 sb=7.2e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn12 (Db SEb net443 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=5.85e-14 \
        ad=4.16e-14 ps=9.7e-07 pd=8.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.86058e-07 sb=4.5e-07 sd=160n sca=12.8392 scb=0.0126987 \
        scc=0.00074151 m=(1)
mn14 (Db \1\:SE net455 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.16e-14 ps=6.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.91058e-07 sb=2.45e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn13 (net455 \3\:SI \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=1.56e-14 ps=8e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.96058e-07 sb=1.4e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn10 (\9\:SEb \6\:SE \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.465e-14 ad=2.03e-14 ps=1.5e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mp45_1__rcx (\27\:qbint n30 \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.627e-14 ad=5.747e-14 ps=1.32e-06 pd=1.08667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.22051e-07 sb=7.73077e-07 sd=160n \
        sca=30.5009 scb=0.0202006 scc=0.00336097 m=(3)
mp50 (\3\:net355 \3\:SN \13\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.04e-13 ad=6.51e-14 ps=1.76e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.85323e-07 sb=3.55e-07 sd=160n sca=11.2287 \
        scb=0.00925355 scc=0.000213039 m=(1)
mp51 (\3\:net355 \23\:qbint \32\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=4.59e-14 ad=6.51e-14 ps=1.22e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.40323e-07 sb=1e-07 sd=160n sca=11.2287 \
        scb=0.00925355 scc=0.000213039 m=(1)
mp52 (\15\:n30 \2\:CKbb net355 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.3871e-07 sb=3.20484e-07 sd=160n sca=35.6995 scb=0.0234062 \
        scc=0.00420468 m=(1)
mp40 (\15\:n30 \3\:CKb \14\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.58e-14 ad=4.96e-14 ps=9e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.4371e-07 sb=1.15484e-07 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(1)
mp30 (\12\:mout \4\:SN \30\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.14e-14 ad=4.96e-14 ps=1.44e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.12e-06 sd=160n sca=11.6918 \
        scb=0.00996378 scc=0.000286585 m=(1)
mp31 (\12\:mout n20 \28\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.7e-14 ad=4.96e-14 ps=1.54e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.05e-07 sb=9.15e-07 sd=160n sca=11.6918 \
        scb=0.00996378 scc=0.000286585 m=(1)
mp35 (net378 \4\:mout \28\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.7e-14 ad=3.565e-14 ps=1.54e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.7e-07 sb=6.5e-07 sd=160n sca=11.6918 \
        scb=0.00996378 scc=0.000286585 m=(1)
mp36 (\6\:n20 \5\:CKb net378 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=3.565e-14 ad=6.51e-14 ps=8.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.3e-07 sb=4.9e-07 sd=160n sca=11.6918 \
        scb=0.00996378 scc=0.000286585 m=(1)
mp25 (\6\:n20 \4\:CKbb \8\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.285e-14 ad=6.51e-14 ps=1.09e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.85e-07 sb=2.35e-07 sd=160n sca=11.6918 \
        scb=0.00996378 scc=0.000286585 m=(1)
mp21 (\9\:CKbb \7\:CKb \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\22\:CKb \1\:CK \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.2125e-13 ad=3.01e-14 ps=1.68e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.28e-06 sd=160n sca=12.1244 \
        scb=0.0107968 scc=0.000332109 m=(1)
mp11 (net390 \1\:D \24\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.2125e-13 ad=1.287e-13 ps=1.68e-06 pd=1.44e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.12885e-07 sb=7.97308e-07 sd=160n sca=11.4561 \
        scb=0.00963524 scc=0.000244209 m=(1)
mp12 (\6\:Db \3\:SE net390 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.287e-13 ad=6.24e-14 ps=1.44e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.87885e-07 sb=4.22308e-07 sd=160n sca=11.4656 \
        scb=0.00963696 scc=0.000244209 m=(1)
mp14 (\6\:Db \3\:SEb net398 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.92885e-07 sb=2.17308e-07 sd=160n sca=12.0152 \
        scb=0.00983999 scc=0.000244281 m=(1)
mp13 (net398 \1\:SI \22\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.38e-14 ad=2.34e-14 ps=1.06e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.09788e-06 sb=1.12308e-07 sd=160n sca=12.499 \
        scb=0.0102001 scc=0.000244729 m=(1)
mp10 (\5\:SEb \7\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.94e-14 ad=3.01e-14 ps=1.15e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=24.2122 scb=0.0283954 \
        scc=0.00140518 m=(1)
ends SDFFSHQX8
// End of subcircuit definition.

// Generated for: spectre (May  9 17:38:24 2012 )
// Library name: gsclib045
// Cell name: SDFFSRHQX1
// View name: extracted

simulator lang=spectre

subckt SDFFSRHQX1 CK D Q RN SE SI SN VDD VSS
mp55 (\1\:Q qbint \28\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.75256e-07 sd=160n sca=40.5329 \
        scb=0.0348939 scc=0.00409042 m=(1)
C1 (D VSS) capacitor c=9.39977e-17
C2 (Q VSS) capacitor c=4.05834e-17
C3 (RN VSS) capacitor c=4.5137e-17
C4 (CK VSS) capacitor c=8.17922e-17
C5 (SE VSS) capacitor c=2.7557e-17
C6 (VDD VSS) capacitor c=4.64901e-16
C7 (SI VSS) capacitor c=9.16067e-17
C8 (qbint VSS) capacitor c=4.61499e-17
C9 (n35 VSS) capacitor c=4.81501e-17
C10 (RNb VSS) capacitor c=1.19491e-16
C11 (net486 VSS) capacitor c=8.11529e-17
C12 (net490 VSS) capacitor c=1.01555e-16
C13 (CKb VSS) capacitor c=3.64621e-17
C14 (mout VSS) capacitor c=3.84992e-17
C15 (CKbb VSS) capacitor c=2.80235e-17
C16 (net469 VSS) capacitor c=5.955e-17
C17 (n20 VSS) capacitor c=6.06015e-17
C18 (net514 VSS) capacitor c=2.26474e-18
C19 (Db VSS) capacitor c=1.307e-16
C20 (net522 VSS) capacitor c=6.99785e-18
C21 (SEb VSS) capacitor c=4.47046e-17
C22 (net394 VSS) capacitor c=1.09543e-16
C23 (net437 VSS) capacitor c=1.24016e-18
C24 (net417 VSS) capacitor c=5.63924e-18
C25 (net425 VSS) capacitor c=4.17817e-18
C26 (net445 VSS) capacitor c=2.61316e-18
C27 (net453 VSS) capacitor c=4.79661e-18
C28 (\7\:SE VSS) capacitor c=5.42413e-17
C29 (\3\:SI VSS) capacitor c=6.06897e-17
C30 (\1\:SE VSS) capacitor c=7.40588e-17
C31 (\1\:D VSS) capacitor c=1.05264e-16
C32 (\1\:CK VSS) capacitor c=4.7841e-17
C33 (\5\:CKb VSS) capacitor c=3.15198e-17
C34 (\7\:CKbb VSS) capacitor c=2.68164e-17
C35 (\9\:CKb VSS) capacitor c=5.25351e-17
C36 (\5\:SN VSS) capacitor c=7.3412e-17
C37 (\3\:CKb VSS) capacitor c=4.35843e-17
C38 (\3\:CKbb VSS) capacitor c=5.12162e-17
C39 (\3\:RNb VSS) capacitor c=7.24781e-17
C40 (\5\:qbint VSS) capacitor c=1.38257e-16
C41 (\1\:SN VSS) capacitor c=4.58835e-17
C42 (\1\:RN VSS) capacitor c=2.81598e-17
C43 (\5\:SE VSS) capacitor c=3.16804e-17
C44 (\1\:SI VSS) capacitor c=8.78861e-17
C45 (\3\:SE VSS) capacitor c=7.47651e-17
C46 (\3\:SEb VSS) capacitor c=6.94603e-17
C47 (\4\:D VSS) capacitor c=4.23249e-17
C48 (\3\:CK VSS) capacitor c=3.42747e-17
C49 (\10\:CKb VSS) capacitor c=2.79437e-17
C50 (\11\:CKb VSS) capacitor c=3.14995e-17
C51 (\5\:CKbb VSS) capacitor c=5.00978e-17
C52 (\3\:mout VSS) capacitor c=5.52696e-17
C53 (\4\:SN VSS) capacitor c=6.63816e-17
C54 (\3\:n20 VSS) capacitor c=3.35897e-17
C55 (\4\:RNb VSS) capacitor c=4.93672e-17
C56 (\5\:RNb VSS) capacitor c=6.73962e-17
C57 (\7\:qbint VSS) capacitor c=7.2803e-17
C58 (\3\:SN VSS) capacitor c=3.747e-17
C59 (\3\:RN VSS) capacitor c=2.75684e-17
C60 (\3\:n35 VSS) capacitor c=3.52614e-17
C61 (\3\:qbint VSS) capacitor c=4.15107e-17
C62 (\6\:SE VSS) capacitor c=5.2086e-17
C63 (\2\:SI VSS) capacitor c=5.78096e-17
C64 (\4\:SE VSS) capacitor c=4.66283e-17
C65 (\2\:SEb VSS) capacitor c=5.5727e-17
C66 (\2\:SE VSS) capacitor c=4.8502e-17
C67 (\3\:D VSS) capacitor c=2.71577e-17
C68 (\2\:CK VSS) capacitor c=5.40778e-17
C69 (\6\:CKb VSS) capacitor c=2.27659e-17
C70 (\8\:CKbb VSS) capacitor c=4.2129e-17
C71 (\6\:CKbb VSS) capacitor c=3.94286e-17
C72 (\2\:mout VSS) capacitor c=4.1661e-17
C73 (\4\:n20 VSS) capacitor c=4.25167e-17
C74 (\6\:SN VSS) capacitor c=2.21119e-17
C75 (\4\:CKbb VSS) capacitor c=3.11375e-17
C76 (\4\:CKb VSS) capacitor c=3.71945e-17
C77 (\2\:CKb VSS) capacitor c=2.17708e-17
C78 (\2\:RNb VSS) capacitor c=9.44074e-17
C79 (\2\:SN VSS) capacitor c=3.57241e-17
C80 (\2\:RN VSS) capacitor c=2.22981e-17
C81 (\6\:qbint VSS) capacitor c=3.55672e-17
C82 (\2\:n35 VSS) capacitor c=3.48002e-17
C83 (\4\:qbint VSS) capacitor c=2.2405e-17
C84 (\8\:SEb VSS) capacitor c=1.32789e-17
C85 (\1\:VDD VSS) capacitor c=3.57993e-17
C86 (\16\:VDD VSS) capacitor c=2.15871e-17
C87 (\18\:CKb VSS) capacitor c=7.49642e-17
C88 (\18\:VDD VSS) capacitor c=4.5983e-17
C89 (\11\:CKbb VSS) capacitor c=1.0896e-16
C90 (\7\:Db VSS) capacitor c=1.02825e-16
C91 (\5\:n20 VSS) capacitor c=8.91456e-17
C92 (\20\:VDD VSS) capacitor c=5.8183e-17
C93 (\11\:mout VSS) capacitor c=1.91635e-16
C94 (\22\:VDD VSS) capacitor c=6.03905e-17
C95 (\7\:mout VSS) capacitor c=3.76131e-17
C96 (\4\:n35 VSS) capacitor c=7.86376e-17
C97 (\24\:VDD VSS) capacitor c=5.43603e-17
C98 (\3\:net394 VSS) capacitor c=8.85202e-17
C99 (\26\:VDD VSS) capacitor c=7.30948e-17
C100 (\7\:RNb VSS) capacitor c=1.57874e-16
C101 (\9\:qbint VSS) capacitor c=6.47949e-17
C102 (\28\:VDD VSS) capacitor c=6.71576e-17
C103 (\1\:Q VSS) capacitor c=4.84828e-17
C104 (\3\:VDD VSS) capacitor c=1.9644e-16
C105 (\4\:SEb VSS) capacitor c=7.50296e-17
C106 (\9\:Db VSS) capacitor c=4.11207e-17
C107 (\12\:CKb VSS) capacitor c=7.72304e-17
C108 (\9\:CKbb VSS) capacitor c=9.45958e-17
C109 (\5\:Db VSS) capacitor c=1.93283e-16
C110 (\9\:n20 VSS) capacitor c=1.93587e-17
C111 (\9\:mout VSS) capacitor c=1.35534e-16
C112 (\3\:net469 VSS) capacitor c=7.3497e-17
C113 (\4\:mout VSS) capacitor c=1.11715e-16
C114 (\8\:n35 VSS) capacitor c=6.25539e-17
C115 (\3\:net490 VSS) capacitor c=1.00586e-16
C116 (\3\:net486 VSS) capacitor c=9.37271e-17
C117 (\9\:RNb VSS) capacitor c=6.87526e-17
C118 (\12\:qbint VSS) capacitor c=5.73324e-17
C119 (\3\:Q VSS) capacitor c=1.5149e-17
C120 (\2\:qbint VSS) capacitor c=1.29808e-17
C121 (\2\:CKbb VSS) capacitor c=5.95223e-17
C122 (\2\:n20 VSS) capacitor c=2.85825e-17
C123 (\8\:qbint VSS) capacitor c=5.27258e-17
C124 (\11\:qbint VSS) capacitor c=5.1237e-17
C125 (\14\:qbint VSS) capacitor c=6.0463e-17
C126 (\7\:CKb VSS) capacitor c=2.22301e-17
C127 (\8\:CKb VSS) capacitor c=6.78106e-17
C128 (\4\:RN VSS) capacitor c=6.6291e-17
C129 (\2\:D VSS) capacitor c=2.66666e-17
C130 (\6\:RNb VSS) capacitor c=1.14348e-16
C131 (\6\:n35 VSS) capacitor c=3.14439e-16
C132 (\7\:n35 VSS) capacitor c=2.52105e-16
C133 (\7\:SN VSS) capacitor c=3.09744e-16
C134 (\8\:SN VSS) capacitor c=3.48224e-16
C135 (\6\:mout VSS) capacitor c=1.47326e-16
C136 (\13\:mout VSS) capacitor c=8.1372e-17
C137 (\7\:n20 VSS) capacitor c=1.10145e-16
C138 (\8\:n20 VSS) capacitor c=8.81833e-17
C139 (\13\:CKbb VSS) capacitor c=1.32303e-16
C140 (\14\:CKbb VSS) capacitor c=6.74271e-17
C141 (\15\:CKbb VSS) capacitor c=2.52491e-16
C142 (\16\:CKbb VSS) capacitor c=1.99139e-16
C143 (\4\:CK VSS) capacitor c=3.19028e-17
C144 (\14\:CKb VSS) capacitor c=9.32969e-17
C145 (\15\:CKb VSS) capacitor c=4.0776e-16
C146 (\16\:CKb VSS) capacitor c=5.16837e-16
C147 (\17\:CKb VSS) capacitor c=1.2219e-16
C148 (\4\:Db VSS) capacitor c=1.98875e-16
C149 (\8\:SE VSS) capacitor c=6.70147e-17
C150 (\9\:SE VSS) capacitor c=5.09199e-17
C151 (\10\:SE VSS) capacitor c=4.46756e-17
C152 (\4\:SI VSS) capacitor c=4.5376e-17
C153 (\6\:SEb VSS) capacitor c=1.00438e-16
C154 (\7\:SEb VSS) capacitor c=8.28004e-17
C155 (\5\:VDD VSS) capacitor c=2.54731e-17
C156 (\6\:VDD VSS) capacitor c=1.43846e-17
C157 (\8\:VDD VSS) capacitor c=4.75908e-17
C158 (\9\:VDD VSS) capacitor c=2.73079e-17
C159 (\11\:VDD VSS) capacitor c=2.99649e-17
C160 (\13\:VDD VSS) capacitor c=2.62265e-17
C161 (\15\:VDD VSS) capacitor c=1.10967e-17
Rk38 (D \5\:D) resistor r=0.004839 c=0
Rk1 (\2\:Q Q) resistor r=0.3083 c=0
Rk2 (Q \4\:Q) resistor r=0.0627 c=0
Rk7 (RN \4\:RN) resistor r=0.1074 c=0
Rk32 (\4\:CK CK) resistor r=0.1038 c=0
Rk44 (\8\:SE \9\:SE) resistor r=0.3182 c=0
Rk46 (\10\:SE SE) resistor r=0.0304 c=0
Rk45 (\9\:SE \10\:SE) resistor r=0.2328 c=0
Rk68 (\2\:VDD \4\:VDD) resistor r=0.3071 c=0
Rk69 (\4\:VDD \5\:VDD) resistor r=0.2984 c=0
Rk70 (\5\:VDD \6\:VDD) resistor r=0.3635 c=0
Rk71 (\6\:VDD \7\:VDD) resistor r=0.1905 c=0
Rk72 (\7\:VDD \8\:VDD) resistor r=0.5469 c=0
Rk73 (\8\:VDD \9\:VDD) resistor r=0.4814 c=0
Rk74 (\9\:VDD \10\:VDD) resistor r=0.1253 c=0
Rk75 (\10\:VDD \11\:VDD) resistor r=0.6071 c=0
Rk76 (\11\:VDD \12\:VDD) resistor r=0.1955 c=0
Rk77 (\12\:VDD \13\:VDD) resistor r=0.2056 c=0
Rk78 (\13\:VDD \14\:VDD) resistor r=0.2959 c=0
Rk80 (\15\:VDD VDD) resistor r=0.1225 c=0
Rk79 (\14\:VDD \15\:VDD) resistor r=0.1278 c=0
Rk81 (\5\:VDD \17\:VDD) resistor r=0.2559 c=0
Rk82 (\6\:VDD \19\:VDD) resistor r=0.3122 c=0
Rk83 (\8\:VDD \21\:VDD) resistor r=0.2365 c=0
Rk84 (\9\:VDD \23\:VDD) resistor r=0.2178 c=0
Rk85 (\11\:VDD \25\:VDD) resistor r=0.2544 c=0
Rk86 (\13\:VDD \27\:VDD) resistor r=0.3355 c=0
Rk87 (\15\:VDD \29\:VDD) resistor r=0.373 c=0
Rk17 (\7\:SN SN) resistor r=2.5763 c=0
Rk18 (SN \8\:SN) resistor r=0.003345 c=0
Rk47 (\4\:SI SI) resistor r=0.0223 c=0
Rk51 (\2\:VSS \3\:VSS) resistor r=0.1127 c=0
Rk52 (\3\:VSS \4\:VSS) resistor r=0.03745 c=0
Rk53 (\4\:VSS \5\:VSS) resistor r=0.3627 c=0
Rk54 (\5\:VSS \6\:VSS) resistor r=0.2874 c=0
Rk55 (\6\:VSS \7\:VSS) resistor r=0.1519 c=0
Rk56 (\7\:VSS \8\:VSS) resistor r=0.621 c=0
Rk57 (\8\:VSS \9\:VSS) resistor r=0.4289 c=0
Rk58 (\9\:VSS \10\:VSS) resistor r=1.1432 c=0
Rk59 (\10\:VSS \11\:VSS) resistor r=0.05908 c=0
Rk61 (\12\:VSS VSS) resistor r=0.1075 c=0
Rk60 (\11\:VSS \12\:VSS) resistor r=0.444 c=0
Rk62 (\3\:VSS \14\:VSS) resistor r=0.2932 c=0
Rk63 (\5\:VSS \16\:VSS) resistor r=0.04335 c=0
Rk64 (\7\:VSS \18\:VSS) resistor r=0.04335 c=0
Rk65 (\8\:VSS \20\:VSS) resistor r=0.2208 c=0
Rk66 (\10\:VSS \22\:VSS) resistor r=0.04335 c=0
Rk67 (\12\:VSS \24\:VSS) resistor r=0.3175 c=0
Rk3 (\8\:qbint \10\:qbint) resistor r=0.4762 c=0
Rk4 (\10\:qbint \11\:qbint) resistor r=0.2549 c=0
Rk5 (\11\:qbint \13\:qbint) resistor r=0.27 c=0
Rk6 (\11\:qbint \14\:qbint) resistor r=0.3115 c=0
Rk13 (\5\:n35 \6\:n35) resistor r=0.1981 c=0
Rk14 (\6\:n35 \7\:n35) resistor r=2.1301 c=0
Rk15 (\6\:n35 \9\:n35) resistor r=0.2555 c=0
Rk8 (\6\:RNb \8\:RNb) resistor r=0.9706 c=0
Rk9 (\8\:RNb \10\:RNb) resistor r=0.3469 c=0
Rk10 (\2\:net486 \4\:net486) resistor r=0.4085 c=0
Rk12 (\2\:net490 \4\:net490) resistor r=0.414 c=0
Rk33 (\13\:CKb \14\:CKb) resistor r=0.5137 c=0
Rk34 (\14\:CKb \15\:CKb) resistor r=0.2565 c=0
Rk35 (\15\:CKb \16\:CKb) resistor r=3.0628 c=0
Rk36 (\16\:CKb \17\:CKb) resistor r=0.885 c=0
Rk37 (\15\:CKb \19\:CKb) resistor r=0.5675 c=0
Rk19 (\5\:mout \6\:mout) resistor r=0.2728 c=0
Rk20 (\6\:mout \8\:mout) resistor r=0.1246 c=0
Rk21 (\5\:mout \10\:mout) resistor r=0.7108 c=0
Rk22 (\6\:mout \12\:mout) resistor r=1.0055 c=0
Rk23 (\12\:mout \13\:mout) resistor r=0.4847 c=0
Rk27 (\10\:CKbb \12\:CKbb) resistor r=0.4924 c=0
Rk28 (\12\:CKbb \13\:CKbb) resistor r=0.3175 c=0
Rk29 (\13\:CKbb \14\:CKbb) resistor r=0.23 c=0
Rk30 (\13\:CKbb \15\:CKbb) resistor r=0.626 c=0
Rk31 (\15\:CKbb \16\:CKbb) resistor r=1.4759 c=0
Rk16 (\2\:net469 \4\:net469) resistor r=0.3105 c=0
Rk24 (\6\:n20 \7\:n20) resistor r=0.4561 c=0
Rk25 (\7\:n20 \8\:n20) resistor r=0.5572 c=0
Rk26 (\7\:n20 \10\:n20) resistor r=0.03488 c=0
Rk39 (\2\:Db \3\:Db) resistor r=0.1635 c=0
Rk40 (\3\:Db \4\:Db) resistor r=0.619 c=0
Rk41 (\4\:Db \6\:Db) resistor r=1.1229 c=0
Rk42 (\6\:Db \8\:Db) resistor r=0.5998 c=0
Rk43 (\4\:Db \10\:Db) resistor r=0.2581 c=0
Rk48 (\5\:SEb \6\:SEb) resistor r=0.7053 c=0
Rk49 (\6\:SEb \7\:SEb) resistor r=0.4832 c=0
Rk50 (\6\:SEb \9\:SEb) resistor r=0.04832 c=0
Rk11 (\2\:net394 \4\:net394) resistor r=0.5311 c=0
Rl38 (\1\:D \2\:D) resistor r=101.157 c=0
Rl40 (\2\:D \4\:D) resistor r=47.3105 c=0
Rl39 (\2\:D \3\:D) resistor r=58.0656 c=0
Rl6 (\1\:RN \2\:RN) resistor r=28.079 c=0
Rl7 (\2\:RN \3\:RN) resistor r=78.079 c=0
Rl36 (\1\:CK \2\:CK) resistor r=166.862 c=0
Rl37 (\2\:CK \3\:CK) resistor r=89.6174 c=0
Rl48 (\6\:SE \7\:SE) resistor r=179.104 c=0
Rl47 (\5\:SE \6\:SE) resistor r=35.3072 c=0
Rl44 (\3\:SE \4\:SE) resistor r=28.079 c=0
Rl41 (\1\:SE \2\:SE) resistor r=31.8672 c=0
Rl24 (\4\:SN \5\:SN) resistor r=197.643 c=0
Rl25 (\5\:SN \6\:SN) resistor r=24.2328 c=0
Rl8 (\1\:SN \2\:SN) resistor r=28.079 c=0
Rl9 (\2\:SN \3\:SN) resistor r=85.7713 c=0
Rl46 (\2\:SI \3\:SI) resistor r=26.3736 c=0
Rl45 (\1\:SI \2\:SI) resistor r=105.769 c=0
Rl11 (\5\:qbint \7\:qbint) resistor r=175 c=0
Rl10 (\5\:qbint \6\:qbint) resistor r=276.436 c=0
Rl1 (qbint \2\:qbint) resistor r=26.9069 c=0
Rl2 (\2\:qbint \3\:qbint) resistor r=72.5882 c=0
Rl3 (\2\:qbint \4\:qbint) resistor r=4.4012 c=0
Rl4 (n35 \2\:n35) resistor r=79.5379 c=0
Rl5 (\2\:n35 \3\:n35) resistor r=29.5379 c=0
Rl19 (RNb \4\:RNb) resistor r=165.385 c=0
Rl20 (\3\:RNb \5\:RNb) resistor r=197.643 c=0
Rl17 (RNb \2\:RNb) resistor r=821.693 c=0
Rl18 (\2\:RNb \3\:RNb) resistor r=24.2328 c=0
Rl30 (\5\:CKb \6\:CKb) resistor r=122.31 c=0
Rl13 (\3\:CKb \4\:CKb) resistor r=29.5379 c=0
Rl12 (CKb \2\:CKb) resistor r=24.2328 c=0
Rl34 (\7\:CKb \10\:CKb) resistor r=30.4507 c=0
Rl31 (\6\:CKb \7\:CKb) resistor r=14.4132 c=0
Rl33 (\8\:CKb \9\:CKb) resistor r=150.722 c=0
Rl35 (\8\:CKb \11\:CKb) resistor r=68.4643 c=0
Rl32 (\7\:CKb \8\:CKb) resistor r=208.53 c=0
Rl26 (mout \2\:mout) resistor r=24.2328 c=0
Rl27 (\2\:mout \3\:mout) resistor r=114.617 c=0
Rl29 (\7\:CKbb \8\:CKbb) resistor r=29.5379 c=0
Rl28 (\5\:CKbb \6\:CKbb) resistor r=62.2302 c=0
Rl14 (CKbb \2\:CKbb) resistor r=34.2969 c=0
Rl15 (\2\:CKbb \3\:CKbb) resistor r=159.159 c=0
Rl16 (\2\:CKbb \4\:CKbb) resistor r=153.772 c=0
Rl21 (n20 \2\:n20) resistor r=133.849 c=0
Rl22 (\2\:n20 \3\:n20) resistor r=28.0797 c=0
Rl23 (\2\:n20 \4\:n20) resistor r=73.9143 c=0
Rl42 (SEb \2\:SEb) resistor r=26.4372 c=0
Rl43 (\2\:SEb \3\:SEb) resistor r=111.5 c=0
Rz1 (\3\:Q \4\:Q) resistor r=75 c=0
Rz25 (\3\:VDD \4\:VDD) resistor r=12.5 c=0
Rz26 (\3\:VDD \7\:VDD) resistor r=6.8182 c=0
Rz27 (\3\:VDD \10\:VDD) resistor r=6.25 c=0
Rz28 (\3\:VDD \12\:VDD) resistor r=18.75 c=0
Rz29 (\3\:VDD \14\:VDD) resistor r=12.5 c=0
Rz19 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz20 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz21 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz22 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz23 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz24 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz2 (\12\:qbint \13\:qbint) resistor r=75 c=0
Rz8 (\8\:n35 \9\:n35) resistor r=75 c=0
Rz3 (\9\:RNb \10\:RNb) resistor r=75 c=0
Rz4 (net486 \2\:net486) resistor r=75 c=0
Rz5 (\3\:net486 \4\:net486) resistor r=75 c=0
Rz6 (net490 \2\:net490) resistor r=75 c=0
Rz7 (\3\:net490 \4\:net490) resistor r=75 c=0
Rz15 (\12\:CKb \13\:CKb) resistor r=75 c=0
Rz11 (\4\:mout \5\:mout) resistor r=75 c=0
Rz12 (\9\:mout \10\:mout) resistor r=75 c=0
Rz14 (\9\:CKbb \10\:CKbb) resistor r=75 c=0
Rz9 (net469 \2\:net469) resistor r=75 c=0
Rz10 (\3\:net469 \4\:net469) resistor r=75 c=0
Rz13 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz16 (\5\:Db \6\:Db) resistor r=75 c=0
Rz17 (\9\:Db \10\:Db) resistor r=75 c=0
Rz18 (\4\:SEb \5\:SEb) resistor r=75 c=0
Ry1 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry21 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry22 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry23 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry24 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry25 (\22\:VDD \23\:VDD) resistor r=62 c=0
Ry26 (\24\:VDD \25\:VDD) resistor r=62 c=0
Ry27 (\26\:VDD \27\:VDD) resistor r=62 c=0
Ry28 (\28\:VDD \29\:VDD) resistor r=62 c=0
Ry16 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry17 (\1\:VSS \4\:VSS) resistor r=62 c=0
Ry18 (\1\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry19 (\1\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry20 (\1\:VSS \11\:VSS) resistor r=5.1667 c=0
Ry2 (\9\:qbint \10\:qbint) resistor r=62 c=0
Ry6 (\4\:n35 \5\:n35) resistor r=31 c=0
Ry3 (\7\:RNb \8\:RNb) resistor r=62 c=0
Ry11 (\18\:CKb \19\:CKb) resistor r=62 c=0
Ry7 (\7\:mout \8\:mout) resistor r=62 c=0
Ry8 (\11\:mout \12\:mout) resistor r=62 c=0
Ry10 (\11\:CKbb \12\:CKbb) resistor r=62 c=0
Ry9 (\5\:n20 \6\:n20) resistor r=62 c=0
Ry12 (Db \2\:Db) resistor r=62 c=0
Ry13 (Db \3\:Db) resistor r=62 c=0
Ry14 (\7\:Db \8\:Db) resistor r=62 c=0
Ry15 (\8\:SEb \9\:SEb) resistor r=62 c=0
Ry4 (net394 \2\:net394) resistor r=62 c=0
Ry5 (\3\:net394 \4\:net394) resistor r=62 c=0
Rx17 (\3\:D \5\:D) resistor r=45 c=0
Rx3 (\2\:RN \4\:RN) resistor r=45 c=0
Rx13 (\2\:CK \4\:CK) resistor r=45 c=0
Rx18 (\2\:SE \8\:SE) resistor r=45 c=0
Rx19 (\4\:SE \9\:SE) resistor r=45 c=0
Rx20 (\6\:SE \10\:SE) resistor r=45 c=0
Rx6 (\6\:SN \7\:SN) resistor r=45 c=0
Rx7 (\2\:SN \8\:SN) resistor r=45 c=0
Rx21 (\2\:SI \4\:SI) resistor r=45 c=0
Rx1 (\6\:qbint \8\:qbint) resistor r=45 c=0
Rx2 (\4\:qbint \14\:qbint) resistor r=45 c=0
Rx5 (\2\:n35 \7\:n35) resistor r=45 c=0
Rx4 (\2\:RNb \6\:RNb) resistor r=45 c=0
Rx14 (\6\:CKb \14\:CKb) resistor r=45 c=0
Rx15 (\4\:CKb \16\:CKb) resistor r=45 c=0
Rx16 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx8 (\2\:mout \13\:mout) resistor r=45 c=0
Rx10 (\8\:CKbb \14\:CKbb) resistor r=45 c=0
Rx11 (\6\:CKbb \15\:CKbb) resistor r=45 c=0
Rx12 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx9 (\4\:n20 \8\:n20) resistor r=45 c=0
Rx22 (\2\:SEb \7\:SEb) resistor r=45 c=0
mn55 (\3\:Q \3\:qbint \23\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.445e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=3.83846e-07 sd=160n sca=14.4034 scb=0.0144248 \
        scc=0.00102063 m=(1)
mn45 (\12\:qbint \3\:n35 \23\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.445e-14 ad=4.613e-14 ps=9e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2.25e-07 sd=160n sca=16.0682 \
        scb=0.0166045 scc=0.00126927 m=(1)
mn22 (\9\:RNb \3\:RN \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.115e-14 ad=2.03e-14 ps=1.96e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=8.93103e-07 sd=160n sca=16.2011 \
        scb=0.0172667 scc=0.0012292 m=(1)
mn50 (\3\:net486 \3\:SN \21\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=8.115e-14 ad=3.28e-14 ps=1.96e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.83537e-07 sb=5.95e-07 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn52 (net490 \7\:qbint \3\:net486 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.28e-14 ad=3.383e-14 ps=7.3e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.88537e-07 sb=3.9e-07 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn51 (net490 \5\:RNb net486 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=3.69e-14 ad=3.383e-14 ps=7.7e-07 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.98537e-07 sb=1.8e-07 sd=160n sca=12.7388 \
        scb=0.0128661 scc=0.000666764 m=(1)
mn53 (\8\:n35 CKb \3\:net490 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.818e-14 ad=4.92e-14 ps=8.8e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=5.7e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn40 (\8\:n35 CKbb \4\:mout VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=5.843e-14 ad=4.92e-14 ps=9.8e-07 pd=8.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=2.85e-07 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(1)
mn31 (\9\:mout \4\:RNb \3\:net469 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=2.87e-14 ad=3.69e-14 ps=6.9e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.40305e-06 sd=160n sca=9.17255 \
        scb=0.0076374 scc=0.000189126 m=(1)
mn32 (\9\:mout \3\:n20 net469 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=6.8e-14 ad=3.69e-14 ps=1.09e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.17805e-06 sd=160n sca=9.17255 \
        scb=0.0076374 scc=0.000189126 m=(1)
mn30 (net469 \4\:SN \19\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.305e-14 ad=6.8e-14 ps=8.3e-07 pd=1.09e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.29268e-07 sb=8.25e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn35 (net514 \3\:mout \19\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.305e-14 ad=2.255e-14 ps=8.3e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.84268e-07 sb=5.7e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn36 (\9\:n20 \5\:CKbb net514 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=2.255e-14 ad=4.715e-14 ps=6.3e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.13927e-06 sb=4.15e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn25 (\5\:Db \11\:CKb \9\:n20 VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.715e-14 ad=2.87e-14 ps=8.7e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.41427e-06 sb=1.4e-07 sd=160n sca=9.00745 \
        scb=0.0073653 scc=0.000173562 m=(1)
mn21 (\9\:CKbb \10\:CKb \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.14e-14 ad=2.03e-14 ps=1.37e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1e-07 sd=160n sca=14.7993 scb=0.0157101 \
        scc=0.000964917 m=(1)
mn20 (\12\:CKb \3\:CK \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.85e-14 ad=2.03e-14 ps=1.69e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.24138e-06 sd=160n sca=13.253 \
        scb=0.0137915 scc=0.000695334 m=(1)
mn11 (net522 \4\:D \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=9.85e-14 ad=5.46e-14 ps=1.69e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.73558e-07 sb=7.89712e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn12 (\9\:Db \3\:SEb net522 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=4.2e-14 ps=9.4e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.28558e-07 sb=5.34712e-07 sd=160n sca=10.79 \
        scb=0.0100512 scc=0.000418069 m=(1)
mn14 (\9\:Db \3\:SE net534 VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=1.56e-14 ad=4.2e-14 ps=6.4e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.99135e-07 sb=3.41635e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn13 (net534 \1\:SI \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=1.56e-14 ps=8.4e-07 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.04135e-07 sb=2.36635e-07 sd=160n sca=10.3222 \
        scb=0.00938145 scc=0.000353946 m=(1)
mn10 (\4\:SEb \5\:SE \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.47e-14 ad=2.03e-14 ps=8.4e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24207e-06 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mp45 (\9\:qbint n35 \28\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.76e-14 ad=3.58e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.15484e-07 sd=160n sca=20.3238 \
        scb=0.019357 scc=0.00139603 m=(1)
mp22 (\7\:RNb \1\:RN \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.1305e-13 ad=2.99e-14 ps=1.38e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3907e-07 sb=8.30349e-07 sd=160n sca=23.7894 \
        scb=0.0219499 scc=0.00260958 m=(1)
mp50 (\3\:net394 \1\:SN \26\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.1305e-13 ad=5.3e-14 ps=1.38e-06 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.92339e-07 sb=4.66532e-07 sd=160n sca=19.8394 \
        scb=0.0179302 scc=0.00185493 m=(1)
mp52 (\3\:net394 \5\:qbint net437 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=1.86e-14 ad=5.3e-14 ps=7.4e-07 pd=1.11e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.05403e-07 sb=4e-07 sd=160n sca=12.9031 \
        scb=0.0116454 scc=0.000496931 m=(1)
mp51 (net437 \3\:RNb \24\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.145e-14 ad=1.86e-14 ps=1.21e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.10403e-07 sb=2.95e-07 sd=160n sca=12.9031 \
        scb=0.0116454 scc=0.000496931 m=(1)
mp53 (\4\:n35 \3\:CKbb net394 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.905e-14 ad=5.89e-14 ps=1.13e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.55e-07 sb=4.6e-07 sd=160n sca=29.7112 \
        scb=0.0220652 scc=0.00347629 m=(1)
mp40 (\4\:n35 \3\:CKb \7\:mout VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.975e-14 ad=5.89e-14 ps=1.07e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=2.25e-07 sd=160n sca=29.7112 \
        scb=0.0220652 scc=0.00347629 m=(1)
mp31 (net417 RNb \22\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.4105e-13 ad=5.58e-14 ps=1.72e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=1.62e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp32 (\11\:mout n20 net417 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.58e-14 ad=6.51e-14 ps=9.8e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.2e-07 sb=1.395e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp30 (\11\:mout \5\:SN \20\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1945e-13 ad=6.51e-14 ps=1.55e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=8.75e-07 sb=1.14e-06 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp35 (net425 mout \20\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=1.1945e-13 ad=6.045e-14 ps=1.55e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=7.6e-07 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp36 (\5\:n20 \9\:CKb net425 VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.045e-14 ad=9.455e-14 ps=1.01e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.495e-06 sb=5.2e-07 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp25 (\5\:n20 \7\:CKbb \7\:Db VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=5.27e-14 ad=9.455e-14 ps=9.6e-07 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.845e-06 sb=1.7e-07 sd=160n sca=22.2698 \
        scb=0.0192893 scc=0.0023049 m=(1)
mp21 (\11\:CKbb \5\:CKb \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=5.052e-14 ps=7.5e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=1.6e-07 sd=160n sca=12.7104 \
        scb=0.0116911 scc=0.00042519 m=(1)
mp20 (\18\:CKb \1\:CK \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.04e-06 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp11 (net445 \1\:D \16\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35064e-07 sb=7.25064e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp12 (Db \1\:SE net445 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=2.34e-14 ad=6.24e-14 ps=9e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.40064e-07 sb=6.20064e-07 sd=160n sca=16.7336 \
        scb=0.0149207 scc=0.00128056 m=(1)
mp14 (Db SEb net453 VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=5.265e-14 \
        ad=6.24e-14 ps=1.05e-06 pd=1.1e-06 nrd=1.16667 nrs=1.16667 \
        sa=5.45064e-07 sb=4.15064e-07 sd=160n sca=17.1865 scb=0.0150693 \
        scc=0.0012806 m=(1)
mp13 (net453 \3\:SI \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=5.265e-14 ps=1.1e-06 pd=1.05e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25064e-07 sb=2.35064e-07 sd=160n sca=18.0577 \
        scb=0.0157675 scc=0.00128176 m=(1)
mp10 (\8\:SEb \7\:SE \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.04e-06 sb=1.4e-07 sd=160n sca=14.5503 \
        scb=0.0131195 scc=0.000188015 m=(1)
ends SDFFSRHQX1
// End of subcircuit definition.

// Generated for: spectre (May  9 17:39:03 2012 )
// Library name: gsclib045
// Cell name: SDFFSRHQX2
// View name: extracted

simulator lang=spectre

subckt SDFFSRHQX2 CK D Q RN SE SI SN VDD VSS
mp55_1__rcx (\1\:Q qbint \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.61e-14 ad=6.24e-14 ps=1.08e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.2359e-07 sd=160n sca=34.9044 \
        scb=0.0259128 scc=0.00343869 m=(2)
C1 (D VSS) capacitor c=5.35111e-17
C2 (RN VSS) capacitor c=3.90399e-17
C3 (CK VSS) capacitor c=5.50696e-17
C4 (Q VSS) capacitor c=3.23815e-17
C5 (SE VSS) capacitor c=3.56938e-17
C6 (VDD VSS) capacitor c=4.99583e-16
C7 (SN VSS) capacitor c=3.78508e-16
C8 (SI VSS) capacitor c=9.04718e-17
C9 (qbint VSS) capacitor c=1.44466e-16
C10 (n35 VSS) capacitor c=4.66226e-17
C11 (RNb VSS) capacitor c=4.98983e-17
C12 (net486 VSS) capacitor c=7.69449e-17
C13 (net490 VSS) capacitor c=9.68057e-17
C14 (CKb VSS) capacitor c=3.73585e-17
C15 (mout VSS) capacitor c=4.37042e-17
C16 (CKbb VSS) capacitor c=2.76552e-17
C17 (net469 VSS) capacitor c=6.93202e-17
C18 (n20 VSS) capacitor c=3.33487e-17
C19 (Db VSS) capacitor c=1.25416e-16
C20 (net522 VSS) capacitor c=5.54178e-18
C21 (SEb VSS) capacitor c=4.61749e-17
C22 (net394 VSS) capacitor c=1.1384e-16
C23 (net437 VSS) capacitor c=1.24016e-18
C24 (net417 VSS) capacitor c=2.09234e-18
C25 (net425 VSS) capacitor c=3.37618e-18
C26 (net445 VSS) capacitor c=2.50874e-18
C27 (net453 VSS) capacitor c=4.35364e-18
C28 (\7\:SE VSS) capacitor c=7.02299e-17
C29 (\3\:SI VSS) capacitor c=6.58342e-17
C30 (\1\:SE VSS) capacitor c=7.51431e-17
C31 (\1\:D VSS) capacitor c=9.37569e-17
C32 (\1\:CK VSS) capacitor c=2.95579e-17
C33 (\5\:CKb VSS) capacitor c=3.71758e-17
C34 (\7\:CKbb VSS) capacitor c=4.03601e-17
C35 (\8\:CKb VSS) capacitor c=6.02293e-17
C36 (\5\:SN VSS) capacitor c=7.24693e-17
C37 (\3\:n20 VSS) capacitor c=9.59885e-17
C38 (\2\:RNb VSS) capacitor c=1.73132e-16
C39 (\3\:CKb VSS) capacitor c=3.46517e-17
C40 (\3\:CKbb VSS) capacitor c=4.71695e-17
C41 (\4\:RNb VSS) capacitor c=7.23117e-17
C42 (\8\:qbint VSS) capacitor c=1.3544e-16
C43 (\1\:SN VSS) capacitor c=4.92877e-17
C44 (\1\:RN VSS) capacitor c=3.05489e-17
C45 (\5\:SE VSS) capacitor c=2.55101e-17
C46 (\1\:SI VSS) capacitor c=7.62758e-17
C47 (\3\:SE VSS) capacitor c=7.15827e-17
C48 (\3\:SEb VSS) capacitor c=7.53973e-17
C49 (\4\:D VSS) capacitor c=4.57235e-17
C50 (\4\:CK VSS) capacitor c=3.49109e-17
C51 (\9\:CKb VSS) capacitor c=2.33317e-17
C52 (\10\:CKb VSS) capacitor c=3.31155e-17
C53 (\5\:CKbb VSS) capacitor c=5.01067e-17
C54 (\3\:mout VSS) capacitor c=5.72083e-17
C55 (\4\:SN VSS) capacitor c=5.95604e-17
C56 (\5\:RNb VSS) capacitor c=7.20959e-17
C57 (\10\:qbint VSS) capacitor c=7.48147e-17
C58 (\3\:SN VSS) capacitor c=3.7617e-17
C59 (\3\:RN VSS) capacitor c=2.55983e-17
C60 (\3\:n35 VSS) capacitor c=3.3393e-17
C61 (\6\:SE VSS) capacitor c=4.78737e-17
C62 (\2\:SI VSS) capacitor c=5.04275e-17
C63 (\4\:SE VSS) capacitor c=4.03377e-17
C64 (\2\:SEb VSS) capacitor c=5.24354e-17
C65 (\2\:SE VSS) capacitor c=4.65961e-17
C66 (\3\:D VSS) capacitor c=2.78482e-17
C67 (\3\:CK VSS) capacitor c=3.94158e-17
C68 (\6\:CKb VSS) capacitor c=4.43289e-17
C69 (\8\:CKbb VSS) capacitor c=3.34609e-17
C70 (\6\:CKbb VSS) capacitor c=4.9109e-17
C71 (\2\:mout VSS) capacitor c=4.23976e-17
C72 (\6\:SN VSS) capacitor c=2.13174e-17
C73 (\4\:CKbb VSS) capacitor c=3.08206e-17
C74 (\4\:CKb VSS) capacitor c=3.85184e-17
C75 (\2\:CKb VSS) capacitor c=2.03598e-17
C76 (\3\:RNb VSS) capacitor c=1.03807e-16
C77 (\2\:SN VSS) capacitor c=4.25257e-17
C78 (\2\:RN VSS) capacitor c=2.16591e-17
C79 (\9\:qbint VSS) capacitor c=4.61869e-17
C80 (\2\:n35 VSS) capacitor c=3.36833e-17
C81 (\8\:SEb VSS) capacitor c=2.92202e-17
C82 (\1\:VDD VSS) capacitor c=4.18874e-17
C83 (\16\:VDD VSS) capacitor c=3.52098e-17
C84 (\17\:CKb VSS) capacitor c=5.07312e-17
C85 (\18\:VDD VSS) capacitor c=4.9756e-17
C86 (\13\:CKbb VSS) capacitor c=1.00662e-16
C87 (\8\:Db VSS) capacitor c=7.91119e-17
C88 (\5\:n20 VSS) capacitor c=8.9527e-17
C89 (\20\:VDD VSS) capacitor c=7.24549e-17
C90 (\9\:mout VSS) capacitor c=2.06129e-16
C91 (\22\:VDD VSS) capacitor c=6.35645e-17
C92 (\4\:mout VSS) capacitor c=3.45289e-17
C93 (\4\:n35 VSS) capacitor c=8.2195e-17
C94 (\24\:VDD VSS) capacitor c=5.22689e-17
C95 (\3\:net394 VSS) capacitor c=9.5704e-17
C96 (\26\:VDD VSS) capacitor c=6.57656e-17
C97 (\7\:RNb VSS) capacitor c=1.74524e-16
C98 (\12\:qbint VSS) capacitor c=6.03462e-17
C99 (\1\:Q VSS) capacitor c=7.37479e-17
C100 (\3\:VDD VSS) capacitor c=3.00069e-16
C101 (\4\:SEb VSS) capacitor c=5.97894e-17
C102 (\6\:Db VSS) capacitor c=3.94097e-17
C103 (\11\:CKb VSS) capacitor c=6.95898e-17
C104 (\15\:CKbb VSS) capacitor c=8.47365e-17
C105 (\4\:Db VSS) capacitor c=1.55658e-16
C106 (\9\:n20 VSS) capacitor c=2.07893e-17
C107 (\11\:mout VSS) capacitor c=1.59466e-16
C108 (\3\:net469 VSS) capacitor c=7.24034e-17
C109 (\7\:mout VSS) capacitor c=1.37281e-16
C110 (\8\:n35 VSS) capacitor c=6.63787e-17
C111 (\3\:net490 VSS) capacitor c=9.30665e-17
C112 (\3\:net486 VSS) capacitor c=7.63896e-17
C113 (\9\:RNb VSS) capacitor c=7.68114e-17
C114 (\16\:qbint VSS) capacitor c=7.10045e-17
C115 (\3\:Q VSS) capacitor c=4.51875e-17
C116 (\2\:CKbb VSS) capacitor c=5.68109e-17
C117 (\2\:n20 VSS) capacitor c=6.88238e-17
C118 (\11\:qbint VSS) capacitor c=8.91639e-17
C119 (\14\:qbint VSS) capacitor c=5.16465e-17
C120 (\15\:qbint VSS) capacitor c=5.71687e-17
C121 (\7\:CKb VSS) capacitor c=7.35456e-17
C122 (\4\:RN VSS) capacitor c=8.39025e-17
C123 (\2\:D VSS) capacitor c=2.82032e-17
C124 (\6\:RNb VSS) capacitor c=1.18575e-16
C125 (\6\:n35 VSS) capacitor c=3.18731e-16
C126 (\7\:n35 VSS) capacitor c=2.6377e-16
C127 (\7\:SN VSS) capacitor c=3.2888e-16
C128 (\6\:mout VSS) capacitor c=1.41009e-16
C129 (\13\:mout VSS) capacitor c=9.15823e-17
C130 (\7\:n20 VSS) capacitor c=1.07678e-16
C131 (\8\:n20 VSS) capacitor c=9.02667e-17
C132 (\9\:CKbb VSS) capacitor c=7.01786e-17
C133 (\10\:CKbb VSS) capacitor c=1.31396e-16
C134 (\11\:CKbb VSS) capacitor c=2.86038e-16
C135 (\12\:CKbb VSS) capacitor c=2.00846e-16
C136 (\13\:CKb VSS) capacitor c=8.54484e-17
C137 (\14\:CKb VSS) capacitor c=4.09844e-16
C138 (\15\:CKb VSS) capacitor c=5.68263e-16
C139 (\16\:CKb VSS) capacitor c=1.28466e-16
C140 (\5\:CK VSS) capacitor c=7.60328e-17
C141 (\6\:D VSS) capacitor c=8.9333e-17
C142 (\3\:Db VSS) capacitor c=2.07163e-16
C143 (\4\:SI VSS) capacitor c=4.55403e-17
C144 (\8\:SE VSS) capacitor c=6.79401e-17
C145 (\9\:SE VSS) capacitor c=8.34658e-17
C146 (\10\:SE VSS) capacitor c=5.32949e-17
C147 (\6\:SEb VSS) capacitor c=1.03445e-16
C148 (\7\:SEb VSS) capacitor c=1.14102e-16
C149 (\5\:VDD VSS) capacitor c=1.56847e-17
C150 (\6\:VDD VSS) capacitor c=4.80496e-18
C151 (\8\:VDD VSS) capacitor c=2.29895e-18
C152 (\10\:VDD VSS) capacitor c=2.6876e-17
C153 (\12\:VDD VSS) capacitor c=2.94161e-17
C154 (\14\:VDD VSS) capacitor c=4.52834e-17
C155 (\15\:VDD VSS) capacitor c=1.35109e-16
Rk40 (D \6\:D) resistor r=0.01506 c=0
Rk52 (\2\:VSS \3\:VSS) resistor r=0.1604 c=0
Rk53 (\3\:VSS \4\:VSS) resistor r=0.09016 c=0
Rk54 (\4\:VSS \5\:VSS) resistor r=0.3251 c=0
Rk55 (\5\:VSS \6\:VSS) resistor r=0.2914 c=0
Rk56 (\6\:VSS \7\:VSS) resistor r=0.08168 c=0
Rk57 (\7\:VSS \8\:VSS) resistor r=0.5871 c=0
Rk58 (\8\:VSS \9\:VSS) resistor r=0.2157 c=0
Rk59 (\9\:VSS \10\:VSS) resistor r=0.8032 c=0
Rk60 (\10\:VSS \11\:VSS) resistor r=0.6122 c=0
Rk61 (\11\:VSS \12\:VSS) resistor r=0.2408 c=0
Rk65 (\13\:VSS VSS) resistor r=0.04222 c=0
Rk62 (\12\:VSS \13\:VSS) resistor r=0.2533 c=0
Rk67 (\3\:VSS \18\:VSS) resistor r=0.3135 c=0
Rk68 (\5\:VSS \20\:VSS) resistor r=0.04336 c=0
Rk69 (\6\:VSS \22\:VSS) resistor r=0.04336 c=0
Rk70 (\8\:VSS \24\:VSS) resistor r=0.2353 c=0
Rk71 (\11\:VSS \26\:VSS) resistor r=0.2896 c=0
Rk7 (RN \4\:RN) resistor r=0.03 c=0
Rk37 (\5\:CK CK) resistor r=0.1318 c=0
Rk1 (Q \2\:Q) resistor r=0.04176 c=0
Rk2 (\2\:Q \4\:Q) resistor r=0.4116 c=0
Rk46 (\8\:SE \9\:SE) resistor r=0.3533 c=0
Rk48 (\10\:SE SE) resistor r=0.002533 c=0
Rk47 (\9\:SE \10\:SE) resistor r=0.4083 c=0
Rk74 (\2\:VDD \4\:VDD) resistor r=0.3673 c=0
Rk75 (\4\:VDD \5\:VDD) resistor r=0.2558 c=0
Rk76 (\5\:VDD \6\:VDD) resistor r=0.2255 c=0
Rk77 (\6\:VDD \7\:VDD) resistor r=0.3713 c=0
Rk78 (\7\:VDD \8\:VDD) resistor r=0.3663 c=0
Rk79 (\8\:VDD \9\:VDD) resistor r=0.03494 c=0
Rk80 (\9\:VDD \10\:VDD) resistor r=0.4767 c=0
Rk81 (\10\:VDD \11\:VDD) resistor r=0.1755 c=0
Rk82 (\11\:VDD \12\:VDD) resistor r=0.5921 c=0
Rk83 (\12\:VDD \13\:VDD) resistor r=0.2106 c=0
Rk84 (\13\:VDD \14\:VDD) resistor r=0.1855 c=0
Rk95 (\15\:VDD VDD) resistor r=0.08489 c=0
Rk85 (\14\:VDD \15\:VDD) resistor r=0.3663 c=0
Rk86 (\5\:VDD \17\:VDD) resistor r=0.3505 c=0
Rk87 (\6\:VDD \19\:VDD) resistor r=0.328 c=0
Rk88 (\8\:VDD \21\:VDD) resistor r=0.2948 c=0
Rk89 (\10\:VDD \23\:VDD) resistor r=0.2211 c=0
Rk90 (\12\:VDD \25\:VDD) resistor r=0.2581 c=0
Rk91 (\14\:VDD \27\:VDD) resistor r=0.2746 c=0
Rk16 (\7\:SN SN) resistor r=2.6432 c=0
Rk17 (SN \8\:SN) resistor r=0.004209 c=0
Rk45 (\4\:SI SI) resistor r=0.01946 c=0
Rk3 (\11\:qbint \13\:qbint) resistor r=0.5771 c=0
Rk4 (\13\:qbint \14\:qbint) resistor r=0.1217 c=0
Rk5 (\14\:qbint \15\:qbint) resistor r=0.2952 c=0
Rk6 (\14\:qbint \17\:qbint) resistor r=0.2994 c=0
Rk13 (\5\:n35 \6\:n35) resistor r=0.2007 c=0
Rk14 (\6\:n35 \7\:n35) resistor r=2.1192 c=0
Rk15 (\6\:n35 \9\:n35) resistor r=0.1633 c=0
Rk8 (\6\:RNb \8\:RNb) resistor r=0.9689 c=0
Rk9 (\8\:RNb \10\:RNb) resistor r=0.4667 c=0
Rk10 (\2\:net486 \4\:net486) resistor r=0.3696 c=0
Rk11 (\2\:net490 \4\:net490) resistor r=0.3932 c=0
Rk32 (\12\:CKb \13\:CKb) resistor r=0.3743 c=0
Rk33 (\13\:CKb \14\:CKb) resistor r=0.2517 c=0
Rk34 (\14\:CKb \15\:CKb) resistor r=3.2991 c=0
Rk35 (\15\:CKb \16\:CKb) resistor r=0.8595 c=0
Rk36 (\14\:CKb \18\:CKb) resistor r=0.2665 c=0
Rk19 (\5\:mout \6\:mout) resistor r=0.08716 c=0
Rk20 (\6\:mout \8\:mout) resistor r=0.3071 c=0
Rk21 (\6\:mout \10\:mout) resistor r=1.0086 c=0
Rk22 (\8\:mout \12\:mout) resistor r=0.9249 c=0
Rk23 (\10\:mout \13\:mout) resistor r=0.4058 c=0
Rk27 (\9\:CKbb \10\:CKbb) resistor r=0.2888 c=0
Rk28 (\10\:CKbb \11\:CKbb) resistor r=0.6598 c=0
Rk29 (\11\:CKbb \12\:CKbb) resistor r=1.5701 c=0
Rk30 (\10\:CKbb \14\:CKbb) resistor r=0.3783 c=0
Rk31 (\14\:CKbb \16\:CKbb) resistor r=0.4604 c=0
Rk18 (\2\:net469 \4\:net469) resistor r=0.3107 c=0
Rk24 (\6\:n20 \7\:n20) resistor r=0.4725 c=0
Rk25 (\7\:n20 \8\:n20) resistor r=0.5302 c=0
Rk26 (\7\:n20 \10\:n20) resistor r=0.06524 c=0
Rk41 (\2\:Db \3\:Db) resistor r=0.7223 c=0
Rk42 (\3\:Db \5\:Db) resistor r=0.9743 c=0
Rk43 (\3\:Db \7\:Db) resistor r=0.2007 c=0
Rk44 (\5\:Db \9\:Db) resistor r=0.5353 c=0
Rk49 (\5\:SEb \6\:SEb) resistor r=0.5142 c=0
Rk50 (\6\:SEb \7\:SEb) resistor r=0.7687 c=0
Rk51 (\6\:SEb \9\:SEb) resistor r=0.4158 c=0
Rk12 (\2\:net394 \4\:net394) resistor r=0.5841 c=0
Rl41 (\1\:D \2\:D) resistor r=108.849 c=0
Rl43 (\2\:D \4\:D) resistor r=47.3105 c=0
Rl42 (\2\:D \3\:D) resistor r=46.5271 c=0
Rl9 (\1\:RN \2\:RN) resistor r=31.9251 c=0
Rl10 (\2\:RN \3\:RN) resistor r=64.6174 c=0
Rl38 (\1\:CK \2\:CK) resistor r=82.4108 c=0
