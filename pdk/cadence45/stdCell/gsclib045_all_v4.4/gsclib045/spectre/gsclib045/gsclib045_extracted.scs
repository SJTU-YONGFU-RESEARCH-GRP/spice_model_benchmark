mp45 (\16\:qbint n30 \24\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=6.11e-14 ad=4.34e-14 ps=1.1e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.41774e-06 sd=160n sca=24.2842 \
        scb=0.0202139 scc=0.00265344 m=(1)
mp50 (net411 \7\:qbint \24\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.11e-14 ad=1.72e-14 ps=1.1e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=2e-06 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp51 (\8\:n30 \5\:CKbb net411 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=3.44e-14 ps=5.9e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1.895e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\8\:n30 \3\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=3.44e-14 ps=1.06e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.69e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp35 (net427 \3\:mout \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=1.29e-14 ps=1.64e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.38e-06 sb=1.065e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp30 (\8\:mout \3\:n20 \22\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.35e-14 ad=6.773e-14 ps=1.64e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.115e-06 sb=1.33e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp36 (\5\:n20 \5\:CKb net427 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.558e-14 ps=5.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.485e-06 sb=9.6e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp26 (\5\:n20 CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=6.558e-14 ps=7.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.835e-06 sb=6.1e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp25 (n22 Dp \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=3.44e-14 ps=1.64e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.05e-07 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp21 (\6\:CKbb \11\:CKb \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.35e-14 ad=3.01e-14 ps=1.64e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp2 (\6\:RNb \1\:RN \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.65e-14 ad=4.085e-14 ps=1.69e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=8.15e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp3 (\3\:n2 \3\:RNb \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.65e-14 ad=3.44e-14 ps=1.69e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=5.5e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp5 (n3 \11\:qbint \3\:n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.6e-07 sb=3.45e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp4 (n3 Eb n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.01e-14 \
        ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.65e-07 sb=1.4e-07 sd=160n sca=17.4145 scb=0.0172865 \
        scc=0.00131682 m=(1)
mp6 (\11\:Dp \3\:E \3\:n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.6e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp7 (\13\:Dp \2\:Db \3\:n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.225e-14 ps=7.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.5e-07 sd=160n sca=17.4145 \
        scb=0.0172865 scc=0.00131682 m=(1)
mp0 (\4\:Eb \4\:E \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.25e-07 sd=160n sca=47.8367 \
        scb=0.030096 scc=0.00588989 m=(1)
mp1 (\4\:Db \1\:D \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.44e-14 ps=1.62e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.6e-07 sd=160n sca=55.1271 \
        scb=0.0420653 scc=0.00650135 m=(1)
ends EDFFTRX1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:47:12 2012 )
// Library name: gsclib045
// Cell name: EDFFTRX2
// View name: extracted

simulator lang=spectre

subckt EDFFTRX2 CK D E Q QN RN VDD VSS
mp1 (\5\:Db \1\:D \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.091e-13 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=47.4597 \
        scb=0.0295856 scc=0.00588691 m=(1)
C1 (D VSS) capacitor c=8.3062e-17
C2 (CK VSS) capacitor c=4.73508e-17
C3 (Q VSS) capacitor c=3.88345e-17
C4 (QN VSS) capacitor c=5.90222e-17
C5 (RN VSS) capacitor c=5.5197e-17
C6 (VDD VSS) capacitor c=5.45836e-16
C7 (E VSS) capacitor c=2.08826e-17
C8 (Db VSS) capacitor c=3.50687e-17
C9 (Eb VSS) capacitor c=6.07143e-17
C10 (n1 VSS) capacitor c=6.36914e-19
C11 (Dp VSS) capacitor c=6.16303e-17
C12 (qbint VSS) capacitor c=3.21573e-17
C13 (RNb VSS) capacitor c=5.22063e-17
C14 (CKb VSS) capacitor c=5.49771e-17
C15 (CKbb VSS) capacitor c=5.19335e-17
C16 (n21 VSS) capacitor c=1.756e-18
C17 (n20 VSS) capacitor c=3.71748e-17
C18 (net516 VSS) capacitor c=3.35896e-18
C19 (mout VSS) capacitor c=7.62358e-17
C20 (n30 VSS) capacitor c=5.39339e-17
C21 (net496 VSS) capacitor c=5.58966e-19
C22 (qint VSS) capacitor c=1.9697e-16
C23 (n3 VSS) capacitor c=7.38311e-17
C24 (n2 VSS) capacitor c=6.52162e-17
C25 (n22 VSS) capacitor c=4.23483e-18
C26 (net427 VSS) capacitor c=1.65611e-18
C27 (net411 VSS) capacitor c=4.16996e-18
C28 (\13\:qbint VSS) capacitor c=3.94432e-17
C29 (\3\:CK VSS) capacitor c=2.97089e-17
C30 (\4\:qbint VSS) capacitor c=4.91039e-17
C31 (\4\:CKbb VSS) capacitor c=3.81168e-17
C32 (\8\:CKb VSS) capacitor c=3.56074e-17
C33 (\6\:CKb VSS) capacitor c=6.06815e-17
C34 (\3\:CKbb VSS) capacitor c=2.16809e-17
C35 (\1\:RN VSS) capacitor c=3.47638e-17
C36 (\2\:qbint VSS) capacitor c=6.36022e-17
C37 (\4\:E VSS) capacitor c=3.89393e-17
C38 (\1\:E VSS) capacitor c=3.49381e-17
C39 (\1\:D VSS) capacitor c=4.02375e-17
C40 (\14\:qbint VSS) capacitor c=4.93992e-17
C41 (\7\:qbint VSS) capacitor c=1.84096e-16
C42 (\1\:CK VSS) capacitor c=3.92497e-17
C43 (\4\:n30 VSS) capacitor c=4.0481e-17
C44 (\6\:qbint VSS) capacitor c=7.97029e-17
C45 (\10\:CKb VSS) capacitor c=6.33444e-17
C46 (\6\:CKbb VSS) capacitor c=3.90153e-17
C47 (\3\:n20 VSS) capacitor c=3.63376e-17
C48 (\3\:mout VSS) capacitor c=2.82691e-17
C49 (\4\:CKb VSS) capacitor c=4.23382e-17
C50 (\2\:Dp VSS) capacitor c=5.30791e-17
C51 (\3\:CKb VSS) capacitor c=2.9607e-17
C52 (\3\:RN VSS) capacitor c=4.29251e-17
C53 (\3\:RNb VSS) capacitor c=3.32957e-17
C54 (\3\:qbint VSS) capacitor c=9.10086e-17
C55 (\2\:Eb VSS) capacitor c=4.82245e-17
C56 (\6\:E VSS) capacitor c=4.46755e-17
C57 (\3\:Db VSS) capacitor c=6.57899e-17
C58 (\3\:E VSS) capacitor c=3.26316e-17
C59 (\3\:D VSS) capacitor c=3.01782e-17
C60 (\15\:qbint VSS) capacitor c=2.51146e-17
C61 (\2\:CK VSS) capacitor c=3.97538e-17
C62 (\3\:n30 VSS) capacitor c=1.93209e-17
C63 (\5\:qbint VSS) capacitor c=2.65295e-17
C64 (\5\:CKbb VSS) capacitor c=4.86955e-17
C65 (\11\:CKb VSS) capacitor c=2.95841e-17
C66 (\9\:CKb VSS) capacitor c=2.22561e-17
C67 (\2\:n20 VSS) capacitor c=3.48392e-17
C68 (\2\:mout VSS) capacitor c=4.8735e-17
C69 (\7\:CKb VSS) capacitor c=5.58244e-17
C70 (\2\:CKbb VSS) capacitor c=4.73196e-17
C71 (\5\:CKb VSS) capacitor c=3.92977e-17
C72 (\3\:Dp VSS) capacitor c=2.13009e-17
C73 (\2\:CKb VSS) capacitor c=4.1661e-17
C74 (\2\:RN VSS) capacitor c=3.93387e-17
C75 (\2\:RNb VSS) capacitor c=4.78769e-17
C76 (\3\:Eb VSS) capacitor c=2.7071e-17
C77 (\5\:E VSS) capacitor c=3.46594e-17
C78 (\2\:Db VSS) capacitor c=2.31651e-17
C79 (\2\:E VSS) capacitor c=3.42381e-17
C80 (\2\:D VSS) capacitor c=3.03362e-17
C81 (\8\:qint VSS) capacitor c=2.7546e-17
C82 (\3\:QN VSS) capacitor c=7.06298e-18
C83 (\2\:Q VSS) capacitor c=5.37664e-17
C84 (\19\:CKb VSS) capacitor c=1.01267e-16
C85 (\18\:qbint VSS) capacitor c=5.6345e-17
C86 (\14\:VDD VSS) capacitor c=8.11002e-17
C87 (\7\:n30 VSS) capacitor c=7.25005e-17
C88 (\8\:mout VSS) capacitor c=5.64365e-17
C89 (\18\:VDD VSS) capacitor c=2.53547e-17
C90 (\7\:n20 VSS) capacitor c=3.31274e-17
C91 (\21\:VDD VSS) capacitor c=1.598e-17
C92 (\11\:CKbb VSS) capacitor c=1.50565e-17
C93 (\4\:RNb VSS) capacitor c=4.90708e-17
C94 (\25\:VDD VSS) capacitor c=1.71369e-17
C95 (\3\:n2 VSS) capacitor c=7.608e-17
C96 (\12\:Dp VSS) capacitor c=4.08922e-17
C97 (\3\:n3 VSS) capacitor c=7.83017e-17
C98 (\9\:Dp VSS) capacitor c=5.84928e-17
C99 (\7\:Eb VSS) capacitor c=7.8006e-17
C100 (\30\:VDD VSS) capacitor c=1.82979e-17
C101 (\5\:Db VSS) capacitor c=1.54429e-16
C102 (\1\:VDD VSS) capacitor c=2.27656e-16
C103 (\12\:qint VSS) capacitor c=1.12522e-17
C104 (\1\:QN VSS) capacitor c=4.01492e-17
C105 (\4\:Q VSS) capacitor c=2.80852e-17
C106 (\23\:CKb VSS) capacitor c=2.92959e-17
C107 (\23\:qbint VSS) capacitor c=6.72219e-17
C108 (\9\:n30 VSS) capacitor c=2.53692e-17
C109 (\4\:mout VSS) capacitor c=4.60623e-17
C110 (\4\:n20 VSS) capacitor c=7.69204e-17
C111 (\7\:CKbb VSS) capacitor c=5.12713e-17
C112 (\8\:RNb VSS) capacitor c=3.82224e-17
C113 (\4\:Dp VSS) capacitor c=2.01743e-16
C114 (\7\:Dp VSS) capacitor c=8.46914e-17
C115 (\5\:Eb VSS) capacitor c=1.48107e-16
C116 (\7\:Db VSS) capacitor c=1.01024e-16
C117 (\4\:D VSS) capacitor c=3.0291e-17
C118 (\2\:n30 VSS) capacitor c=1.57173e-17
C119 (\4\:Db VSS) capacitor c=9.82778e-17
C120 (\7\:E VSS) capacitor c=1.22706e-16
C121 (\8\:E VSS) capacitor c=1.21217e-16
C122 (\9\:E VSS) capacitor c=3.4841e-17
C123 (\4\:Eb VSS) capacitor c=1.38163e-16
C124 (\4\:RN VSS) capacitor c=4.40359e-17
C125 (\6\:RNb VSS) capacitor c=5.66121e-17
C126 (\7\:RNb VSS) capacitor c=4.57969e-17
C127 (\6\:Dp VSS) capacitor c=1.16065e-16
C128 (\11\:Dp VSS) capacitor c=1.41159e-16
C129 (\6\:n20 VSS) capacitor c=6.87049e-17
C130 (\9\:n20 VSS) capacitor c=6.3162e-17
C131 (\6\:mout VSS) capacitor c=6.70061e-17
C132 (\7\:mout VSS) capacitor c=5.67005e-17
C133 (\9\:CKbb VSS) capacitor c=7.79135e-17
C134 (\10\:CKbb VSS) capacitor c=2.41618e-16
C135 (\13\:CKbb VSS) capacitor c=2.45149e-16
C136 (\5\:n30 VSS) capacitor c=6.62953e-17
C137 (\6\:n30 VSS) capacitor c=8.70078e-17
C138 (\12\:CKb VSS) capacitor c=2.7553e-17
C139 (\13\:CKb VSS) capacitor c=8.41622e-17
C140 (\14\:CKb VSS) capacitor c=1.24271e-16
C141 (\15\:CKb VSS) capacitor c=1.4788e-16
C142 (\16\:CKb VSS) capacitor c=9.44538e-17
C143 (\17\:CKb VSS) capacitor c=4.03339e-17
C144 (\18\:CKb VSS) capacitor c=8.7998e-17
C145 (\21\:CKb VSS) capacitor c=8.30856e-17
C146 (\22\:CKb VSS) capacitor c=4.15408e-17
C147 (\4\:CK VSS) capacitor c=8.17416e-17
C148 (\1\:Q VSS) capacitor c=4.35778e-17
C149 (\16\:qbint VSS) capacitor c=8.83945e-17
C150 (\17\:qbint VSS) capacitor c=1.27288e-16
C151 (\20\:qbint VSS) capacitor c=9.45415e-17
C152 (\21\:qbint VSS) capacitor c=3.7812e-16
C153 (\22\:qbint VSS) capacitor c=9.19548e-17
C154 (\25\:qbint VSS) capacitor c=2.40157e-16
C155 (\10\:qint VSS) capacitor c=2.11133e-17
C156 (\11\:qint VSS) capacitor c=2.25049e-17
C157 (\3\:VDD VSS) capacitor c=7.91979e-17
C158 (\13\:VDD VSS) capacitor c=2.9251e-17
C159 (\17\:VDD VSS) capacitor c=2.89554e-17
C160 (\29\:VDD VSS) capacitor c=1.79588e-17
Rk1 (\4\:D D) resistor r=0.1009 c=0
Rk43 (\4\:CK CK) resistor r=0.08837 c=0
Rk44 (Q \1\:Q) resistor r=0.07065 c=0
Rk45 (\1\:Q \3\:Q) resistor r=0.1486 c=0
Rk46 (\1\:Q \5\:Q) resistor r=0.1584 c=0
Rk84 (\1\:VSS \7\:VSS) resistor r=0.3773 c=0
Rk85 (\7\:VSS \8\:VSS) resistor r=0.1543 c=0
Rk86 (\8\:VSS \9\:VSS) resistor r=0.4361 c=0
Rk87 (\9\:VSS \10\:VSS) resistor r=0.5312 c=0
Rk88 (\10\:VSS \11\:VSS) resistor r=0.2355 c=0
Rk89 (\11\:VSS \12\:VSS) resistor r=0.2305 c=0
Rk90 (\12\:VSS \13\:VSS) resistor r=0.3657 c=0
Rk91 (\13\:VSS \14\:VSS) resistor r=0.1475 c=0
Rk92 (\14\:VSS \15\:VSS) resistor r=0.3082 c=0
Rk94 (\16\:VSS VSS) resistor r=0.2804 c=0
Rk93 (\15\:VSS \16\:VSS) resistor r=0.1202 c=0
Rk97 (\7\:VSS \22\:VSS) resistor r=0.0433 c=0
Rk98 (\9\:VSS \24\:VSS) resistor r=0.2424 c=0
Rk99 (\10\:VSS \26\:VSS) resistor r=0.1225 c=0
Rk100 (\12\:VSS \28\:VSS) resistor r=0.1632 c=0
Rk101 (\13\:VSS \30\:VSS) resistor r=0.193 c=0
Rk102 (\14\:VSS \32\:VSS) resistor r=0.1739 c=0
Rk103 (\16\:VSS \34\:VSS) resistor r=0.2811 c=0
Rk47 (\2\:QN QN) resistor r=0.2696 c=0
Rk48 (QN \4\:QN) resistor r=0.005786 c=0
Rk11 (RN \4\:RN) resistor r=0.141 c=0
Rk59 (\2\:VDD \3\:VDD) resistor r=0.1051 c=0
Rk65 (\3\:VDD \12\:VDD) resistor r=0.1252 c=0
Rk66 (\12\:VDD \13\:VDD) resistor r=0.2455 c=0
Rk67 (\13\:VDD \15\:VDD) resistor r=0.3763 c=0
Rk68 (\13\:VDD \16\:VDD) resistor r=0.4562 c=0
Rk69 (\16\:VDD \17\:VDD) resistor r=0.1192 c=0
Rk70 (\17\:VDD \19\:VDD) resistor r=0.0433 c=0
Rk71 (\17\:VDD \20\:VDD) resistor r=0.5304 c=0
Rk72 (\20\:VDD \22\:VDD) resistor r=0.1201 c=0
Rk73 (\20\:VDD \23\:VDD) resistor r=0.2513 c=0
Rk74 (\23\:VDD \24\:VDD) resistor r=0.1803 c=0
Rk75 (\24\:VDD \26\:VDD) resistor r=0.07381 c=0
Rk76 (\24\:VDD \27\:VDD) resistor r=0.07001 c=0
Rk77 (\27\:VDD \28\:VDD) resistor r=0.6519 c=0
Rk80 (\29\:VDD VDD) resistor r=0.2945 c=0
Rk78 (\28\:VDD \29\:VDD) resistor r=0.2546 c=0
Rk79 (\29\:VDD \31\:VDD) resistor r=0.0433 c=0
Rk5 (\8\:E E) resistor r=0.003075 c=0
Rk4 (\7\:E \8\:E) resistor r=0.8144 c=0
Rk6 (\8\:E \9\:E) resistor r=0.199 c=0
Rk2 (\4\:Db \6\:Db) resistor r=0.738 c=0
Rk3 (\6\:Db \8\:Db) resistor r=0.8318 c=0
Rk7 (\4\:Eb \6\:Eb) resistor r=1.0163 c=0
Rk8 (\6\:Eb \8\:Eb) resistor r=0.3423 c=0
Rk15 (\5\:Dp \6\:Dp) resistor r=0.5923 c=0
Rk16 (\6\:Dp \8\:Dp) resistor r=0.4251 c=0
Rk17 (\8\:Dp \10\:Dp) resistor r=0.2574 c=0
Rk18 (\5\:Dp \11\:Dp) resistor r=1.1713 c=0
Rk19 (\6\:Dp \13\:Dp) resistor r=0.198 c=0
Rk49 (\16\:qbint \17\:qbint) resistor r=0.7471 c=0
Rk50 (\17\:qbint \19\:qbint) resistor r=0.4259 c=0
Rk51 (\19\:qbint \20\:qbint) resistor r=0.2321 c=0
Rk52 (\20\:qbint \21\:qbint) resistor r=0.508 c=0
Rk53 (\17\:qbint \22\:qbint) resistor r=0.345 c=0
Rk54 (\20\:qbint \24\:qbint) resistor r=0.2945 c=0
Rk55 (\21\:qbint \25\:qbint) resistor r=2.2653 c=0
Rk12 (\5\:RNb \6\:RNb) resistor r=0.2592 c=0
Rk13 (\6\:RNb \7\:RNb) resistor r=0.2581 c=0
Rk14 (\6\:RNb \9\:RNb) resistor r=0.125 c=0
Rk33 (\12\:CKb \13\:CKb) resistor r=0.06796 c=0
Rk34 (\13\:CKb \14\:CKb) resistor r=0.2633 c=0
Rk35 (\14\:CKb \15\:CKb) resistor r=0.6951 c=0
Rk36 (\15\:CKb \16\:CKb) resistor r=0.7289 c=0
Rk37 (\16\:CKb \17\:CKb) resistor r=0.2224 c=0
Rk38 (\13\:CKb \18\:CKb) resistor r=0.5879 c=0
Rk39 (\18\:CKb \20\:CKb) resistor r=0.457 c=0
Rk40 (\14\:CKb \21\:CKb) resistor r=0.372 c=0
Rk41 (\15\:CKb \22\:CKb) resistor r=0.1884 c=0
Rk42 (\18\:CKb \24\:CKb) resistor r=0.04879 c=0
Rk26 (\8\:CKbb \9\:CKbb) resistor r=0.3813 c=0
Rk27 (\9\:CKbb \10\:CKbb) resistor r=0.4399 c=0
Rk28 (\9\:CKbb \12\:CKbb) resistor r=0.1224 c=0
Rk29 (\10\:CKbb \13\:CKbb) resistor r=1.6181 c=0
Rk20 (\5\:n20 \6\:n20) resistor r=0.3743 c=0
Rk21 (\6\:n20 \8\:n20) resistor r=0.04277 c=0
Rk22 (\6\:n20 \9\:n20) resistor r=0.3528 c=0
Rk23 (\5\:mout \6\:mout) resistor r=0.1766 c=0
Rk24 (\6\:mout \7\:mout) resistor r=0.2948 c=0
Rk25 (\6\:mout \9\:mout) resistor r=0.2219 c=0
Rk30 (\5\:n30 \6\:n30) resistor r=0.3819 c=0
Rk31 (\6\:n30 \8\:n30) resistor r=0.3835 c=0
Rk32 (\6\:n30 \10\:n30) resistor r=0.07121 c=0
Rk56 (\9\:qint \10\:qint) resistor r=0.1943 c=0
Rk57 (\10\:qint \11\:qint) resistor r=0.1513 c=0
Rk58 (\10\:qint \13\:qint) resistor r=0.1342 c=0
Rk9 (\2\:n3 \4\:n3) resistor r=0.5725 c=0
Rk10 (\2\:n2 \4\:n2) resistor r=0.3322 c=0
Rl1 (\1\:D \2\:D) resistor r=79.5379 c=0
Rl2 (\2\:D \3\:D) resistor r=39.1533 c=0
Rl39 (\2\:CK \3\:CK) resistor r=29.9451 c=0
Rl38 (\1\:CK \2\:CK) resistor r=115.385 c=0
Rl15 (\1\:RN \2\:RN) resistor r=26.9231 c=0
Rl16 (\2\:RN \3\:RN) resistor r=100.795 c=0
Rl7 (\4\:E \5\:E) resistor r=90.6605 c=0
Rl8 (\5\:E \6\:E) resistor r=39.6174 c=0
Rl3 (\1\:E \2\:E) resistor r=35.3066 c=0
Rl4 (\2\:E \3\:E) resistor r=84.4104 c=0
Rl6 (Db \3\:Db) resistor r=92.3077 c=0
Rl5 (Db \2\:Db) resistor r=50.6918 c=0
Rl9 (Eb \2\:Eb) resistor r=151.923 c=0
Rl10 (\2\:Eb \3\:Eb) resistor r=24.2328 c=0
Rl19 (Dp \2\:Dp) resistor r=151.923 c=0
Rl20 (\2\:Dp \3\:Dp) resistor r=25.2509 c=0
Rl11 (qbint \2\:qbint) resistor r=102.252 c=0
Rl51 (\14\:qbint \13\:qbint) resistor r=130.769 c=0
Rl34 (\6\:qbint \4\:qbint) resistor r=151.923 c=0
Rl12 (\3\:qbint \2\:qbint) resistor r=172.643 c=0
Rl52 (\15\:qbint \13\:qbint) resistor r=37.6504 c=0
Rl33 (\5\:qbint \4\:qbint) resistor r=29.5379 c=0
Rl13 (RNb \2\:RNb) resistor r=82.4874 c=0
Rl14 (\2\:RNb \3\:RNb) resistor r=42.2849 c=0
Rl32 (\10\:CKb \11\:CKb) resistor r=89.6174 c=0
Rl29 (\8\:CKb \9\:CKb) resistor r=33.8482 c=0
Rl24 (\6\:CKb \7\:CKb) resistor r=66.5405 c=0
Rl21 (\4\:CKb \5\:CKb) resistor r=86.0515 c=0
Rl17 (CKb \2\:CKb) resistor r=89.6174 c=0
Rl18 (\2\:CKb \3\:CKb) resistor r=68.7849 c=0
Rl30 (\4\:CKbb \5\:CKbb) resistor r=49.2328 c=0
Rl31 (\5\:CKbb \6\:CKbb) resistor r=114.939 c=0
Rl22 (CKbb \2\:CKbb) resistor r=157.246 c=0
Rl23 (\2\:CKbb \3\:CKbb) resistor r=24.2328 c=0
Rl27 (n20 \2\:n20) resistor r=24.2328 c=0
Rl28 (\2\:n20 \3\:n20) resistor r=99.2328 c=0
Rl25 (mout \2\:mout) resistor r=93.4057 c=0
Rl26 (\2\:mout \3\:mout) resistor r=26.098 c=0
Rl35 (n30 \2\:n30) resistor r=78.5603 c=0
Rl37 (\2\:n30 \4\:n30) resistor r=43.9449 c=0
Rl36 (\2\:n30 \3\:n30) resistor r=2.7666 c=0
Rz11 (\5\:Q \4\:Q) resistor r=75 c=0
Rz26 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz27 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz28 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz29 (\28\:VSS \27\:VSS) resistor r=75 c=0
Rz30 (\30\:VSS \29\:VSS) resistor r=75 c=0
Rz31 (\32\:VSS \31\:VSS) resistor r=75 c=0
Rz32 (\34\:VSS \33\:VSS) resistor r=75 c=0
Rz12 (\2\:QN \1\:QN) resistor r=75 c=0
Rz15 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz16 (\3\:VDD \1\:VDD) resistor r=15 c=0
Rz17 (\12\:VDD \1\:VDD) resistor r=37.5 c=0
Rz18 (\16\:VDD \1\:VDD) resistor r=6.25 c=0
Rz19 (\20\:VDD \1\:VDD) resistor r=75 c=0
Rz20 (\23\:VDD \1\:VDD) resistor r=18.75 c=0
Rz21 (\27\:VDD \1\:VDD) resistor r=75 c=0
Rz22 (\28\:VDD \1\:VDD) resistor r=6.25 c=0
Rz1 (\7\:Db \8\:Db) resistor r=75 c=0
Rz2 (\5\:Eb \6\:Eb) resistor r=75 c=0
Rz4 (\4\:Dp \5\:Dp) resistor r=75 c=0
Rz5 (\7\:Dp \8\:Dp) resistor r=75 c=0
Rz13 (\24\:qbint \23\:qbint) resistor r=75 c=0
Rz3 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz10 (\23\:CKb \24\:CKb) resistor r=75 c=0
Rz8 (\7\:CKbb \8\:CKbb) resistor r=75 c=0
Rz6 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz7 (\4\:mout \5\:mout) resistor r=75 c=0
Rz9 (\9\:n30 \10\:n30) resistor r=75 c=0
Rz14 (\13\:qint \12\:qint) resistor r=75 c=0
Ry15 (\3\:Q \2\:Q) resistor r=62 c=0
Ry27 (\1\:VSS \3\:VSS) resistor r=10.3333 c=0
Ry28 (\8\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry29 (\11\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry30 (\15\:VSS \3\:VSS) resistor r=6.8889 c=0
Ry16 (\4\:QN \3\:QN) resistor r=62 c=0
Ry22 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry23 (\19\:VDD \18\:VDD) resistor r=62 c=0
Ry24 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry25 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry26 (\31\:VDD \30\:VDD) resistor r=62 c=0
Ry1 (\5\:Db \6\:Db) resistor r=62 c=0
Ry2 (\7\:Eb \8\:Eb) resistor r=62 c=0
Ry8 (\9\:Dp \10\:Dp) resistor r=62 c=0
Ry9 (\12\:Dp \13\:Dp) resistor r=62 c=0
Ry17 (\19\:qbint \18\:qbint) resistor r=62 c=0
Ry7 (\4\:RNb \5\:RNb) resistor r=62 c=0
Ry14 (\19\:CKb \20\:CKb) resistor r=62 c=0
Ry12 (\11\:CKbb \12\:CKbb) resistor r=62 c=0
Ry10 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry11 (\8\:mout \9\:mout) resistor r=62 c=0
Ry13 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry18 (\9\:qint \8\:qint) resistor r=62 c=0
Ry3 (n3 \2\:n3) resistor r=62 c=0
Ry4 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry5 (n2 \2\:n2) resistor r=62 c=0
Ry6 (\3\:n2 \4\:n2) resistor r=62 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx19 (\2\:CK \4\:CK) resistor r=45 c=0
Rx6 (\2\:RN \4\:RN) resistor r=45 c=0
Rx3 (\5\:E \7\:E) resistor r=45 c=0
Rx4 (\2\:E \9\:E) resistor r=45 c=0
Rx2 (\2\:Db \4\:Db) resistor r=45 c=0
Rx5 (\3\:Eb \4\:Eb) resistor r=45 c=0
Rx8 (\3\:Dp \11\:Dp) resistor r=45 c=0
Rx20 (\16\:qbint \15\:qbint) resistor r=45 c=0
Rx21 (\21\:qbint \5\:qbint) resistor r=45 c=0
Rx22 (\22\:qbint \7\:qbint) resistor r=22.5 c=0
Rx23 (\25\:qbint qbint) resistor r=45 c=0
Rx7 (\2\:RNb \7\:RNb) resistor r=45 c=0
Rx14 (\11\:CKb \12\:CKb) resistor r=45 c=0
Rx15 (\5\:CKb \16\:CKb) resistor r=45 c=0
Rx16 (\2\:CKb \17\:CKb) resistor r=45 c=0
Rx17 (\9\:CKb \21\:CKb) resistor r=45 c=0
Rx18 (\7\:CKb \22\:CKb) resistor r=45 c=0
Rx11 (\2\:CKbb \10\:CKbb) resistor r=45 c=0
Rx12 (\5\:CKbb \13\:CKbb) resistor r=45 c=0
Rx9 (\2\:n20 \9\:n20) resistor r=45 c=0
Rx10 (\2\:mout \7\:mout) resistor r=45 c=0
Rx13 (\3\:n30 \5\:n30) resistor r=45 c=0
Rx24 (\11\:qint qint) resistor r=45 c=0
mn1 (\7\:Db \3\:D \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn0 (\5\:Eb \3\:E \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.465e-14 ps=6.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.7e-07 sd=160n sca=10.4914 \
        scb=0.00978575 scc=0.000300434 m=(1)
mn7 (\7\:Dp \3\:Db n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.75e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn6 (n1 \6\:E \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.885e-14 ad=8.7e-15 ps=1.2e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.7e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn4 (n0 \2\:Eb \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.597e-14 ad=8.7e-15 ps=1.1e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.95e-07 sb=8e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn5 (\4\:Dp \3\:qbint n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=6.95e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn3 (\4\:Dp \3\:RNb \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=2.32e-14 ps=1.05e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=4.9e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\8\:RNb \3\:RN \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.11e-14 ad=3.262e-14 ps=1.05e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.7e-07 sb=2.25e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn21 (\7\:CKbb \3\:CKb \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.37e-14 ad=4.132e-14 ps=1.41e-06 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=2e-06 sd=160n sca=15.7071 scb=0.0167369 \
        scc=0.00113434 m=(1)
mn25 (n21 \2\:Dp \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.37e-14 ad=4.06e-14 ps=1.41e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.9e-07 sb=2e-06 sd=160n sca=15.7071 scb=0.0167369 \
        scc=0.00113434 m=(1)
mn26 (\4\:n20 \4\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.06e-14 ad=2.32e-14 ps=8.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.15e-07 sb=2e-06 sd=160n sca=15.7071 scb=0.0167369 \
        scc=0.00113434 m=(1)
mn36 (\4\:n20 CKbb net516 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.48e-14 ad=2.32e-14 ps=7.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.12e-06 sb=1.86e-06 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn35 (net516 \3\:mout \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.69e-14 ad=3.48e-14 ps=9.8e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.405e-06 sb=1.575e-06 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn30 (\4\:mout \3\:n20 \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.69e-14 ad=7.54e-14 ps=9.8e-07 pd=1.33e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.67e-06 sb=1.31e-06 sd=160n sca=15.7071 \
        scb=0.0167369 scc=0.00113434 m=(1)
mn40 (\9\:n30 \6\:CKbb \4\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.54e-14 ad=2.32e-14 ps=1.33e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.45e-07 sd=160n sca=15.7071 scb=0.0167369 \
        scc=0.00113434 m=(1)
mn51 (\9\:n30 \10\:CKb net496 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=2.32e-14 ps=4.3e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.4e-07 sd=160n sca=15.7071 scb=0.0167369 \
        scc=0.00113434 m=(1)
mn50 (net496 \6\:qbint \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.6e-14 ad=1.015e-14 ps=1.6e-06 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.25e-07 sd=160n sca=15.7071 scb=0.0167369 \
        scc=0.00113434 m=(1)
mn45 (\23\:qbint \4\:n30 \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.6e-14 ad=4.16e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.17577e-06 sb=1.6e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn20 (\23\:CKb \1\:CK \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.687e-14 ad=2.03e-14 ps=8.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.06793e-06 sd=160n sca=12.2839 \
        scb=0.0124725 scc=0.000542081 m=(1)
mn55_1__rcx (\4\:Q \7\:qbint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.924e-14 ad=4.68e-14 ps=8.55e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=9.06058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn57 (\1\:QN qint \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.262e-14 ad=4.16e-14 ps=8.7e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.75e-07 sb=4.76058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
mn56 (\12\:qint \14\:qbint \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05069e-06 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp0 (\7\:Eb \1\:E \30\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.091e-13 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=46.1185 \
        scb=0.028424 scc=0.00588418 m=(1)
mp7 (\9\:Dp Db \3\:n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.558e-14 ad=3.655e-14 ps=1.04e-06 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=4.9e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp6 (\12\:Dp \4\:E \3\:n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.558e-14 ad=3.01e-14 ps=1.04e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp4 (n3 Eb \3\:n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.01e-14 \
        ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=8.1e-07 sd=160n sca=39.8855 scb=0.0273598 \
        scc=0.00519679 m=(1)
mp5 (n3 \2\:qbint n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=6.05e-07 sd=160n sca=39.8855 \
        scb=0.0273598 scc=0.00519679 m=(1)
mp3 (n2 RNb \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.128e-14 ad=3.44e-14 ps=1.93e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=4e-07 sd=160n sca=39.8855 scb=0.0273598 \
        scc=0.00519679 m=(1)
mp2 (\4\:RNb \1\:RN \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.128e-14 ad=3.87e-14 ps=1.93e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.7e-07 sb=1.8e-07 sd=160n sca=39.8855 \
        scb=0.0273598 scc=0.00519679 m=(1)
mp21 (\11\:CKbb CKb \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=3.01e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=17.9376 scb=0.0177709 \
        scc=0.00142383 m=(1)
mp25 (n22 Dp \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=6.773e-14 ps=1.7e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=2e-06 sd=160n sca=17.9376 scb=0.0177709 \
        scc=0.00142383 m=(1)
mp26 (\7\:n20 \3\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=6.558e-14 ps=1.06e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.95e-07 sb=1.97e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp36 (\7\:n20 \6\:CKb net427 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.558e-14 ps=5.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=1.62e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp35 (net427 mout \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=1.29e-14 ps=1.7e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.15e-06 sb=1.515e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp30 (\8\:mout n20 \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=5.697e-14 ps=1.7e-06 pd=9.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.415e-06 sb=1.25e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp40 (\7\:n30 \8\:CKb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.697e-14 ad=7.203e-14 ps=9.6e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.725e-06 sb=9.4e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp51 (\7\:n30 \4\:CKbb net411 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.225e-14 ad=7.203e-14 ps=7.3e-07 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.6e-07 sd=160n sca=17.9376 scb=0.0177709 \
        scc=0.00142383 m=(1)
mp50 (net411 \4\:qbint \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.48e-14 ad=3.225e-14 ps=1.22e-06 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.65e-07 sd=160n sca=17.9376 scb=0.0177709 \
        scc=0.00142383 m=(1)
mp56 (\8\:qint \13\:qbint \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=7.015e-14 ad=3.01e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.32314e-06 sb=1.4e-07 sd=160n sca=23.0212 \
        scb=0.0246876 scc=0.0015445 m=(1)
mp45 (\18\:qbint n30 \14\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.48e-14 ad=4.5e-14 ps=1.22e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.14744e-06 sb=1.15385e-07 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(1)
mp20 (\19\:CKb \3\:CK \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.08e-13 ad=3.83e-14 ps=1.72e-06 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7814e-07 sb=1.285e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp55 (\2\:Q \7\:qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=1.029e-13 ad=6.24e-14 ps=1.57e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.2609e-07 sb=9.04551e-07 sd=160n sca=14.3987 \
        scb=0.0130081 scc=0.000814275 m=(2)
mp57 (\3\:QN qint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.397e-14 ad=6.24e-14 ps=1.56e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.9609e-07 sb=4.34551e-07 sd=160n sca=14.9766 \
        scb=0.0132237 scc=0.000814354 m=(2)
ends EDFFTRX2
// End of subcircuit definition.

// Generated for: spectre (May  9 14:47:51 2012 )
// Library name: gsclib045
// Cell name: EDFFTRX4
// View name: extracted

simulator lang=spectre

subckt EDFFTRX4 CK D E Q QN RN VDD VSS
mp1 (\5\:Db \1\:D \41\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.001e-13 ad=3.01e-14 ps=1.75e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=22.8473 \
        scb=0.0215844 scc=0.00209118 m=(1)
C1 (D VSS) capacitor c=5.98968e-17
C2 (CK VSS) capacitor c=8.06372e-17
C3 (Q VSS) capacitor c=1.50379e-17
C4 (QN VSS) capacitor c=1.98885e-17
C5 (RN VSS) capacitor c=5.6343e-17
C6 (VDD VSS) capacitor c=5.37691e-16
C7 (E VSS) capacitor c=2.58244e-17
C8 (Db VSS) capacitor c=6.71217e-17
C9 (Eb VSS) capacitor c=7.55939e-17
C10 (n1 VSS) capacitor c=7.13172e-19
C11 (Dp VSS) capacitor c=6.80061e-17
C12 (qbint VSS) capacitor c=3.64872e-17
C13 (RNb VSS) capacitor c=4.6542e-17
C14 (n20 VSS) capacitor c=4.59339e-17
C15 (CKb VSS) capacitor c=3.6454e-17
C16 (net516 VSS) capacitor c=1.19036e-18
C17 (CKbb VSS) capacitor c=3.73771e-17
C18 (mout VSS) capacitor c=4.15395e-17
C19 (n30 VSS) capacitor c=1.78485e-16
C20 (net496 VSS) capacitor c=4.27756e-20
C21 (qint VSS) capacitor c=2.88122e-16
C22 (n3 VSS) capacitor c=7.95215e-17
C23 (n2 VSS) capacitor c=6.50594e-17
C24 (n22 VSS) capacitor c=1.09542e-18
C25 (net427 VSS) capacitor c=5.75394e-19
C26 (net411 VSS) capacitor c=9.50992e-19
C27 (\20\:qbint VSS) capacitor c=4.18173e-17
C28 (\1\:CK VSS) capacitor c=4.93481e-17
C29 (\9\:CKb VSS) capacitor c=5.81322e-17
C30 (\5\:qbint VSS) capacitor c=6.15828e-17
C31 (\5\:CKb VSS) capacitor c=4.03366e-17
C32 (\3\:CKb VSS) capacitor c=4.72894e-17
C33 (\5\:CKbb VSS) capacitor c=7.37004e-17
C34 (\1\:RN VSS) capacitor c=4.66977e-17
C35 (\2\:qbint VSS) capacitor c=5.84442e-17
C36 (\4\:E VSS) capacitor c=3.91583e-17
C37 (\2\:Db VSS) capacitor c=4.33805e-17
C38 (\1\:E VSS) capacitor c=3.40339e-17
C39 (\1\:D VSS) capacitor c=3.29946e-17
C40 (\22\:qbint VSS) capacitor c=4.07713e-17
C41 (\7\:qbint VSS) capacitor c=2.63897e-16
C42 (\3\:CK VSS) capacitor c=2.81753e-17
C43 (\10\:CKb VSS) capacitor c=2.30167e-17
C44 (\6\:qbint VSS) capacitor c=7.9934e-17
C45 (\7\:CKb VSS) capacitor c=6.43342e-17
C46 (\3\:CKbb VSS) capacitor c=9.17527e-17
C47 (\3\:n20 VSS) capacitor c=3.76398e-17
C48 (\3\:mout VSS) capacitor c=5.26524e-17
C49 (\4\:CKbb VSS) capacitor c=1.15178e-16
C50 (\2\:CKb VSS) capacitor c=7.05483e-17
C51 (\2\:Dp VSS) capacitor c=4.93804e-17
C52 (\3\:RN VSS) capacitor c=4.88515e-17
C53 (\3\:RNb VSS) capacitor c=5.36643e-17
C54 (\3\:qbint VSS) capacitor c=8.86239e-17
C55 (\2\:Eb VSS) capacitor c=4.17933e-17
C56 (\6\:E VSS) capacitor c=5.77398e-17
C57 (\3\:E VSS) capacitor c=2.87496e-17
C58 (\3\:D VSS) capacitor c=3.19154e-17
C59 (\21\:qbint VSS) capacitor c=4.99994e-17
C60 (\2\:CK VSS) capacitor c=2.86254e-17
C61 (\11\:CKb VSS) capacitor c=2.08737e-17
C62 (\4\:qbint VSS) capacitor c=2.40504e-17
C63 (\2\:CKbb VSS) capacitor c=7.26343e-17
C64 (\8\:CKb VSS) capacitor c=3.36839e-17
C65 (\6\:CKb VSS) capacitor c=4.0888e-17
C66 (\2\:n20 VSS) capacitor c=3.40121e-17
C67 (\2\:mout VSS) capacitor c=4.32054e-17
C68 (\4\:CKb VSS) capacitor c=4.29438e-17
C69 (\3\:Dp VSS) capacitor c=2.81785e-17
C70 (\2\:RN VSS) capacitor c=4.11256e-17
C71 (\2\:RNb VSS) capacitor c=4.10538e-17
C72 (\3\:Eb VSS) capacitor c=2.78102e-17
C73 (\5\:E VSS) capacitor c=3.67902e-17
C74 (\3\:Db VSS) capacitor c=2.40245e-17
C75 (\2\:E VSS) capacitor c=3.25188e-17
C76 (\2\:D VSS) capacitor c=2.90704e-17
C77 (\16\:qint VSS) capacitor c=5.66523e-17
C78 (\1\:QN VSS) capacitor c=1.13727e-16
C79 (\26\:qbint VSS) capacitor c=3.99345e-17
C80 (\12\:CKb VSS) capacitor c=1.46978e-16
C81 (\10\:CKbb VSS) capacitor c=3.77507e-17
C82 (\25\:VDD VSS) capacitor c=2.34064e-17
C83 (\8\:n30 VSS) capacitor c=2.23917e-16
C84 (\4\:mout VSS) capacitor c=2.47034e-17
C85 (\28\:VDD VSS) capacitor c=1.05689e-17
C86 (\6\:n20 VSS) capacitor c=1.26583e-16
C87 (\32\:VDD VSS) capacitor c=8.44015e-18
C88 (\4\:RNb VSS) capacitor c=7.72902e-17
C89 (\36\:VDD VSS) capacitor c=1.04745e-17
C90 (\3\:n2 VSS) capacitor c=7.57229e-17
C91 (\11\:Dp VSS) capacitor c=4.70706e-17
C92 (\3\:n3 VSS) capacitor c=7.76282e-17
C93 (\13\:Dp VSS) capacitor c=5.49981e-17
C94 (\7\:Eb VSS) capacitor c=6.19857e-17
C95 (\41\:VDD VSS) capacitor c=2.74558e-17
C96 (\5\:Db VSS) capacitor c=1.64235e-16
C97 (\1\:VDD VSS) capacitor c=2.0022e-16
C98 (\20\:qint VSS) capacitor c=8.66741e-18
C99 (\5\:QN VSS) capacitor c=7.47516e-17
C100 (\1\:Q VSS) capacitor c=7.00285e-17
C101 (\29\:qbint VSS) capacitor c=2.28663e-17
C102 (\14\:CKb VSS) capacitor c=1.22046e-16
C103 (\6\:CKbb VSS) capacitor c=5.82691e-17
C104 (\10\:n30 VSS) capacitor c=8.46177e-17
C105 (\8\:mout VSS) capacitor c=6.74187e-17
C106 (\4\:n20 VSS) capacitor c=7.19727e-17
C107 (\8\:RNb VSS) capacitor c=2.83886e-17
C108 (\5\:Dp VSS) capacitor c=1.16942e-16
C109 (\9\:Dp VSS) capacitor c=3.84802e-17
C110 (\5\:Eb VSS) capacitor c=1.50995e-16
C111 (\7\:Db VSS) capacitor c=8.17299e-17
C112 (\4\:D VSS) capacitor c=5.81125e-17
C113 (\4\:Db VSS) capacitor c=1.13823e-16
C114 (\7\:E VSS) capacitor c=5.78704e-17
C115 (\8\:E VSS) capacitor c=1.04741e-16
C116 (\9\:E VSS) capacitor c=1.11139e-16
C117 (\4\:Eb VSS) capacitor c=1.49319e-16
C118 (\6\:RNb VSS) capacitor c=3.73178e-17
C119 (\7\:RNb VSS) capacitor c=1.14822e-17
C120 (\4\:Dp VSS) capacitor c=6.75694e-17
C121 (\7\:Dp VSS) capacitor c=9.95528e-17
C122 (\8\:Dp VSS) capacitor c=6.58168e-17
C123 (\4\:RN VSS) capacitor c=4.81144e-17
C124 (\8\:n20 VSS) capacitor c=1.22242e-16
C125 (\6\:mout VSS) capacitor c=4.79968e-17
C126 (\7\:mout VSS) capacitor c=6.02353e-17
C127 (\8\:CKbb VSS) capacitor c=6.03958e-17
C128 (\9\:CKbb VSS) capacitor c=6.22022e-17
C129 (\16\:CKb VSS) capacitor c=1.41005e-16
C130 (\17\:CKb VSS) capacitor c=1.1548e-16
C131 (\18\:CKb VSS) capacitor c=3.40077e-17
C132 (\19\:CKb VSS) capacitor c=1.21899e-16
C133 (\20\:CKb VSS) capacitor c=1.06052e-16
C134 (\21\:CKb VSS) capacitor c=3.17508e-17
C135 (\22\:CKb VSS) capacitor c=8.03469e-17
C136 (\23\:CKb VSS) capacitor c=6.06628e-17
C137 (\4\:CK VSS) capacitor c=5.73461e-17
C138 (\7\:n30 VSS) capacitor c=2.54808e-16
C139 (\4\:Q VSS) capacitor c=1.1859e-16
C140 (\23\:qbint VSS) capacitor c=2.25411e-16
C141 (\24\:qbint VSS) capacitor c=3.1912e-16
C142 (\25\:qbint VSS) capacitor c=3.42804e-16
C143 (\28\:qbint VSS) capacitor c=4.01239e-17
C144 (\31\:qbint VSS) capacitor c=2.019e-16
C145 (\32\:qbint VSS) capacitor c=2.5756e-17
C146 (\18\:qint VSS) capacitor c=4.10174e-17
C147 (\19\:qint VSS) capacitor c=4.53908e-17
C148 (\3\:VDD VSS) capacitor c=2.64501e-16
C149 (\24\:VDD VSS) capacitor c=2.98654e-17
C150 (\27\:VDD VSS) capacitor c=2.44694e-17
C151 (\40\:VDD VSS) capacitor c=2.49232e-17
Rk1 (\4\:D D) resistor r=0.1053 c=0
Rk38 (\4\:CK CK) resistor r=0.04731 c=0
Rk42 (\1\:Q Q) resistor r=0.1911 c=0
Rk43 (Q \4\:Q) resistor r=0.04541 c=0
Rk91 (\2\:VSS \3\:VSS) resistor r=0.1829 c=0
Rk98 (\3\:VSS \10\:VSS) resistor r=0.2506 c=0
Rk99 (\10\:VSS \11\:VSS) resistor r=0.2807 c=0
Rk100 (\11\:VSS \12\:VSS) resistor r=0.5112 c=0
Rk101 (\12\:VSS \13\:VSS) resistor r=0.05999 c=0
Rk102 (\13\:VSS \14\:VSS) resistor r=0.4227 c=0
Rk103 (\14\:VSS \15\:VSS) resistor r=0.2168 c=0
Rk104 (\15\:VSS \16\:VSS) resistor r=0.1603 c=0
Rk105 (\16\:VSS \17\:VSS) resistor r=0.1703 c=0
Rk106 (\17\:VSS \18\:VSS) resistor r=0.07986 c=0
Rk107 (\18\:VSS \19\:VSS) resistor r=0.3509 c=0
Rk109 (\20\:VSS VSS) resistor r=0.2804 c=0
Rk108 (\19\:VSS \20\:VSS) resistor r=0.07002 c=0
Rk116 (\11\:VSS \34\:VSS) resistor r=0.3927 c=0
Rk117 (\12\:VSS \36\:VSS) resistor r=0.2571 c=0
Rk118 (\14\:VSS \38\:VSS) resistor r=0.04331 c=0
Rk119 (\15\:VSS \40\:VSS) resistor r=0.07393 c=0
Rk120 (\17\:VSS \42\:VSS) resistor r=0.2739 c=0
Rk121 (\18\:VSS \44\:VSS) resistor r=0.2734 c=0
Rk122 (\20\:VSS \46\:VSS) resistor r=0.3824 c=0
Rk48 (\1\:QN QN) resistor r=0.07077 c=0
Rk49 (QN \5\:QN) resistor r=0.2435 c=0
Rk20 (\4\:RN RN) resistor r=0.03934 c=0
Rk61 (\2\:VDD \3\:VDD) resistor r=0.08256 c=0
Rk75 (\3\:VDD \23\:VDD) resistor r=0.3926 c=0
Rk76 (\23\:VDD \24\:VDD) resistor r=0.05653 c=0
Rk77 (\24\:VDD \26\:VDD) resistor r=0.04331 c=0
Rk78 (\24\:VDD \27\:VDD) resistor r=0.5253 c=0
Rk79 (\27\:VDD \29\:VDD) resistor r=0.07393 c=0
Rk80 (\27\:VDD \30\:VDD) resistor r=0.218 c=0
Rk81 (\30\:VDD \31\:VDD) resistor r=0.2155 c=0
Rk82 (\31\:VDD \33\:VDD) resistor r=0.07393 c=0
Rk83 (\31\:VDD \34\:VDD) resistor r=0.08507 c=0
Rk84 (\34\:VDD \35\:VDD) resistor r=0.1127 c=0
Rk85 (\35\:VDD \37\:VDD) resistor r=0.07393 c=0
Rk86 (\35\:VDD \38\:VDD) resistor r=0.03742 c=0
Rk87 (\38\:VDD \39\:VDD) resistor r=0.652 c=0
Rk90 (\40\:VDD VDD) resistor r=0.2945 c=0
Rk88 (\39\:VDD \40\:VDD) resistor r=0.2547 c=0
Rk89 (\40\:VDD \42\:VDD) resistor r=0.04331 c=0
Rk5 (\8\:E E) resistor r=0.02565 c=0
Rk4 (\7\:E \8\:E) resistor r=0.2497 c=0
Rk6 (\8\:E \9\:E) resistor r=0.7111 c=0
Rk2 (\4\:Db \6\:Db) resistor r=0.7537 c=0
Rk3 (\6\:Db \8\:Db) resistor r=0.8054 c=0
Rk7 (\4\:Eb \6\:Eb) resistor r=1.037 c=0
Rk8 (\6\:Eb \8\:Eb) resistor r=0.342 c=0
Rk14 (\4\:Dp \6\:Dp) resistor r=0.6651 c=0
Rk15 (\6\:Dp \7\:Dp) resistor r=0.4335 c=0
Rk16 (\7\:Dp \8\:Dp) resistor r=0.4498 c=0
Rk17 (\8\:Dp \10\:Dp) resistor r=0.09733 c=0
Rk18 (\7\:Dp \12\:Dp) resistor r=0.2091 c=0
Rk19 (\8\:Dp \14\:Dp) resistor r=0.249 c=0
Rk51 (\23\:qbint \24\:qbint) resistor r=1.7888 c=0
Rk52 (\24\:qbint \25\:qbint) resistor r=1.0893 c=0
Rk53 (\24\:qbint \27\:qbint) resistor r=0.05684 c=0
Rk54 (\27\:qbint \28\:qbint) resistor r=0.3137 c=0
Rk55 (\28\:qbint \30\:qbint) resistor r=0.1511 c=0
Rk56 (\25\:qbint \31\:qbint) resistor r=1.7824 c=0
Rk57 (\28\:qbint \32\:qbint) resistor r=0.1983 c=0
Rk11 (\5\:RNb \6\:RNb) resistor r=0.3873 c=0
Rk12 (\6\:RNb \7\:RNb) resistor r=0.03421 c=0
Rk13 (\6\:RNb \9\:RNb) resistor r=0.1231 c=0
Rk21 (\5\:n20 \7\:n20) resistor r=0.4259 c=0
Rk22 (\7\:n20 \8\:n20) resistor r=0.6927 c=0
Rk29 (\13\:CKb \15\:CKb) resistor r=0.839 c=0
Rk30 (\15\:CKb \16\:CKb) resistor r=0.5402 c=0
Rk31 (\16\:CKb \17\:CKb) resistor r=0.7864 c=0
Rk32 (\17\:CKb \18\:CKb) resistor r=0.08968 c=0
Rk33 (\17\:CKb \19\:CKb) resistor r=0.1764 c=0
Rk34 (\19\:CKb \20\:CKb) resistor r=0.7273 c=0
Rk35 (\20\:CKb \21\:CKb) resistor r=0.1849 c=0
Rk36 (\19\:CKb \22\:CKb) resistor r=0.3637 c=0
Rk37 (\20\:CKb \23\:CKb) resistor r=0.2555 c=0
Rk26 (\7\:CKbb \8\:CKbb) resistor r=0.2466 c=0
Rk27 (\8\:CKbb \9\:CKbb) resistor r=0.3602 c=0
Rk28 (\8\:CKbb \11\:CKbb) resistor r=0.1695 c=0
Rk23 (\5\:mout \6\:mout) resistor r=0.07763 c=0
Rk24 (\6\:mout \7\:mout) resistor r=0.2448 c=0
Rk25 (\6\:mout \9\:mout) resistor r=0.2879 c=0
Rk39 (\7\:n30 \9\:n30) resistor r=1.5052 c=0
Rk40 (\9\:n30 \11\:n30) resistor r=0.3575 c=0
Rk58 (\17\:qint \18\:qint) resistor r=0.4787 c=0
Rk59 (\18\:qint \19\:qint) resistor r=0.2487 c=0
Rk60 (\18\:qint \21\:qint) resistor r=0.03792 c=0
Rk9 (\2\:n3 \4\:n3) resistor r=0.5224 c=0
Rk10 (\2\:n2 \4\:n2) resistor r=0.3324 c=0
Rl1 (\1\:D \2\:D) resistor r=31.461 c=0
Rl2 (\2\:D \3\:D) resistor r=64.1533 c=0
Rl35 (\1\:CK \2\:CK) resistor r=81.461 c=0
Rl36 (\2\:CK \3\:CK) resistor r=39.1533 c=0
Rl15 (\1\:RN \2\:RN) resistor r=45.3867 c=0
Rl16 (\2\:RN \3\:RN) resistor r=102.463 c=0
Rl7 (\4\:E \5\:E) resistor r=103.4 c=0
Rl8 (\5\:E \6\:E) resistor r=91.1062 c=0
Rl3 (\1\:E \2\:E) resistor r=35.3066 c=0
Rl4 (\2\:E \3\:E) resistor r=61.3335 c=0
Rl5 (Db \2\:Db) resistor r=123.889 c=0
Rl6 (\2\:Db \3\:Db) resistor r=64.1533 c=0
Rl9 (Eb \2\:Eb) resistor r=145.72 c=0
Rl10 (\2\:Eb \3\:Eb) resistor r=24.2328 c=0
Rl17 (Dp \2\:Dp) resistor r=132.539 c=0
Rl18 (\2\:Dp \3\:Dp) resistor r=29.5379 c=0
Rl11 (qbint \2\:qbint) resistor r=31.0981 c=0
Rl32 (\6\:qbint \5\:qbint) resistor r=145.72 c=0
Rl12 (\3\:qbint \2\:qbint) resistor r=166.439 c=0
Rl68 (\21\:qbint \20\:qbint) resistor r=65.3618 c=0
Rl69 (\21\:qbint \22\:qbint) resistor r=63.2566 c=0
Rl31 (\4\:qbint \5\:qbint) resistor r=58.3841 c=0
Rl13 (RNb \2\:RNb) resistor r=68.4636 c=0
Rl14 (\2\:RNb \3\:RNb) resistor r=97.631 c=0
Rl23 (n20 \2\:n20) resistor r=76.9231 c=0
Rl24 (\2\:n20 \3\:n20) resistor r=29.9451 c=0
Rl33 (\9\:CKb \10\:CKb) resistor r=130.769 c=0
Rl19 (CKb \2\:CKb) resistor r=64.0094 c=0
Rl34 (\10\:CKb \11\:CKb) resistor r=29.5379 c=0
Rl26 (\7\:CKb \8\:CKb) resistor r=94.9225 c=0
Rl25 (\5\:CKb \6\:CKb) resistor r=28.079 c=0
Rl20 (\3\:CKb \4\:CKb) resistor r=54.5567 c=0
Rl30 (\4\:CKbb \5\:CKbb) resistor r=186.104 c=0
Rl29 (\3\:CKbb \4\:CKbb) resistor r=447.643 c=0
Rl27 (CKbb \2\:CKbb) resistor r=24.2328 c=0
Rl28 (\2\:CKbb \3\:CKbb) resistor r=195.274 c=0
Rl21 (mout \2\:mout) resistor r=24.2328 c=0
Rl22 (\2\:mout \3\:mout) resistor r=93.0293 c=0
Rz32 (\34\:VSS \33\:VSS) resistor r=75 c=0
Rz33 (\36\:VSS \35\:VSS) resistor r=75 c=0
Rz34 (\38\:VSS \37\:VSS) resistor r=75 c=0
Rz35 (\40\:VSS \39\:VSS) resistor r=75 c=0
Rz36 (\42\:VSS \41\:VSS) resistor r=75 c=0
Rz37 (\44\:VSS \43\:VSS) resistor r=75 c=0
Rz38 (\46\:VSS \45\:VSS) resistor r=75 c=0
Rz17 (\2\:VDD \1\:VDD) resistor r=37.5 c=0
Rz20 (\3\:VDD \1\:VDD) resistor r=8.3333 c=0
Rz21 (\23\:VDD \1\:VDD) resistor r=6.25 c=0
Rz22 (\30\:VDD \1\:VDD) resistor r=18.75 c=0
Rz23 (\34\:VDD \1\:VDD) resistor r=37.5 c=0
Rz24 (\38\:VDD \1\:VDD) resistor r=75 c=0
Rz25 (\39\:VDD \1\:VDD) resistor r=6.25 c=0
Rz1 (\7\:Db \8\:Db) resistor r=75 c=0
Rz2 (\5\:Eb \6\:Eb) resistor r=75 c=0
Rz4 (\5\:Dp \6\:Dp) resistor r=75 c=0
Rz5 (\9\:Dp \10\:Dp) resistor r=75 c=0
Rz15 (\30\:qbint \29\:qbint) resistor r=75 c=0
Rz3 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz6 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz9 (\14\:CKb \15\:CKb) resistor r=75 c=0
Rz8 (\6\:CKbb \7\:CKbb) resistor r=75 c=0
Rz7 (\8\:mout \9\:mout) resistor r=75 c=0
Rz10 (\11\:n30 \10\:n30) resistor r=75 c=0
Rz16 (\21\:qint \20\:qint) resistor r=75 c=0
Ry32 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry33 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry34 (\10\:VSS \1\:VSS) resistor r=12.4 c=0
Ry35 (\13\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry36 (\16\:VSS \1\:VSS) resistor r=15.5 c=0
Ry37 (\19\:VSS \1\:VSS) resistor r=7.75 c=0
Ry27 (\26\:VDD \25\:VDD) resistor r=62 c=0
Ry28 (\29\:VDD \28\:VDD) resistor r=62 c=0
Ry29 (\33\:VDD \32\:VDD) resistor r=62 c=0
Ry30 (\37\:VDD \36\:VDD) resistor r=62 c=0
Ry31 (\42\:VDD \41\:VDD) resistor r=62 c=0
Ry1 (\5\:Db \6\:Db) resistor r=62 c=0
Ry2 (\7\:Eb \8\:Eb) resistor r=62 c=0
Ry8 (\11\:Dp \12\:Dp) resistor r=62 c=0
Ry9 (\13\:Dp \14\:Dp) resistor r=62 c=0
Ry19 (\27\:qbint \26\:qbint) resistor r=31 c=0
Ry7 (\4\:RNb \5\:RNb) resistor r=62 c=0
Ry10 (\6\:n20 \7\:n20) resistor r=62 c=0
Ry13 (\12\:CKb \13\:CKb) resistor r=62 c=0
Ry12 (\10\:CKbb \11\:CKbb) resistor r=62 c=0
Ry11 (\4\:mout \5\:mout) resistor r=62 c=0
Ry14 (\9\:n30 \8\:n30) resistor r=62 c=0
Ry20 (\17\:qint \16\:qint) resistor r=20.6667 c=0
Ry3 (n3 \2\:n3) resistor r=62 c=0
Ry4 (\3\:n3 \4\:n3) resistor r=62 c=0
Ry5 (n2 \2\:n2) resistor r=62 c=0
Ry6 (\3\:n2 \4\:n2) resistor r=62 c=0
Rx1 (\2\:D \4\:D) resistor r=45 c=0
Rx17 (\2\:CK \4\:CK) resistor r=45 c=0
Rx8 (\2\:RN \4\:RN) resistor r=45 c=0
Rx3 (\2\:E \7\:E) resistor r=45 c=0
Rx4 (\5\:E \9\:E) resistor r=45 c=0
Rx2 (\3\:Db \4\:Db) resistor r=45 c=0
Rx5 (\3\:Eb \4\:Eb) resistor r=45 c=0
Rx7 (\3\:Dp \4\:Dp) resistor r=45 c=0
Rx19 (\23\:qbint \21\:qbint) resistor r=45 c=0
Rx20 (\25\:qbint \4\:qbint) resistor r=45 c=0
Rx21 (\31\:qbint qbint) resistor r=45 c=0
Rx22 (\32\:qbint \7\:qbint) resistor r=45 c=0
Rx6 (\2\:RNb \7\:RNb) resistor r=45 c=0
Rx9 (\2\:n20 \8\:n20) resistor r=45 c=0
Rx12 (\11\:CKb \16\:CKb) resistor r=45 c=0
Rx13 (\8\:CKb \18\:CKb) resistor r=45 c=0
Rx14 (CKb \21\:CKb) resistor r=45 c=0
Rx15 (\6\:CKb \22\:CKb) resistor r=45 c=0
Rx16 (\4\:CKb \23\:CKb) resistor r=45 c=0
Rx11 (\2\:CKbb \9\:CKbb) resistor r=45 c=0
Rx10 (\2\:mout \7\:mout) resistor r=45 c=0
Rx18 (\7\:n30 n30) resistor r=45 c=0
Rx23 (\19\:qint qint) resistor r=45 c=0
mn1 (\7\:Db \3\:D \45\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn0 (\5\:Eb \3\:E \45\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn7 (\9\:Dp Db n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.61e-14 ps=4.1e-07 pd=6.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.8e-07 sb=2.75e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn26 (\4\:n20 \2\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.277e-14 ps=4.1e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn6 (n1 \6\:E \43\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.445e-14 ad=8.7e-15 ps=9.6e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.7e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn4 (n0 \2\:Eb \41\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.137e-14 ad=8.7e-15 ps=1.19e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.95e-07 sb=4.1e-07 sd=160n sca=21.4614 \
        scb=0.0218523 scc=0.00230065 m=(1)
mn5 (\5\:Dp \3\:qbint n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4e-07 sb=3.05e-07 sd=160n sca=21.4614 scb=0.0218523 \
        scc=0.00230065 m=(1)
mn3 (\5\:Dp \3\:RNb \39\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.415e-14 ad=2.32e-14 ps=1.48e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.05e-07 sb=1e-07 sd=160n sca=21.4614 scb=0.0218523 \
        scc=0.00230065 m=(1)
mn2 (\8\:RNb \3\:RN \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.0078e-13 ad=2.03e-14 ps=1.83e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn25 (n21 \2\:Dp \37\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.0078e-13 ad=8.7e-15 ps=1.83e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn36 (\4\:n20 \4\:CKbb net516 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.812e-14 ad=4.277e-14 ps=5.4e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.65e-07 sb=1.71e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (net516 \3\:mout \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.485e-14 ad=1.812e-14 ps=1.1e-06 pd=5.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.135e-06 sb=1.54e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\8\:mout \3\:n20 \35\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.485e-14 ad=3.552e-14 ps=1.1e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.43e-06 sb=1.245e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\10\:n30 \3\:CKbb \8\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.552e-14 ad=4.567e-14 ps=7.8e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.72e-06 sb=9.55e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\10\:n30 \7\:CKb net496 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.567e-14 ps=4.1e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.95e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn50 (net496 \6\:qbint \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.552e-14 ad=8.7e-15 ps=7.8e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.9e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21 (\6\:CKbb \10\:CKb \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.552e-14 ad=2.9e-14 ps=7.8e-07 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\14\:CKb \3\:CK \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.812e-14 ad=2.03e-14 ps=8.2e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.9911 scb=0.0120555 \
        scc=0.000498628 m=(1)
mn45 (\29\:qbint n30 \3\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 nf=1 \
        as=4.444e-14 ad=3.895e-14 ps=8.8e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.16829e-07 sb=2e-06 sd=160n sca=10.7727 \
        scb=0.0101457 scc=0.000373012 m=(2)
mn55_1__rcx (\1\:Q \7\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.389e-14 ad=4.16e-14 ps=8.65e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.65769e-07 sb=1.785e-06 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(4)
mn57_1__rcx (\5\:QN qint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.225e-14 ps=8.4e-07 pd=8.45e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48577e-06 sb=9.65e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(4)
mn56 (\20\:qint \22\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.95452e-06 sb=1.4e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(1)
mp0 (\7\:Eb \1\:E \41\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.001e-13 ad=3.01e-14 ps=1.75e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=21.5061 \
        scb=0.0204227 scc=0.00208845 m=(1)
mp7 (\13\:Dp \2\:Db \3\:n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.203e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.2e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp6 (\11\:Dp \4\:E \3\:n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.203e-14 ad=3.01e-14 ps=1.1e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.4e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp4 (n3 Eb \3\:n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.01e-14 \
        ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=5.1e-07 sd=160n sca=19.0975 scb=0.0187686 \
        scc=0.00166224 m=(1)
mp5 (n3 \2\:qbint n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.05e-07 sd=160n sca=19.0975 \
        scb=0.0187686 scc=0.00166224 m=(1)
mp3 (n2 RNb \36\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.115e-14 ad=3.44e-14 ps=1.62e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=1e-07 sd=160n sca=19.0975 scb=0.0187686 \
        scc=0.00166224 m=(1)
mp2 (\4\:RNb \1\:RN \32\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=2.77e-14 ps=1.7e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.28837e-07 sb=2e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp25 (n22 Dp \32\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.14e-14 ad=3.87e-14 ps=1.7e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.23837e-07 sb=2e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp26 (\6\:n20 \5\:CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.87e-14 ad=5.052e-14 ps=7.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.48837e-07 sb=1.84e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp36 (\6\:n20 \3\:CKb net427 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.58e-14 ad=5.052e-14 ps=6.7e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.28837e-07 sb=1.56e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp35 (net427 mout \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=2.58e-14 ps=1.7e-06 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=9.93837e-07 sb=1.395e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp30 (\4\:mout n20 \28\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.71e-14 ad=4.515e-14 ps=1.7e-06 pd=8.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25884e-06 sb=1.13e-06 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp40 (\8\:n30 \5\:CKb \4\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.515e-14 ad=6.558e-14 ps=8.5e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.51384e-06 sb=8.75e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp51 (\8\:n30 CKbb net411 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=6.558e-14 ps=7e-07 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.86384e-06 sb=5.25e-07 sd=160n sca=17.9376 \
        scb=0.0177709 scc=0.00142383 m=(1)
mp50 (net411 \5\:qbint \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.355e-14 ad=2.903e-14 ps=1.72e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.45e-07 sd=160n sca=17.9376 scb=0.0177709 \
        scc=0.00142383 m=(1)
mp21 (\10\:CKbb \9\:CKb \25\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.355e-14 ad=3.01e-14 ps=1.72e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=17.9376 scb=0.0177709 \
        scc=0.00142383 m=(1)
mp20 (\12\:CKb \1\:CK \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.115e-14 ad=3.01e-14 ps=1.9e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=29.9075 scb=0.0247057 \
        scc=0.00372713 m=(1)
mp45 (\26\:qbint n30 \3\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=7.948e-14 ad=4.96e-14 ps=1.61e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.62984e-07 sb=2e-06 sd=160n sca=35.6995 \
        scb=0.0234062 scc=0.00420468 m=(2)
mp55_1__rcx (\4\:Q \7\:qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.08e-14 ad=6.24e-14 ps=1.32e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=6.175e-07 sb=2e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
mp57_1__rcx (\1\:QN qint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.18e-14 ad=6.24e-14 ps=1.32e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.5575e-06 sb=1.08e-06 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(4)
mp56 (\16\:qint \20\:qbint \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=9.18e-14 ad=5.46e-14 ps=1.32e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=44.1638 scb=0.0392167 \
        scc=0.00476734 m=(1)
ends EDFFTRX4
// End of subcircuit definition.

// Generated for: spectre (May  9 14:48:28 2012 )
// Library name: gsclib045
// Cell name: EDFFTRXL
// View name: extracted

simulator lang=spectre

subckt EDFFTRXL CK D E Q QN RN VDD VSS
mp57 (\1\:QN \4\:qint \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.515e-14 ad=3.762e-14 ps=1.45e-06 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.35e-07 sd=160n sca=49.7297 \
        scb=0.0332192 scc=0.00593869 m=(1)
C1 (CK VSS) capacitor c=4.92013e-17
C2 (D VSS) capacitor c=5.99761e-17
C3 (QN VSS) capacitor c=2.1175e-17
C4 (E VSS) capacitor c=2.25282e-17
C5 (VDD VSS) capacitor c=4.077e-16
C6 (Q VSS) capacitor c=3.385e-17
C7 (RN VSS) capacitor c=5.94935e-17
C8 (qint VSS) capacitor c=1.99277e-17
C9 (qbint VSS) capacitor c=2.55709e-17
C10 (CKb VSS) capacitor c=7.82596e-17
C11 (n30 VSS) capacitor c=4.06396e-17
C12 (mout VSS) capacitor c=5.26886e-17
C13 (CKbb VSS) capacitor c=3.16184e-17
C14 (n20 VSS) capacitor c=3.03753e-17
C15 (net516 VSS) capacitor c=5.49529e-19
C16 (Dp VSS) capacitor c=3.31525e-17
C17 (RNb VSS) capacitor c=3.39203e-17
C18 (n0 VSS) capacitor c=1.31823e-18
C19 (Eb VSS) capacitor c=4.89634e-17
C20 (n1 VSS) capacitor c=1.30814e-18
C21 (Db VSS) capacitor c=6.08044e-17
C22 (net411 VSS) capacitor c=2.30706e-18
C23 (net427 VSS) capacitor c=9.1065e-19
C24 (n2 VSS) capacitor c=8.76965e-17
C25 (n3 VSS) capacitor c=8.32355e-17
C26 (\1\:D VSS) capacitor c=2.70411e-17
C27 (\4\:E VSS) capacitor c=3.81431e-17
C28 (\3\:E VSS) capacitor c=3.99053e-17
C29 (\12\:qbint VSS) capacitor c=5.48686e-17
C30 (\3\:RNb VSS) capacitor c=5.50663e-17
C31 (\1\:RN VSS) capacitor c=3.40865e-17
C32 (\9\:CKb VSS) capacitor c=4.83362e-17
C33 (\3\:Dp VSS) capacitor c=7.79991e-17
C34 (\5\:CKb VSS) capacitor c=6.27787e-17
C35 (\4\:mout VSS) capacitor c=7.43889e-17
C36 (\3\:CKb VSS) capacitor c=3.85733e-17
C37 (\5\:CKbb VSS) capacitor c=9.76899e-17
C38 (\9\:qbint VSS) capacitor c=6.21796e-17
C39 (\1\:CK VSS) capacitor c=4.11343e-17
C40 (\5\:qbint VSS) capacitor c=2.30775e-17
C41 (\7\:qbint VSS) capacitor c=3.55124e-17
C42 (\4\:qint VSS) capacitor c=3.72413e-17
C43 (\4\:D VSS) capacitor c=2.56395e-17
C44 (\7\:E VSS) capacitor c=2.64268e-17
C45 (\2\:Db VSS) capacitor c=8.2872e-17
C46 (\1\:E VSS) capacitor c=6.85916e-17
C47 (\3\:Eb VSS) capacitor c=4.78333e-17
C48 (\11\:qbint VSS) capacitor c=1.05433e-16
C49 (\3\:RN VSS) capacitor c=3.45947e-17
C50 (\11\:CKb VSS) capacitor c=3.23153e-17
C51 (\2\:Dp VSS) capacitor c=5.50509e-17
C52 (\7\:CKb VSS) capacitor c=5.20333e-17
C53 (\3\:CKbb VSS) capacitor c=1.11415e-16
C54 (\3\:n20 VSS) capacitor c=4.48701e-17
C55 (\4\:CKbb VSS) capacitor c=1.04614e-16
C56 (\8\:qbint VSS) capacitor c=8.00705e-17
C57 (\3\:n30 VSS) capacitor c=3.38167e-17
C58 (\4\:CK VSS) capacitor c=2.83231e-17
C59 (\4\:qbint VSS) capacitor c=2.66083e-17
C60 (\3\:qint VSS) capacitor c=3.06048e-17
C61 (\3\:D VSS) capacitor c=2.71515e-17
C62 (\6\:E VSS) capacitor c=2.90516e-17
C63 (\3\:Db VSS) capacitor c=2.08189e-17
C64 (\2\:E VSS) capacitor c=7.03918e-17
C65 (\2\:Eb VSS) capacitor c=4.51769e-17
C66 (\13\:qbint VSS) capacitor c=3.11218e-17
C67 (\2\:RNb VSS) capacitor c=6.04019e-17
C68 (\2\:RN VSS) capacitor c=3.5602e-17
C69 (\10\:CKb VSS) capacitor c=3.32646e-17
C70 (\8\:CKb VSS) capacitor c=5.12814e-17
C71 (\2\:CKbb VSS) capacitor c=7.03652e-17
C72 (\6\:CKb VSS) capacitor c=4.77335e-17
C73 (\3\:mout VSS) capacitor c=1.84154e-17
C74 (\2\:n20 VSS) capacitor c=3.4264e-17
C75 (\4\:CKb VSS) capacitor c=3.67686e-17
C76 (\2\:CKb VSS) capacitor c=3.33451e-17
C77 (\10\:qbint VSS) capacitor c=3.17853e-17
C78 (\2\:n30 VSS) capacitor c=3.01793e-17
C79 (\3\:CK VSS) capacitor c=3.2741e-17
C80 (\6\:qbint VSS) capacitor c=1.75412e-17
C81 (\4\:Db VSS) capacitor c=1.12769e-16
C82 (\1\:VDD VSS) capacitor c=4.09312e-17
C83 (\4\:Eb VSS) capacitor c=5.45615e-17
C84 (\13\:Dp VSS) capacitor c=8.11536e-17
C85 (\3\:n3 VSS) capacitor c=7.91494e-17
C86 (\11\:Dp VSS) capacitor c=2.87757e-17
C87 (\3\:n2 VSS) capacitor c=7.5725e-17
C88 (\12\:VDD VSS) capacitor c=1.49687e-17
C89 (\6\:RNb VSS) capacitor c=4.46229e-17
C90 (\6\:CKbb VSS) capacitor c=3.35621e-17
C91 (\14\:VDD VSS) capacitor c=1.71858e-17
C92 (\6\:n20 VSS) capacitor c=8.66105e-17
C93 (\16\:VDD VSS) capacitor c=1.71563e-17
C94 (\7\:mout VSS) capacitor c=4.98168e-17
C95 (\4\:n30 VSS) capacitor c=5.23896e-17
C96 (\18\:VDD VSS) capacitor c=7.18746e-17
C97 (\17\:qbint VSS) capacitor c=4.36535e-17
C98 (\22\:CKb VSS) capacitor c=6.30374e-17
C99 (\20\:VDD VSS) capacitor c=1.96066e-17
C100 (\3\:Q VSS) capacitor c=5.18249e-17
C101 (\5\:qint VSS) capacitor c=2.28118e-17
C102 (\23\:VDD VSS) capacitor c=5.29349e-18
C103 (\1\:QN VSS) capacitor c=1.57765e-17
C104 (\3\:VDD VSS) capacitor c=1.23213e-16
C105 (\7\:Db VSS) capacitor c=3.15975e-17
C106 (\6\:Eb VSS) capacitor c=1.24519e-16
C107 (\4\:Dp VSS) capacitor c=1.14524e-16
C108 (\6\:Dp VSS) capacitor c=9.39889e-17
C109 (\8\:RNb VSS) capacitor c=4.83336e-17
C110 (\10\:CKbb VSS) capacitor c=4.61981e-17
C111 (\4\:n20 VSS) capacitor c=8.43209e-17
C112 (\9\:mout VSS) capacitor c=4.40798e-17
C113 (\8\:n30 VSS) capacitor c=3.60547e-17
C114 (\21\:qbint VSS) capacitor c=5.03809e-17
C115 (\17\:CKb VSS) capacitor c=1.02654e-16
C116 (\1\:Q VSS) capacitor c=3.24447e-17
C117 (\9\:qint VSS) capacitor c=2.54202e-17
C118 (\3\:QN VSS) capacitor c=3.42427e-17
C119 (\2\:qint VSS) capacitor c=1.2543e-17
C120 (\2\:qbint VSS) capacitor c=3.02226e-17
C121 (\3\:qbint VSS) capacitor c=3.67774e-17
C122 (\2\:mout VSS) capacitor c=4.01299e-17
C123 (\7\:qint VSS) capacitor c=2.72214e-17
C124 (\8\:qint VSS) capacitor c=2.90999e-17
C125 (\5\:CK VSS) capacitor c=8.61527e-17
C126 (\5\:E VSS) capacitor c=2.10748e-17
C127 (\6\:n30 VSS) capacitor c=5.10573e-17
C128 (\7\:n30 VSS) capacitor c=5.39451e-17
C129 (\5\:mout VSS) capacitor c=6.61545e-17
C130 (\6\:mout VSS) capacitor c=5.60867e-17
C131 (\8\:n20 VSS) capacitor c=8.23822e-17
C132 (\12\:CKb VSS) capacitor c=4.56069e-17
C133 (\13\:CKb VSS) capacitor c=1.06904e-16
C134 (\14\:CKb VSS) capacitor c=1.50829e-16
C135 (\15\:CKb VSS) capacitor c=9.89677e-17
C136 (\16\:CKb VSS) capacitor c=7.10412e-17
C137 (\19\:CKb VSS) capacitor c=5.5375e-17
C138 (\20\:CKb VSS) capacitor c=8.15792e-17
C139 (\21\:CKb VSS) capacitor c=2.12749e-17
C140 (\8\:CKbb VSS) capacitor c=5.57897e-17
C141 (\9\:CKbb VSS) capacitor c=7.07465e-17
C142 (\4\:RN VSS) capacitor c=5.94062e-17
C143 (\4\:RNb VSS) capacitor c=6.85835e-17
C144 (\5\:RNb VSS) capacitor c=5.86465e-17
C145 (\14\:qbint VSS) capacitor c=2.0074e-16
C146 (\16\:qbint VSS) capacitor c=7.47364e-17
C147 (\19\:qbint VSS) capacitor c=6.4851e-17
C148 (\20\:qbint VSS) capacitor c=2.72234e-16
C149 (\8\:Dp VSS) capacitor c=2.14883e-16
C150 (\9\:Dp VSS) capacitor c=1.39916e-16
C151 (\10\:Dp VSS) capacitor c=1.16864e-16
C152 (\8\:E VSS) capacitor c=6.28562e-17
C153 (\9\:E VSS) capacitor c=7.6459e-17
C154 (\8\:Eb VSS) capacitor c=1.57048e-16
C155 (\5\:D VSS) capacitor c=7.36187e-17
C156 (\6\:Db VSS) capacitor c=9.26398e-17
C157 (\5\:VDD VSS) capacitor c=2.70698e-17
C158 (\7\:VDD VSS) capacitor c=1.12535e-17
C159 (\9\:VDD VSS) capacitor c=2.54014e-17
C160 (\10\:VDD VSS) capacitor c=2.84413e-17
C161 (\22\:VDD VSS) capacitor c=1.09043e-17
Rk8 (\5\:CK CK) resistor r=0.05475 c=0
Rk51 (D \5\:D) resistor r=0.08319 c=0
Rk2 (\4\:QN QN) resistor r=0.07348 c=0
Rk1 (\2\:QN \4\:QN) resistor r=0.2244 c=0
Rk47 (E \8\:E) resistor r=0.02903 c=0
Rk48 (\8\:E \9\:E) resistor r=0.2684 c=0
Rk54 (\2\:VDD \4\:VDD) resistor r=0.5338 c=0
Rk55 (\4\:VDD \5\:VDD) resistor r=0.5788 c=0
Rk56 (\5\:VDD \6\:VDD) resistor r=0.2229 c=0
Rk57 (\6\:VDD \7\:VDD) resistor r=0.2154 c=0
Rk58 (\7\:VDD \8\:VDD) resistor r=0.2856 c=0
Rk59 (\8\:VDD \9\:VDD) resistor r=0.1602 c=0
Rk60 (\9\:VDD \10\:VDD) resistor r=0.5059 c=0
Rk61 (\10\:VDD \11\:VDD) resistor r=0.2354 c=0
Rk62 (\5\:VDD \13\:VDD) resistor r=0.07358 c=0
Rk63 (\7\:VDD \15\:VDD) resistor r=0.1022 c=0
Rk64 (\9\:VDD \17\:VDD) resistor r=0.1022 c=0
Rk65 (\10\:VDD \19\:VDD) resistor r=0.3882 c=0
Rk66 (\11\:VDD \21\:VDD) resistor r=0.2628 c=0
Rk69 (\22\:VDD VDD) resistor r=0.2126 c=0
Rk67 (\11\:VDD \22\:VDD) resistor r=0.3388 c=0
Rk68 (\22\:VDD \24\:VDD) resistor r=0.2233 c=0
Rk6 (Q \2\:Q) resistor r=0.05094 c=0
Rk7 (Q \4\:Q) resistor r=0.1768 c=0
Rk70 (\2\:VSS \4\:VSS) resistor r=0.4677 c=0
Rk71 (\4\:VSS \5\:VSS) resistor r=0.3708 c=0
Rk72 (\5\:VSS \6\:VSS) resistor r=0.1375 c=0
Rk73 (\6\:VSS \7\:VSS) resistor r=0.04242 c=0
Rk74 (\7\:VSS \8\:VSS) resistor r=0.2003 c=0
Rk75 (\8\:VSS \9\:VSS) resistor r=0.1001 c=0
Rk76 (\9\:VSS \10\:VSS) resistor r=0.3723 c=0
Rk77 (\10\:VSS \11\:VSS) resistor r=0.3272 c=0
Rk78 (\11\:VSS \12\:VSS) resistor r=0.1276 c=0
Rk79 (\12\:VSS \13\:VSS) resistor r=0.4683 c=0
Rk80 (\13\:VSS \14\:VSS) resistor r=0.1552 c=0
Rk81 (\14\:VSS \15\:VSS) resistor r=0.1878 c=0
Rk82 (\15\:VSS \16\:VSS) resistor r=0.1126 c=0
Rk83 (\16\:VSS \17\:VSS) resistor r=0.1878 c=0
Rk85 (\18\:VSS VSS) resistor r=0.1 c=0
Rk84 (\17\:VSS \18\:VSS) resistor r=0.1126 c=0
Rk86 (\5\:VSS \20\:VSS) resistor r=0.1854 c=0
Rk87 (\6\:VSS \22\:VSS) resistor r=0.1854 c=0
Rk88 (\8\:VSS \24\:VSS) resistor r=0.2524 c=0
Rk89 (\10\:VSS \26\:VSS) resistor r=0.04328 c=0
Rk90 (\12\:VSS \28\:VSS) resistor r=0.2805 c=0
Rk91 (\13\:VSS \30\:VSS) resistor r=0.07358 c=0
Rk92 (\15\:VSS \32\:VSS) resistor r=0.07358 c=0
Rk93 (\17\:VSS \34\:VSS) resistor r=0.07358 c=0
Rk29 (RN \4\:RN) resistor r=0.1689 c=0
Rk3 (\6\:qint \7\:qint) resistor r=0.1176 c=0
Rk4 (\7\:qint \8\:qint) resistor r=0.1192 c=0
Rk5 (\7\:qint \10\:qint) resistor r=0.1056 c=0
Rk33 (\14\:qbint \15\:qbint) resistor r=1.9541 c=0
Rk34 (\15\:qbint \16\:qbint) resistor r=0.5433 c=0
Rk35 (\16\:qbint \18\:qbint) resistor r=0.07984 c=0
Rk36 (\18\:qbint \19\:qbint) resistor r=0.421 c=0
Rk37 (\15\:qbint \20\:qbint) resistor r=0.04368 c=0
Rk38 (\16\:qbint \22\:qbint) resistor r=0.2761 c=0
Rk17 (\12\:CKb \13\:CKb) resistor r=0.2329 c=0
Rk18 (\13\:CKb \14\:CKb) resistor r=0.6727 c=0
Rk19 (\14\:CKb \15\:CKb) resistor r=0.6357 c=0
Rk20 (\15\:CKb \16\:CKb) resistor r=0.2131 c=0
Rk21 (\16\:CKb \18\:CKb) resistor r=0.6107 c=0
Rk22 (\14\:CKb \19\:CKb) resistor r=0.2285 c=0
Rk23 (\15\:CKb \20\:CKb) resistor r=0.3593 c=0
Rk24 (\16\:CKb \21\:CKb) resistor r=0.04287 c=0
Rk25 (\18\:CKb \23\:CKb) resistor r=0.3113 c=0
Rk9 (\5\:n30 \6\:n30) resistor r=0.2465 c=0
Rk10 (\6\:n30 \7\:n30) resistor r=0.2913 c=0
Rk11 (\6\:n30 \9\:n30) resistor r=0.1274 c=0
Rk12 (\5\:mout \6\:mout) resistor r=0.2623 c=0
Rk13 (\6\:mout \8\:mout) resistor r=0.2355 c=0
Rk14 (\6\:mout \10\:mout) resistor r=0.1379 c=0
Rk26 (\7\:CKbb \8\:CKbb) resistor r=0.1171 c=0
Rk27 (\8\:CKbb \9\:CKbb) resistor r=0.3948 c=0
Rk28 (\8\:CKbb \11\:CKbb) resistor r=0.2213 c=0
Rk15 (\5\:n20 \7\:n20) resistor r=0.3957 c=0
Rk16 (\7\:n20 \8\:n20) resistor r=0.4817 c=0
Rk41 (\5\:Dp \7\:Dp) resistor r=0.7688 c=0
Rk42 (\7\:Dp \8\:Dp) resistor r=0.07676 c=0
Rk43 (\8\:Dp \9\:Dp) resistor r=1.2187 c=0
Rk44 (\8\:Dp \10\:Dp) resistor r=0.6473 c=0
Rk45 (\10\:Dp \12\:Dp) resistor r=0.0496 c=0
Rk46 (\10\:Dp \14\:Dp) resistor r=0.3172 c=0
Rk30 (\4\:RNb \5\:RNb) resistor r=0.3251 c=0
Rk31 (\5\:RNb \7\:RNb) resistor r=0.2296 c=0
Rk32 (\5\:RNb \9\:RNb) resistor r=0.2124 c=0
Rk49 (\5\:Eb \7\:Eb) resistor r=0.2817 c=0
Rk50 (\7\:Eb \8\:Eb) resistor r=0.8339 c=0
Rk52 (\5\:Db \6\:Db) resistor r=0.871 c=0
Rk53 (\5\:Db \8\:Db) resistor r=0.2562 c=0
Rk39 (\2\:n2 \4\:n2) resistor r=0.3108 c=0
Rk40 (\2\:n3 \4\:n3) resistor r=0.4708 c=0
Rl10 (\1\:CK \2\:CK) resistor r=49.7141 c=0
Rl12 (\2\:CK \4\:CK) resistor r=34.3295 c=0
Rl11 (\2\:CK \3\:CK) resistor r=0.5166 c=0
Rl49 (\1\:D \2\:D) resistor r=42.0262 c=0
Rl51 (\2\:D \4\:D) resistor r=53.5647 c=0
Rl50 (\2\:D \3\:D) resistor r=3.1741 c=0
Rl43 (\2\:E \3\:E) resistor r=63.4387 c=0
Rl42 (\1\:E \2\:E) resistor r=134.41 c=0
Rl46 (\4\:E \5\:E) resistor r=49.2335 c=0
Rl48 (\5\:E \7\:E) resistor r=39.6181 c=0
Rl47 (\5\:E \6\:E) resistor r=92.681 c=0
Rl34 (\1\:RN \2\:RN) resistor r=24.2328 c=0
Rl35 (\2\:RN \3\:RN) resistor r=137.694 c=0
Rl1 (qint \2\:qint) resistor r=0.5213 c=0
Rl3 (\2\:qint \4\:qint) resistor r=49.7141 c=0
Rl2 (\2\:qint \3\:qint) resistor r=34.3295 c=0
Rl38 (\11\:qbint \12\:qbint) resistor r=211.104 c=0
Rl15 (\8\:qbint \9\:qbint) resistor r=145.073 c=0
Rl39 (\12\:qbint \13\:qbint) resistor r=30.0021 c=0
Rl16 (\9\:qbint \10\:qbint) resistor r=24.2328 c=0
Rl8 (\5\:qbint \6\:qbint) resistor r=24.2328 c=0
Rl4 (qbint \2\:qbint) resistor r=28.0797 c=0
Rl7 (\2\:qbint \5\:qbint) resistor r=60.772 c=0
Rl9 (\3\:qbint \7\:qbint) resistor r=60.772 c=0
Rl6 (\3\:qbint \4\:qbint) resistor r=28.0797 c=0
Rl5 (\2\:qbint \3\:qbint) resistor r=141.671 c=0
Rl32 (\9\:CKb \10\:CKb) resistor r=89.6174 c=0
Rl33 (\10\:CKb \11\:CKb) resistor r=24.2328 c=0
Rl29 (\7\:CKb \8\:CKb) resistor r=24.2328 c=0
Rl24 (\5\:CKb \6\:CKb) resistor r=37.2302 c=0
Rl18 (\3\:CKb \4\:CKb) resistor r=39.6174 c=0
Rl17 (CKb \2\:CKb) resistor r=71.8456 c=0
Rl13 (n30 \2\:n30) resistor r=87.2302 c=0
Rl14 (\2\:n30 \3\:n30) resistor r=29.5379 c=0
Rl21 (mout \2\:mout) resistor r=38.6163 c=0
Rl23 (\2\:mout \4\:mout) resistor r=82.5332 c=0
Rl22 (\2\:mout \3\:mout) resistor r=4.287 c=0
Rl28 (\4\:CKbb \5\:CKbb) resistor r=174.131 c=0
Rl27 (\3\:CKbb \4\:CKbb) resistor r=459.181 c=0
Rl25 (CKbb \2\:CKbb) resistor r=28.079 c=0
Rl26 (\2\:CKbb \3\:CKbb) resistor r=166.427 c=0
Rl19 (n20 \2\:n20) resistor r=24.2328 c=0
Rl20 (\2\:n20 \3\:n20) resistor r=89.6174 c=0
Rl30 (Dp \2\:Dp) resistor r=24.2328 c=0
Rl31 (\2\:Dp \3\:Dp) resistor r=145.72 c=0
Rl36 (RNb \2\:RNb) resistor r=93.9465 c=0
Rl37 (\2\:RNb \3\:RNb) resistor r=85.7713 c=0
Rl40 (Eb \2\:Eb) resistor r=119.922 c=0
Rl41 (\2\:Eb \3\:Eb) resistor r=44.9225 c=0
Rl44 (Db \2\:Db) resistor r=223.077 c=0
Rl45 (Db \3\:Db) resistor r=24.2328 c=0
Rz1 (\3\:QN \4\:QN) resistor r=75 c=0
Rz15 (\3\:VDD \4\:VDD) resistor r=6.25 c=0
Rz16 (\3\:VDD \6\:VDD) resistor r=18.75 c=0
Rz17 (\3\:VDD \8\:VDD) resistor r=12.5 c=0
Rz18 (\3\:VDD \11\:VDD) resistor r=6.25 c=0
Rz3 (\1\:Q \2\:Q) resistor r=75 c=0
Rz19 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz20 (\19\:VSS \20\:VSS) resistor r=75 c=0
Rz21 (\21\:VSS \22\:VSS) resistor r=75 c=0
Rz22 (\23\:VSS \24\:VSS) resistor r=75 c=0
Rz23 (\25\:VSS \26\:VSS) resistor r=75 c=0
Rz24 (\27\:VSS \28\:VSS) resistor r=75 c=0
Rz25 (\29\:VSS \30\:VSS) resistor r=75 c=0
Rz26 (\31\:VSS \32\:VSS) resistor r=75 c=0
Rz27 (\33\:VSS \34\:VSS) resistor r=75 c=0
Rz2 (\9\:qint \10\:qint) resistor r=75 c=0
Rz10 (\21\:qbint \22\:qbint) resistor r=75 c=0
Rz7 (\17\:CKb \18\:CKb) resistor r=75 c=0
Rz4 (\8\:n30 \9\:n30) resistor r=75 c=0
Rz5 (\9\:mout \10\:mout) resistor r=75 c=0
Rz8 (\10\:CKbb \11\:CKbb) resistor r=75 c=0
Rz6 (\4\:n20 \5\:n20) resistor r=75 c=0
Rz11 (\4\:Dp \5\:Dp) resistor r=75 c=0
Rz12 (\6\:Dp \7\:Dp) resistor r=75 c=0
Rz9 (\8\:RNb \9\:RNb) resistor r=75 c=0
Rz13 (\6\:Eb \7\:Eb) resistor r=75 c=0
Rz14 (\7\:Db \8\:Db) resistor r=75 c=0
Ry1 (\1\:QN \2\:QN) resistor r=62 c=0
Ry19 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry20 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry21 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry22 (\16\:VDD \17\:VDD) resistor r=62 c=0
Ry23 (\18\:VDD \19\:VDD) resistor r=62 c=0
Ry24 (\20\:VDD \21\:VDD) resistor r=62 c=0
Ry25 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry3 (\3\:Q \4\:Q) resistor r=62 c=0
Ry26 (\3\:VSS \4\:VSS) resistor r=8.8571 c=0
Ry27 (\3\:VSS \7\:VSS) resistor r=15.5 c=0
Ry28 (\3\:VSS \9\:VSS) resistor r=31 c=0
Ry29 (\3\:VSS \11\:VSS) resistor r=5.1667 c=0
Ry30 (\3\:VSS \14\:VSS) resistor r=20.6667 c=0
Ry31 (\3\:VSS \16\:VSS) resistor r=20.6667 c=0
Ry32 (\3\:VSS \18\:VSS) resistor r=20.6667 c=0
Ry2 (\5\:qint \6\:qint) resistor r=62 c=0
Ry10 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry7 (\22\:CKb \23\:CKb) resistor r=62 c=0
Ry4 (\4\:n30 \5\:n30) resistor r=62 c=0
Ry5 (\7\:mout \8\:mout) resistor r=62 c=0
Ry8 (\6\:CKbb \7\:CKbb) resistor r=62 c=0
Ry6 (\6\:n20 \7\:n20) resistor r=62 c=0
Ry15 (\11\:Dp \12\:Dp) resistor r=62 c=0
Ry16 (\13\:Dp \14\:Dp) resistor r=62 c=0
Ry9 (\6\:RNb \7\:RNb) resistor r=62 c=0
Ry17 (\4\:Eb \5\:Eb) resistor r=62 c=0
Ry18 (\4\:Db \5\:Db) resistor r=62 c=0
Ry11 (n2 \2\:n2) resistor r=62 c=0
Ry12 (\3\:n2 \4\:n2) resistor r=62 c=0
Ry13 (n3 \2\:n3) resistor r=62 c=0
Ry14 (\3\:n3 \4\:n3) resistor r=62 c=0
Rx2 (\3\:CK \5\:CK) resistor r=45 c=0
Rx21 (\3\:D \5\:D) resistor r=45 c=0
Rx18 (\6\:E \8\:E) resistor r=45 c=0
Rx19 (\2\:E \9\:E) resistor r=45 c=0
Rx12 (\2\:RN \4\:RN) resistor r=45 c=0
Rx1 (qint \8\:qint) resistor r=45 c=0
Rx14 (\13\:qbint \14\:qbint) resistor r=45 c=0
Rx15 (\6\:qbint \19\:qbint) resistor r=45 c=0
Rx16 (\10\:qbint \20\:qbint) resistor r=45 c=0
Rx6 (\10\:CKb \12\:CKb) resistor r=45 c=0
Rx7 (\8\:CKb \13\:CKb) resistor r=45 c=0
Rx8 (\6\:CKb \19\:CKb) resistor r=45 c=0
Rx9 (\4\:CKb \20\:CKb) resistor r=45 c=0
Rx10 (\2\:CKb \21\:CKb) resistor r=45 c=0
Rx3 (\2\:n30 \7\:n30) resistor r=45 c=0
Rx4 (\3\:mout \5\:mout) resistor r=45 c=0
Rx11 (\2\:CKbb \9\:CKbb) resistor r=45 c=0
Rx5 (\2\:n20 \8\:n20) resistor r=45 c=0
Rx17 (Dp \9\:Dp) resistor r=45 c=0
Rx13 (\2\:RNb \4\:RNb) resistor r=45 c=0
Rx20 (\2\:Eb \8\:Eb) resistor r=45 c=0
Rx22 (\3\:Db \6\:Db) resistor r=45 c=0
mn57 (\3\:QN \3\:qint \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.537e-14 ps=1.6e-06 pd=6.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.75e-07 sb=3.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\9\:qint \4\:qbint \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55 (\1\:Q qbint \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.35e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (net496 \8\:qbint \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.54e-14 ad=8.7e-15 ps=1.65e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn20 (\17\:CKb \4\:CK \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.19e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\21\:qbint \3\:n30 \29\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.54e-14 ad=2.9e-14 ps=1.65e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn51 (\8\:n30 CKb net496 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.9e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn40 (\8\:n30 \4\:CKbb \9\:mout VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.147e-14 ad=2.32e-14 ps=1e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.695e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\9\:mout \3\:n20 \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.632e-14 ad=5.147e-14 ps=1.11e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.125e-06 sb=1.295e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (net516 mout \27\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.632e-14 ad=8.7e-15 ps=1.11e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.455e-06 sb=9.65e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\4\:n20 \3\:CKbb net516 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=4.132e-14 ps=4.1e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.56e-06 sb=8.6e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn26 (\4\:n20 \7\:CKb n21 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.957e-14 ad=4.132e-14 ps=5.6e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.89e-06 sb=5.3e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn25 (n21 \2\:Dp \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.407e-14 ad=1.957e-14 ps=1.63e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=3.5e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn21 (\10\:CKbb \11\:CKb \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.407e-14 ad=2.03e-14 ps=1.63e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn2 (\8\:RNb \3\:RN \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.567e-14 ad=2.32e-14 ps=9.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=8.4e-07 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
mn3 (\6\:Dp RNb \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.567e-14 ad=2.32e-14 ps=9.2e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=4.8e-07 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
mn5 (\6\:Dp \11\:qbint n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2.75e-07 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
mn4 (n0 \3\:Eb \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.485e-14 ad=8.7e-15 ps=8e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.3e-07 sb=1.7e-07 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
mn6 (n1 \1\:E \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn7 (\4\:Dp \2\:Db n1 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=7.00131 \
        scb=0.00386446 scc=3.38236e-05 m=(1)
mn0 (\6\:Eb \7\:E \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.03e-14 ps=6.9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn1 (\7\:Db \4\:D \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=2.32e-14 ps=6.9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.85e-07 sb=1.6e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mp56 (\5\:qint \7\:qbint \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=5.515e-14 ad=3.01e-14 ps=1.45e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.7e-07 sb=1.4e-07 sd=160n sca=47.2218 \
        scb=0.0292973 scc=0.00588575 m=(1)
mp55 (\3\:Q \5\:qbint \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.805e-14 ad=3.01e-14 ps=1.51e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.4e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp20 (\22\:CKb \1\:CK \20\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.805e-14 ad=3.117e-14 ps=1.51e-06 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.35e-07 sb=1.45e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp45 (\17\:qbint n30 \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.87e-14 ps=8.3e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-07 sb=2e-06 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp50 (net411 \9\:qbint \18\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.3e-14 ad=1.29e-14 ps=8.3e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.25e-07 sb=1.975e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp51 (\4\:n30 \5\:CKbb net411 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.87e-14 ps=5.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.3e-07 sb=1.87e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp40 (\4\:n30 \3\:CKb \7\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.558e-14 ad=3.87e-14 ps=1.04e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=1.645e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp30 (\7\:mout n20 \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=6.558e-14 ps=1.64e-06 pd=1.04e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.105e-06 sb=1.295e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp35 (net427 \4\:mout \16\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=1.29e-14 ps=1.64e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.37e-06 sb=1.03e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp25 (n22 \3\:Dp \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=2.902e-14 ps=1.64e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.995e-06 sb=4.05e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp36 (\6\:n20 \5\:CKb net427 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=6.342e-14 ps=5.5e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.475e-06 sb=9.25e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp26 (\6\:n20 CKbb n22 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.902e-14 ad=6.342e-14 ps=7e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.815e-06 sb=5.85e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp21 (\6\:CKbb \9\:CKb \14\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.35e-14 ad=3.01e-14 ps=1.64e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp2 (\6\:RNb \1\:RN \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.638e-14 ad=4.085e-14 ps=1.87e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.9e-07 sb=8.1e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp3 (\3\:n2 \3\:RNb \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.638e-14 ad=3.44e-14 ps=1.87e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=5.5e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp5 (n3 \12\:qbint \3\:n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.44e-14 ps=7.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.55e-07 sb=3.45e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp4 (n3 Eb n2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.01e-14 \
        ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=8.6e-07 sb=1.4e-07 sd=160n sca=20.4333 scb=0.0198015 \
        scc=0.00193653 m=(1)
mp6 (\11\:Dp \3\:E \3\:n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.01e-14 ps=7.6e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.6e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp7 (\13\:Dp Db \3\:n3 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.548e-14 ad=3.225e-14 ps=7.6e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.5e-07 sb=1.5e-07 sd=160n sca=20.4333 \
        scb=0.0198015 scc=0.00193653 m=(1)
mp0 (\4\:Eb \4\:E \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=47.1147 \
        scb=0.0291776 scc=0.00588536 m=(1)
mp1 (\4\:Db \1\:D \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.23e-14 ad=3.01e-14 ps=1.62e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=51.1829 \
        scb=0.0357894 scc=0.00602791 m=(1)
ends EDFFTRXL
// End of subcircuit definition.

// Generated for: spectre (May  9 14:49:06 2012 )
// Library name: gsclib045
// Cell name: EDFFX1
// View name: extracted

simulator lang=spectre

subckt EDFFX1 CK D E Q QN VDD VSS
mp20 (\10\:Ckb \1\:CK \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.3e-14 ad=3.44e-14 ps=8.3e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=4.15e-07 sd=160n sca=18.4817 \
        scb=0.0199259 scc=0.00053385 m=(1)
C1 (D VSS) capacitor c=8.40914e-17
C2 (Q VSS) capacitor c=2.86825e-17
C3 (CK VSS) capacitor c=6.57707e-17
C4 (VDD VSS) capacitor c=3.25093e-16
C5 (Ckb VSS) capacitor c=8.35467e-17
C6 (CKbb VSS) capacitor c=3.21438e-17
C7 (n20 VSS) capacitor c=5.70908e-17
C8 (Db VSS) capacitor c=1.16501e-16
C9 (mout VSS) capacitor c=6.12923e-17
C10 (n30 VSS) capacitor c=7.69103e-17
C11 (qbint VSS) capacitor c=3.07172e-17
C12 (Eb VSS) capacitor c=3.85503e-17
C13 (qint VSS) capacitor c=3.83482e-17
C14 (net342 VSS) capacitor c=1.45033e-18
C15 (net362 VSS) capacitor c=1.61612e-18
C16 (\5\:qbint VSS) capacitor c=2.25899e-17
C17 (\8\:qbint VSS) capacitor c=3.0121e-17
C18 (\5\:E VSS) capacitor c=2.06804e-17
C19 (\1\:D VSS) capacitor c=3.91441e-17
C20 (\1\:E VSS) capacitor c=4.01903e-17
C21 (\4\:qbint VSS) capacitor c=4.56902e-17
C22 (\7\:CKbb VSS) capacitor c=5.26026e-17
C23 (\2\:Ckb VSS) capacitor c=1.29725e-16
C24 (\3\:Ckb VSS) capacitor c=1.2553e-16
C25 (\9\:Ckb VSS) capacitor c=3.93191e-17
C26 (\1\:CK VSS) capacitor c=3.30315e-17
C27 (\4\:qint VSS) capacitor c=2.88757e-17
C28 (\9\:qbint VSS) capacitor c=1.74844e-17
C29 (\10\:qbint VSS) capacitor c=2.12128e-17
C30 (\7\:E VSS) capacitor c=4.47684e-17
C31 (\3\:D VSS) capacitor c=4.24616e-17
C32 (\3\:E VSS) capacitor c=4.98095e-17
C33 (\3\:Eb VSS) capacitor c=6.58502e-17
C34 (\4\:n30 VSS) capacitor c=3.04391e-17
C35 (\3\:qbint VSS) capacitor c=6.42368e-17
C36 (\5\:CKbb VSS) capacitor c=3.27353e-17
C37 (\4\:n20 VSS) capacitor c=3.0957e-17
C38 (\3\:mout VSS) capacitor c=6.93736e-17
C39 (\3\:CKbb VSS) capacitor c=8.17024e-17
C40 (\8\:Ckb VSS) capacitor c=2.87621e-17
C41 (\7\:Ckb VSS) capacitor c=2.40173e-17
C42 (\3\:CK VSS) capacitor c=3.70067e-17
C43 (\3\:qint VSS) capacitor c=1.45802e-17
C44 (\7\:qbint VSS) capacitor c=1.49183e-17
C45 (\6\:E VSS) capacitor c=2.72978e-17
C46 (\2\:D VSS) capacitor c=4.7832e-17
C47 (\2\:Eb VSS) capacitor c=7.87892e-17
C48 (\4\:E VSS) capacitor c=4.97094e-17
C49 (\2\:E VSS) capacitor c=2.09234e-17
C50 (\3\:n30 VSS) capacitor c=1.81454e-17
C51 (\8\:CKbb VSS) capacitor c=3.91934e-17
C52 (\6\:CKbb VSS) capacitor c=4.21338e-17
C53 (\3\:n20 VSS) capacitor c=1.60361e-17
C54 (\2\:mout VSS) capacitor c=4.92632e-17
C55 (\4\:CKbb VSS) capacitor c=2.57274e-17
C56 (\2\:CKbb VSS) capacitor c=4.73208e-17
C57 (\6\:Ckb VSS) capacitor c=1.75889e-17
C58 (\2\:CK VSS) capacitor c=4.29267e-17
C59 (\1\:QN VSS) capacitor c=4.08343e-17
C60 (\13\:VDD VSS) capacitor c=2.54405e-17
C61 (\9\:qint VSS) capacitor c=2.6277e-17
C62 (\15\:VDD VSS) capacitor c=7.38291e-17
C63 (\1\:Q VSS) capacitor c=7.64291e-17
C64 (\8\:Eb VSS) capacitor c=7.13797e-17
C65 (\17\:VDD VSS) capacitor c=3.50188e-17
C66 (\3\:Db VSS) capacitor c=2.44731e-16
C67 (\16\:qbint VSS) capacitor c=4.51059e-17
C68 (\19\:VDD VSS) capacitor c=2.37828e-17
C69 (\8\:n30 VSS) capacitor c=7.39705e-17
C70 (\4\:mout VSS) capacitor c=3.24518e-17
C71 (\21\:VDD VSS) capacitor c=4.809e-17
C72 (\9\:n20 VSS) capacitor c=4.21448e-17
C73 (\5\:Db VSS) capacitor c=2.54832e-16
C74 (\18\:CKbb VSS) capacitor c=8.47138e-17
C75 (\23\:VDD VSS) capacitor c=3.49615e-17
C76 (\10\:Ckb VSS) capacitor c=4.55684e-17
C77 (\1\:VDD VSS) capacitor c=1.20038e-16
C78 (\3\:QN VSS) capacitor c=3.63151e-17
C79 (\7\:qint VSS) capacitor c=2.17528e-17
C80 (\3\:Q VSS) capacitor c=4.93988e-17
C81 (\4\:Eb VSS) capacitor c=4.37915e-17
C82 (\12\:qbint VSS) capacitor c=2.22311e-16
C83 (\5\:n30 VSS) capacitor c=5.57287e-17
C84 (\8\:mout VSS) capacitor c=7.34914e-17
C85 (\7\:n20 VSS) capacitor c=3.82766e-17
C86 (\7\:Db VSS) capacitor c=9.60618e-17
C87 (\13\:CKbb VSS) capacitor c=9.15246e-17
C88 (\13\:Ckb VSS) capacitor c=1.85512e-17
C89 (\2\:n20 VSS) capacitor c=2.35743e-17
C90 (\4\:Ckb VSS) capacitor c=7.1512e-17
C91 (\5\:Ckb VSS) capacitor c=3.50211e-17
C92 (\2\:qbint VSS) capacitor c=2.74421e-17
C93 (\2\:n30 VSS) capacitor c=2.1496e-17
C94 (\6\:qbint VSS) capacitor c=1.14699e-17
C95 (\2\:qint VSS) capacitor c=5.8413e-18
C96 (\12\:Ckb VSS) capacitor c=4.65794e-17
C97 (\15\:Ckb VSS) capacitor c=5.214e-17
C98 (\4\:CK VSS) capacitor c=4.6594e-17
C99 (\5\:n20 VSS) capacitor c=4.97e-17
C100 (\6\:n20 VSS) capacitor c=5.4292e-17
C101 (\6\:mout VSS) capacitor c=6.12211e-17
C102 (\7\:mout VSS) capacitor c=5.71228e-17
C103 (\9\:CKbb VSS) capacitor c=2.54131e-17
C104 (\10\:CKbb VSS) capacitor c=1.25691e-16
C105 (\11\:CKbb VSS) capacitor c=1.00821e-16
C106 (\12\:CKbb VSS) capacitor c=6.5197e-17
C107 (\15\:CKbb VSS) capacitor c=4.9654e-17
C108 (\17\:CKbb VSS) capacitor c=7.39584e-17
C109 (\7\:n30 VSS) capacitor c=6.18913e-17
C110 (\10\:n30 VSS) capacitor c=4.12475e-17
C111 (\4\:D VSS) capacitor c=5.16035e-17
C112 (\8\:E VSS) capacitor c=6.40443e-17
C113 (\9\:E VSS) capacitor c=1.07244e-16
C114 (\10\:E VSS) capacitor c=6.73414e-17
C115 (\11\:E VSS) capacitor c=9.61789e-17
C116 (\6\:Eb VSS) capacitor c=1.0202e-16
C117 (\7\:Eb VSS) capacitor c=1.09414e-16
C118 (\11\:qbint VSS) capacitor c=1.85183e-16
C119 (\14\:qbint VSS) capacitor c=5.75236e-17
C120 (\15\:qbint VSS) capacitor c=4.36043e-17
C121 (\5\:qint VSS) capacitor c=2.1631e-17
C122 (\6\:qint VSS) capacitor c=1.5675e-17
C123 (\3\:VDD VSS) capacitor c=3.90566e-18
C124 (\4\:VDD VSS) capacitor c=1.51441e-17
C125 (\6\:VDD VSS) capacitor c=3.27026e-17
C126 (\7\:VDD VSS) capacitor c=3.35568e-17
C127 (\11\:VDD VSS) capacitor c=6.35852e-19
Rk25 (\4\:D D) resistor r=0.02915 c=0
Rk33 (Q \2\:Q) resistor r=0.1437 c=0
Rk34 (Q \4\:Q) resistor r=0.1526 c=0
Rk4 (\4\:CK CK) resistor r=0.1913 c=0
Rk42 (\2\:QN QN) resistor r=0.3009 c=0
Rk43 (QN \4\:QN) resistor r=0.05391 c=0
Rk61 (\2\:VSS \3\:VSS) resistor r=0.1503 c=0
Rk62 (\3\:VSS \4\:VSS) resistor r=0.1008 c=0
Rk63 (\4\:VSS \5\:VSS) resistor r=0.03488 c=0
Rk64 (\5\:VSS \6\:VSS) resistor r=0.2153 c=0
Rk65 (\6\:VSS \7\:VSS) resistor r=0.3556 c=0
Rk66 (\7\:VSS \8\:VSS) resistor r=0.4458 c=0
Rk67 (\8\:VSS \9\:VSS) resistor r=0.07498 c=0
Rk68 (\9\:VSS \10\:VSS) resistor r=0.5108 c=0
Rk69 (\10\:VSS \11\:VSS) resistor r=0.3155 c=0
Rk70 (\11\:VSS \12\:VSS) resistor r=0.303 c=0
Rk72 (\13\:VSS VSS) resistor r=0.04986 c=0
Rk71 (\12\:VSS \13\:VSS) resistor r=0.09753 c=0
Rk73 (\3\:VSS \15\:VSS) resistor r=0.1202 c=0
Rk74 (\5\:VSS \17\:VSS) resistor r=0.07415 c=0
Rk75 (\7\:VSS \19\:VSS) resistor r=0.1219 c=0
Rk76 (\9\:VSS \21\:VSS) resistor r=0.3279 c=0
Rk77 (\10\:VSS \23\:VSS) resistor r=0.102 c=0
Rk78 (\12\:VSS \25\:VSS) resistor r=0.2812 c=0
Rk44 (\2\:VDD \3\:VDD) resistor r=0.105 c=0
Rk45 (\3\:VDD \4\:VDD) resistor r=0.1976 c=0
Rk46 (\4\:VDD \5\:VDD) resistor r=0.4483 c=0
Rk47 (\5\:VDD \6\:VDD) resistor r=0.05493 c=0
Rk48 (\6\:VDD \7\:VDD) resistor r=0.5509 c=0
Rk49 (\7\:VDD \8\:VDD) resistor r=0.2454 c=0
Rk50 (\8\:VDD \9\:VDD) resistor r=0.2654 c=0
Rk51 (\9\:VDD \10\:VDD) resistor r=0.2855 c=0
Rk52 (\10\:VDD \11\:VDD) resistor r=0.303 c=0
Rk54 (\12\:VDD VDD) resistor r=0.04986 c=0
Rk53 (\11\:VDD \12\:VDD) resistor r=0.09753 c=0
Rk55 (\3\:VDD \14\:VDD) resistor r=0.3034 c=0
Rk56 (\4\:VDD \16\:VDD) resistor r=0.3955 c=0
Rk57 (\6\:VDD \18\:VDD) resistor r=0.2525 c=0
Rk58 (\7\:VDD \20\:VDD) resistor r=0.102 c=0
Rk59 (\9\:VDD \22\:VDD) resistor r=0.2247 c=0
Rk60 (\11\:VDD \24\:VDD) resistor r=0.2724 c=0
Rk28 (\9\:E E) resistor r=0.591 c=0
Rk26 (\8\:E \9\:E) resistor r=0.298 c=0
Rk27 (\9\:E \10\:E) resistor r=0.4474 c=0
Rk29 (E \11\:E) resistor r=0.005986 c=0
Rk1 (\11\:Ckb \12\:Ckb) resistor r=0.3871 c=0
Rk2 (\12\:Ckb \14\:Ckb) resistor r=0.1224 c=0
Rk3 (\12\:Ckb \15\:Ckb) resistor r=0.2161 c=0
Rk11 (\9\:CKbb \10\:CKbb) resistor r=0.02782 c=0
Rk12 (\10\:CKbb \11\:CKbb) resistor r=0.881 c=0
Rk13 (\11\:CKbb \12\:CKbb) resistor r=0.2309 c=0
Rk14 (\12\:CKbb \14\:CKbb) resistor r=0.2964 c=0
Rk15 (\10\:CKbb \15\:CKbb) resistor r=0.2216 c=0
Rk16 (\11\:CKbb \16\:CKbb) resistor r=0.0153 c=0
Rk17 (\12\:CKbb \17\:CKbb) resistor r=0.3653 c=0
Rk18 (\14\:CKbb \19\:CKbb) resistor r=0.5279 c=0
Rk5 (\5\:n20 \6\:n20) resistor r=0.2834 c=0
Rk6 (\6\:n20 \8\:n20) resistor r=0.1271 c=0
Rk7 (\6\:n20 \10\:n20) resistor r=0.2466 c=0
Rk22 (\2\:Db \4\:Db) resistor r=0.6236 c=0
Rk23 (\4\:Db \6\:Db) resistor r=1.6561 c=0
Rk24 (\6\:Db \8\:Db) resistor r=0.5727 c=0
Rk8 (\5\:mout \6\:mout) resistor r=0.1508 c=0
Rk9 (\6\:mout \7\:mout) resistor r=0.2802 c=0
Rk10 (\6\:mout \9\:mout) resistor r=0.3002 c=0
Rk19 (\6\:n30 \7\:n30) resistor r=0.2364 c=0
Rk20 (\7\:n30 \9\:n30) resistor r=0.4212 c=0
Rk21 (\7\:n30 \10\:n30) resistor r=0.1677 c=0
Rk35 (\11\:qbint \13\:qbint) resistor r=1.6067 c=0
Rk36 (\13\:qbint \14\:qbint) resistor r=0.3925 c=0
Rk37 (\14\:qbint \15\:qbint) resistor r=0.1573 c=0
Rk38 (\14\:qbint \17\:qbint) resistor r=0.09343 c=0
Rk30 (\5\:Eb \6\:Eb) resistor r=0.2046 c=0
Rk31 (\6\:Eb \7\:Eb) resistor r=0.6985 c=0
Rk32 (\6\:Eb \9\:Eb) resistor r=0.4704 c=0
Rk39 (\5\:qint \6\:qint) resistor r=0.05315 c=0
Rk40 (\6\:qint \8\:qint) resistor r=0.09647 c=0
Rk41 (\6\:qint \10\:qint) resistor r=0.1264 c=0
Rl30 (\1\:D \2\:D) resistor r=106.461 c=0
Rl31 (\2\:D \3\:D) resistor r=77.6149 c=0
Rl1 (\1\:CK \2\:CK) resistor r=95.3867 c=0
Rl2 (\2\:CK \3\:CK) resistor r=99.2328 c=0
Rl32 (\5\:E \6\:E) resistor r=29.5379 c=0
Rl33 (\6\:E \7\:E) resistor r=154.538 c=0
Rl27 (\3\:E \4\:E) resistor r=89.8977 c=0
Rl26 (\1\:E \2\:E) resistor r=33.8482 c=0
Rl12 (Ckb \2\:Ckb) resistor r=237.593 c=0
Rl13 (\2\:Ckb \3\:Ckb) resistor r=389.516 c=0
Rl17 (\6\:Ckb \7\:Ckb) resistor r=35.7134 c=0
Rl14 (\3\:Ckb \4\:Ckb) resistor r=174.543 c=0
Rl18 (\4\:Ckb \8\:Ckb) resistor r=30.4507 c=0
Rl19 (\5\:Ckb \9\:Ckb) resistor r=135.772 c=0
Rl16 (\5\:Ckb \6\:Ckb) resistor r=15.7162 c=0
Rl15 (\4\:Ckb \5\:Ckb) resistor r=214.3 c=0
Rl11 (\7\:CKbb \8\:CKbb) resistor r=29.5379 c=0
Rl10 (\5\:CKbb \6\:CKbb) resistor r=39.1533 c=0
Rl4 (\3\:CKbb \4\:CKbb) resistor r=58.8482 c=0
Rl3 (CKbb \2\:CKbb) resistor r=62.9746 c=0
Rl7 (n20 \2\:n20) resistor r=102.726 c=0
Rl9 (\2\:n20 \4\:n20) resistor r=37.3411 c=0
Rl8 (\2\:n20 \3\:n20) resistor r=1.2301 c=0
Rl5 (mout \2\:mout) resistor r=24.2328 c=0
Rl6 (\2\:mout \3\:mout) resistor r=97.3098 c=0
Rl23 (n30 \2\:n30) resistor r=107.406 c=0
Rl25 (\2\:n30 \4\:n30) resistor r=34.3295 c=0
Rl24 (\2\:n30 \3\:n30) resistor r=1.2666 c=0
Rl36 (\7\:qbint \8\:qbint) resistor r=56.5101 c=0
Rl38 (\7\:qbint \10\:qbint) resistor r=24.5191 c=0
Rl20 (qbint \2\:qbint) resistor r=11.5001 c=0
Rl22 (\2\:qbint \4\:qbint) resistor r=34.3295 c=0
Rl21 (\2\:qbint \3\:qbint) resistor r=107.406 c=0
Rl34 (\5\:qbint \6\:qbint) resistor r=53.0797 c=0
Rl37 (\6\:qbint \9\:qbint) resistor r=35.772 c=0
Rl35 (\6\:qbint \7\:qbint) resistor r=35.7515 c=0
Rl28 (Eb \2\:Eb) resistor r=106.925 c=0
Rl29 (\2\:Eb \3\:Eb) resistor r=201.477 c=0
Rl39 (qint \2\:qint) resistor r=60.772 c=0
Rl41 (\2\:qint \4\:qint) resistor r=28.0797 c=0
Rl40 (\2\:qint \3\:qint) resistor r=34.9887 c=0
Rz9 (\3\:Q \4\:Q) resistor r=75 c=0
Rz12 (\3\:QN \4\:QN) resistor r=75 c=0
Rz18 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz19 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz20 (\18\:VSS \19\:VSS) resistor r=75 c=0
Rz21 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz22 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz23 (\24\:VSS \25\:VSS) resistor r=75 c=0
Rz13 (\1\:VDD \2\:VDD) resistor r=25 c=0
Rz14 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz15 (\1\:VDD \8\:VDD) resistor r=15 c=0
Rz16 (\1\:VDD \10\:VDD) resistor r=12.5 c=0
Rz17 (\1\:VDD \12\:VDD) resistor r=37.5 c=0
Rz1 (\13\:Ckb \14\:Ckb) resistor r=75 c=0
Rz4 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz2 (\7\:n20 \8\:n20) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\8\:mout \9\:mout) resistor r=75 c=0
Rz5 (\5\:n30 \6\:n30) resistor r=75 c=0
Rz10 (\12\:qbint \13\:qbint) resistor r=75 c=0
Rz8 (\4\:Eb \5\:Eb) resistor r=75 c=0
Rz11 (\7\:qint \8\:qint) resistor r=75 c=0
Ry9 (\1\:Q \2\:Q) resistor r=20.6667 c=0
Ry12 (\1\:QN \2\:QN) resistor r=20.6667 c=0
Ry19 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry20 (\1\:VSS \3\:VSS) resistor r=62 c=0
Ry21 (\1\:VSS \4\:VSS) resistor r=62 c=0
Ry22 (\1\:VSS \6\:VSS) resistor r=15.5 c=0
Ry23 (\1\:VSS \8\:VSS) resistor r=5.1667 c=0
Ry24 (\1\:VSS \11\:VSS) resistor r=10.3333 c=0
Ry25 (\1\:VSS \13\:VSS) resistor r=31 c=0
Ry13 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry14 (\15\:VDD \16\:VDD) resistor r=20.6667 c=0
Ry15 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry16 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry17 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry18 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry1 (\10\:Ckb \11\:Ckb) resistor r=62 c=0
Ry4 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry2 (\9\:n20 \10\:n20) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Ry3 (\4\:mout \5\:mout) resistor r=62 c=0
Ry5 (\8\:n30 \9\:n30) resistor r=62 c=0
Ry10 (\16\:qbint \17\:qbint) resistor r=62 c=0
Ry8 (\8\:Eb \9\:Eb) resistor r=62 c=0
Ry11 (\9\:qint \10\:qint) resistor r=62 c=0
Rx10 (\2\:D \4\:D) resistor r=45 c=0
Rx2 (\2\:CK \4\:CK) resistor r=45 c=0
Rx11 (\4\:E \8\:E) resistor r=45 c=0
Rx12 (\2\:E \10\:E) resistor r=45 c=0
Rx13 (\6\:E \11\:E) resistor r=45 c=0
Rx1 (\6\:Ckb \15\:Ckb) resistor r=45 c=0
Rx5 (\6\:CKbb \9\:CKbb) resistor r=45 c=0
Rx6 (\8\:CKbb \15\:CKbb) resistor r=45 c=0
Rx7 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \17\:CKbb) resistor r=45 c=0
Rx3 (\3\:n20 \5\:n20) resistor r=45 c=0
Rx4 (\2\:mout \7\:mout) resistor r=45 c=0
Rx9 (\3\:n30 \10\:n30) resistor r=45 c=0
Rx15 (\7\:qbint \11\:qbint) resistor r=45 c=0
Rx16 (qbint \15\:qbint) resistor r=45 c=0
Rx14 (\2\:Eb \7\:Eb) resistor r=45 c=0
Rx17 (\3\:qint \5\:qint) resistor r=45 c=0
mn20 (\13\:Ckb \3\:CK \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=4.15e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn21 (\13\:CKbb \7\:Ckb \24\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=3.045e-14 ps=6.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=2.1e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mn25 (\7\:Db \8\:Ckb \7\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.827e-14 ad=4.132e-14 ps=6.8e-07 pd=8.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.85e-07 sb=1.89034e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn36 (\7\:n20 \3\:CKbb net411 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.42e-15 ad=2.827e-14 ps=4.2e-07 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=1.79103e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn30 (\8\:mout \4\:n20 \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.41e-14 ad=3.988e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=1.63586e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn35 (net411 \3\:mout \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.41e-14 ad=9.43e-15 ps=1.6e-06 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=1.74552e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn40 (\8\:mout \5\:CKbb \5\:n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.988e-14 ad=3.988e-14 ps=8.4e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=1.50345e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn51 (\5\:n30 Ckb net415 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.015e-14 ad=3.988e-14 ps=4.3e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.54e-06 sb=1.27138e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn50 (net415 \3\:qbint \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.03e-14 ad=1.015e-14 ps=8.5e-07 pd=4.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.655e-06 sb=1.15638e-06 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn45 (\12\:qbint \4\:n30 \20\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=4.03e-14 ad=4.877e-14 ps=8.5e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.39902e-06 sb=1.05488e-06 sd=160n sca=19.867 \
        scb=0.0198061 scc=0.00201945 m=(1)
mn1 (\12\:qbint \3\:Eb Db VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.205e-14 ad=4.877e-14 ps=8.7e-07 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.37103e-06 sb=1.11e-06 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn3 (Db \3\:E n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=1.667e-14 \
        ad=4.205e-14 ps=5.2e-07 pd=8.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.50966e-06 sb=7.75e-07 sd=160n sca=15.2405 scb=0.016218 \
        scc=0.00104639 m=(1)
mn2 (n0 \3\:D \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.775e-14 ad=1.668e-14 ps=1.74e-06 pd=5.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.57586e-06 sb=6.15e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn0 (\4\:Eb \7\:E \18\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.775e-14 ad=2.03e-14 ps=1.74e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.77241e-06 sb=1.4e-07 sd=160n sca=15.2405 \
        scb=0.016218 scc=0.00104639 m=(1)
mn55 (\3\:Q \10\:qbint \16\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.545e-14 ad=4.16e-14 ps=1.73e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=2.31058e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn56 (\7\:qint \9\:qbint \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.545e-14 ad=2.03e-14 ps=1.73e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.55e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn57 (\3\:QN \4\:qint \14\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=5.04e-14 ad=3.64e-14 ps=1.5e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mp21 (\18\:CKbb \9\:Ckb \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.3e-14 ad=3.655e-14 ps=8.3e-07 pd=7.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.7e-07 sd=160n sca=13.2059 \
        scb=0.0110334 scc=0.000224619 m=(1)
mp25 (\9\:n20 CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.88733e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp36 (\9\:n20 \3\:Ckb net342 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=3.44e-14 ps=5.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.79674e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp35 (net342 mout \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.29e-14 ad=1.505e-14 ps=1.13e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=1.74593e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp30 (\4\:mout n20 \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.29e-14 ad=5.912e-14 ps=1.13e-06 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=1.62884e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp40 (\8\:n30 \2\:Ckb \4\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.912e-14 ad=4.73e-14 ps=9.8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.045e-06 sb=1.48744e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp51 (\8\:n30 \7\:CKbb net362 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.687e-14 ad=4.73e-14 ps=6.8e-07 pd=8.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.31e-06 sb=1.3536e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp50 (net362 \4\:qbint \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.585e-14 ad=2.687e-14 ps=1.6e-06 pd=6.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.48e-06 sb=1.1836e-06 sd=160n sca=13.9534 \
        scb=0.0134231 scc=0.000640578 m=(1)
mp45 (\16\:qbint n30 \19\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=9.585e-14 ad=5.415e-14 ps=1.6e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.26234e-06 sb=1.1075e-06 sd=160n sca=12.6932 \
        scb=0.0113709 scc=0.000458931 m=(1)
mp1 (\16\:qbint \1\:E \3\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.632e-14 ad=5.415e-14 ps=1.14e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.28407e-06 sb=1.3e-06 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp3 (\3\:Db Eb n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=3.333e-14 \
        ad=7.632e-14 ps=7.4e-07 pd=1.14e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.47198e-06 sb=9e-07 sd=160n sca=10.718 scb=0.00841932 \
        scc=0.00013813 m=(1)
mp2 (n1 \1\:D \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.245e-14 ad=3.333e-14 ps=1.29e-06 pd=7.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.56035e-06 sb=7e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp0 (\8\:Eb \5\:E \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.245e-14 ad=4.838e-14 ps=1.29e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.77023e-06 sb=2.25e-07 sd=160n sca=10.718 \
        scb=0.00841932 scc=0.00013813 m=(1)
mp55 (\1\:Q \8\:qbint \15\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=5.46e-14 ps=1.16e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.59808e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp56 (\9\:qint \5\:qbint \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=2.63e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=1.22326e-07 sd=160n sca=46.2776 \
        scb=0.0284965 scc=0.00588421 m=(1)
mp57 (\1\:QN qint \13\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=4.56e-14 ad=6.24e-14 ps=1.09e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.16923e-07 sb=1.6e-07 sd=160n sca=34.4399 \
        scb=0.0250891 scc=0.0034155 m=(1)
ends EDFFX1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:49:43 2012 )
// Library name: gsclib045
// Cell name: EDFFX2
// View name: extracted

simulator lang=spectre

subckt EDFFX2 CK D E Q QN VDD VSS
mp20 (\17\:Ckb \4\:CK \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=28.9181 \
        scb=0.0340412 scc=0.0022918 m=(1)
C1 (D VSS) capacitor c=4.89974e-17
C2 (QN VSS) capacitor c=5.13861e-17
C3 (CK VSS) capacitor c=7.75828e-17
C4 (VDD VSS) capacitor c=2.92522e-16
C5 (Q VSS) capacitor c=6.17647e-17
C6 (Ckb VSS) capacitor c=3.28592e-17
C7 (CKbb VSS) capacitor c=4.40314e-17
C8 (n20 VSS) capacitor c=3.78977e-17
C9 (Db VSS) capacitor c=9.18724e-17
C10 (mout VSS) capacitor c=7.51317e-17
C11 (n30 VSS) capacitor c=5.83902e-17
C12 (net415 VSS) capacitor c=1.90771e-18
C13 (qbint VSS) capacitor c=7.30547e-17
C14 (Eb VSS) capacitor c=5.54473e-17
C15 (n0 VSS) capacitor c=5.10789e-19
C16 (qint VSS) capacitor c=1.89687e-16
C17 (net342 VSS) capacitor c=7.55565e-19
C18 (net362 VSS) capacitor c=2.84036e-18
C19 (n1 VSS) capacitor c=1.5203e-18
C20 (\13\:qbint VSS) capacitor c=4.52249e-17
C21 (\4\:qbint VSS) capacitor c=5.55523e-16
C22 (\5\:E VSS) capacitor c=3.46236e-17
C23 (\3\:D VSS) capacitor c=9.0375e-17
C24 (\4\:Eb VSS) capacitor c=6.41817e-17
C25 (\1\:E VSS) capacitor c=4.1667e-17
C26 (\7\:CKbb VSS) capacitor c=7.11779e-17
C27 (\11\:Ckb VSS) capacitor c=5.26289e-17
C28 (\2\:Ckb VSS) capacitor c=8.6142e-17
C29 (\8\:Ckb VSS) capacitor c=5.25889e-17
C30 (\4\:CK VSS) capacitor c=3.4056e-17
C31 (\12\:qbint VSS) capacitor c=4.19151e-17
C32 (\7\:E VSS) capacitor c=3.8529e-17
C33 (\1\:D VSS) capacitor c=6.43799e-17
C34 (\3\:E VSS) capacitor c=5.62333e-17
C35 (\3\:Eb VSS) capacitor c=5.51436e-17
C36 (\3\:n30 VSS) capacitor c=4.49833e-17
C37 (\3\:qbint VSS) capacitor c=2.67484e-17
C38 (\10\:Ckb VSS) capacitor c=5.54362e-17
C39 (\6\:CKbb VSS) capacitor c=4.5419e-17
C40 (\4\:n20 VSS) capacitor c=4.49887e-17
C41 (\3\:mout VSS) capacitor c=5.31394e-17
C42 (\3\:CKbb VSS) capacitor c=8.44196e-17
C43 (\7\:Ckb VSS) capacitor c=3.19174e-17
C44 (\9\:Ckb VSS) capacitor c=2.52109e-17
C45 (\3\:CK VSS) capacitor c=5.85252e-17
C46 (\11\:qbint VSS) capacitor c=2.18643e-17
C47 (\6\:E VSS) capacitor c=2.95399e-17
C48 (\2\:D VSS) capacitor c=4.97038e-17
C49 (\4\:E VSS) capacitor c=5.32077e-17
C50 (\2\:E VSS) capacitor c=2.51503e-17
C51 (\2\:n30 VSS) capacitor c=2.68816e-17
C52 (\2\:qbint VSS) capacitor c=3.73073e-17
C53 (\8\:CKbb VSS) capacitor c=4.07349e-17
C54 (\12\:Ckb VSS) capacitor c=2.42635e-17
C55 (\5\:CKbb VSS) capacitor c=2.68102e-17
C56 (\3\:n20 VSS) capacitor c=1.9773e-17
C57 (\2\:mout VSS) capacitor c=4.61773e-17
C58 (\4\:CKbb VSS) capacitor c=2.8213e-17
C59 (\2\:CKbb VSS) capacitor c=4.47363e-17
C60 (\6\:Ckb VSS) capacitor c=2.61461e-17
C61 (\1\:CK VSS) capacitor c=2.47493e-17
C62 (\11\:qint VSS) capacitor c=2.53769e-17
C63 (\1\:VDD VSS) capacitor c=2.66155e-16
C64 (\1\:QN VSS) capacitor c=8.99797e-17
C65 (\1\:Q VSS) capacitor c=9.27964e-17
C66 (\9\:Eb VSS) capacitor c=8.57672e-17
C67 (\17\:VDD VSS) capacitor c=3.18094e-17
C68 (\3\:Db VSS) capacitor c=2.63753e-16
C69 (\23\:qbint VSS) capacitor c=7.22507e-17
C70 (\19\:VDD VSS) capacitor c=4.65128e-17
C71 (\5\:n30 VSS) capacitor c=1.15408e-16
C72 (\8\:mout VSS) capacitor c=6.3112e-17
C73 (\21\:VDD VSS) capacitor c=1.69658e-17
C74 (\7\:n20 VSS) capacitor c=3.85305e-17
C75 (\5\:Db VSS) capacitor c=2.5318e-16
C76 (\15\:CKbb VSS) capacitor c=8.05299e-17
C77 (\23\:VDD VSS) capacitor c=3.77062e-17
C78 (\17\:Ckb VSS) capacitor c=5.63868e-17
C79 (\4\:VDD VSS) capacitor c=7.85086e-17
C80 (\7\:qint VSS) capacitor c=2.56808e-17
C81 (\3\:QN VSS) capacitor c=3.35465e-17
C82 (\3\:Q VSS) capacitor c=3.75809e-17
C83 (\5\:Eb VSS) capacitor c=2.63231e-17
C84 (\17\:qbint VSS) capacitor c=1.42039e-16
C85 (\7\:n30 VSS) capacitor c=8.20776e-17
C86 (\6\:mout VSS) capacitor c=3.01241e-17
C87 (\9\:n20 VSS) capacitor c=5.76663e-17
C88 (\7\:Db VSS) capacitor c=7.87143e-17
C89 (\13\:CKbb VSS) capacitor c=1.00694e-16
C90 (\15\:Ckb VSS) capacitor c=1.97306e-17
C91 (\2\:CK VSS) capacitor c=3.01295e-17
C92 (\3\:Ckb VSS) capacitor c=5.98985e-17
C93 (\4\:Ckb VSS) capacitor c=4.31379e-17
C94 (\5\:Ckb VSS) capacitor c=9.97519e-18
C95 (\2\:n20 VSS) capacitor c=1.87517e-17
C96 (\2\:Eb VSS) capacitor c=5.39451e-17
C97 (\5\:CK VSS) capacitor c=4.47328e-17
C98 (\13\:Ckb VSS) capacitor c=4.40558e-17
C99 (\14\:Ckb VSS) capacitor c=3.84294e-17
C100 (\5\:n20 VSS) capacitor c=5.85809e-17
C101 (\6\:n20 VSS) capacitor c=4.64089e-17
C102 (\4\:mout VSS) capacitor c=4.95887e-17
C103 (\5\:mout VSS) capacitor c=4.29595e-17
C104 (\19\:Ckb VSS) capacitor c=8.32192e-17
C105 (\20\:Ckb VSS) capacitor c=8.44631e-17
C106 (\9\:CKbb VSS) capacitor c=2.62078e-17
C107 (\10\:CKbb VSS) capacitor c=1.17313e-16
C108 (\11\:CKbb VSS) capacitor c=6.13555e-17
C109 (\12\:CKbb VSS) capacitor c=5.55422e-17
C110 (\17\:CKbb VSS) capacitor c=8.33587e-17
C111 (\18\:CKbb VSS) capacitor c=7.18153e-17
C112 (\4\:n30 VSS) capacitor c=7.64941e-17
C113 (\4\:D VSS) capacitor c=6.69468e-17
C114 (\7\:Eb VSS) capacitor c=1.13356e-16
C115 (\8\:Eb VSS) capacitor c=1.03648e-16
C116 (\8\:E VSS) capacitor c=7.62284e-17
C117 (\9\:E VSS) capacitor c=1.25789e-16
C118 (\10\:E VSS) capacitor c=4.63632e-17
C119 (\11\:E VSS) capacitor c=1.4279e-16
C120 (\14\:qbint VSS) capacitor c=6.449e-17
C121 (\19\:qbint VSS) capacitor c=4.15727e-17
C122 (\20\:qbint VSS) capacitor c=5.30864e-17
C123 (\9\:qint VSS) capacitor c=2.51927e-17
C124 (\10\:qint VSS) capacitor c=3.27371e-17
C125 (\7\:VDD VSS) capacitor c=1.38869e-17
C126 (\9\:VDD VSS) capacitor c=1.90834e-17
C127 (\10\:VDD VSS) capacitor c=1.90491e-17
C128 (\12\:VDD VSS) capacitor c=1.2994e-17
Rk24 (D \4\:D) resistor r=0.09311 c=0
Rk34 (\2\:QN QN) resistor r=0.3684 c=0
Rk35 (QN \4\:QN) resistor r=0.07892 c=0
Rk47 (\2\:VSS \3\:VSS) resistor r=0.1042 c=0
Rk51 (\3\:VSS \7\:VSS) resistor r=0.2647 c=0
Rk52 (\7\:VSS \8\:VSS) resistor r=0.07159 c=0
Rk53 (\8\:VSS \9\:VSS) resistor r=0.4853 c=0
Rk54 (\9\:VSS \10\:VSS) resistor r=0.4702 c=0
Rk55 (\10\:VSS \11\:VSS) resistor r=0.1218 c=0
Rk57 (\12\:VSS VSS) resistor r=0.08734 c=0
Rk56 (\11\:VSS \12\:VSS) resistor r=0.4638 c=0
Rk61 (\8\:VSS \20\:VSS) resistor r=0.04332 c=0
Rk62 (\9\:VSS \22\:VSS) resistor r=0.2651 c=0
Rk63 (\10\:VSS \24\:VSS) resistor r=0.04332 c=0
Rk64 (\12\:VSS \26\:VSS) resistor r=0.1803 c=0
Rk1 (\5\:CK CK) resistor r=0.009896 c=0
Rk68 (\1\:VDD \7\:VDD) resistor r=0.4285 c=0
Rk69 (\7\:VDD \8\:VDD) resistor r=0.203 c=0
Rk70 (\8\:VDD \9\:VDD) resistor r=0.2381 c=0
Rk71 (\9\:VDD \10\:VDD) resistor r=0.4401 c=0
Rk72 (\10\:VDD \11\:VDD) resistor r=0.1218 c=0
Rk74 (\12\:VDD VDD) resistor r=0.1024 c=0
Rk73 (\11\:VDD \12\:VDD) resistor r=0.4488 c=0
Rk77 (\7\:VDD \18\:VDD) resistor r=0.1563 c=0
Rk78 (\9\:VDD \20\:VDD) resistor r=0.2634 c=0
Rk79 (\10\:VDD \22\:VDD) resistor r=0.04332 c=0
Rk80 (\12\:VDD \24\:VDD) resistor r=0.3317 c=0
Rk30 (\9\:E E) resistor r=0.9201 c=0
Rk28 (\8\:E \9\:E) resistor r=0.4126 c=0
Rk29 (\9\:E \10\:E) resistor r=0.2656 c=0
Rk31 (E \11\:E) resistor r=0.01024 c=0
Rk32 (\2\:Q Q) resistor r=0.3614 c=0
Rk33 (Q \4\:Q) resistor r=0.06696 c=0
Rk2 (\13\:Ckb \14\:Ckb) resistor r=0.1577 c=0
Rk3 (\14\:Ckb \16\:Ckb) resistor r=0.1183 c=0
Rk4 (\14\:Ckb \18\:Ckb) resistor r=0.4309 c=0
Rk11 (\19\:Ckb \20\:Ckb) resistor r=0.4206 c=0
Rk12 (\9\:CKbb \10\:CKbb) resistor r=0.03538 c=0
Rk13 (\10\:CKbb \11\:CKbb) resistor r=0.5838 c=0
Rk14 (\11\:CKbb \12\:CKbb) resistor r=0.09782 c=0
Rk15 (\12\:CKbb \14\:CKbb) resistor r=0.2801 c=0
Rk16 (\14\:CKbb \16\:CKbb) resistor r=0.588 c=0
Rk17 (\10\:CKbb \17\:CKbb) resistor r=0.5166 c=0
Rk18 (\12\:CKbb \18\:CKbb) resistor r=0.3366 c=0
Rk5 (\5\:n20 \6\:n20) resistor r=0.2661 c=0
Rk6 (\6\:n20 \8\:n20) resistor r=0.07753 c=0
Rk7 (\6\:n20 \10\:n20) resistor r=0.2567 c=0
Rk21 (\2\:Db \4\:Db) resistor r=0.5172 c=0
Rk22 (\4\:Db \6\:Db) resistor r=1.5614 c=0
Rk23 (\6\:Db \8\:Db) resistor r=0.4526 c=0
Rk8 (\4\:mout \5\:mout) resistor r=0.2397 c=0
Rk9 (\5\:mout \7\:mout) resistor r=0.07152 c=0
Rk10 (\5\:mout \9\:mout) resistor r=0.2656 c=0
Rk19 (\4\:n30 \6\:n30) resistor r=0.4558 c=0
Rk20 (\6\:n30 \8\:n30) resistor r=0.4297 c=0
Rk36 (\14\:qbint \4\:qbint) resistor r=0.5168 c=0
Rk38 (\4\:qbint \18\:qbint) resistor r=1.1352 c=0
Rk39 (\18\:qbint \19\:qbint) resistor r=0.1491 c=0
Rk40 (\19\:qbint \20\:qbint) resistor r=0.2199 c=0
Rk43 (\19\:qbint \24\:qbint) resistor r=0.2879 c=0
Rk25 (\6\:Eb \7\:Eb) resistor r=0.07551 c=0
Rk26 (\7\:Eb \8\:Eb) resistor r=0.5 c=0
Rk27 (\7\:Eb \10\:Eb) resistor r=0.4461 c=0
Rk44 (\8\:qint \9\:qint) resistor r=0.1706 c=0
Rk45 (\9\:qint \10\:qint) resistor r=0.1518 c=0
Rk46 (\9\:qint \12\:qint) resistor r=0.2338 c=0
Rl33 (\2\:D \3\:D) resistor r=218.029 c=0
Rl32 (\1\:D \2\:D) resistor r=101.477 c=0
Rl3 (\2\:CK \4\:CK) resistor r=70.868 c=0
Rl2 (\2\:CK \3\:CK) resistor r=167.022 c=0
Rl1 (\1\:CK \2\:CK) resistor r=1.2713 c=0
Rl34 (\5\:E \6\:E) resistor r=37.2302 c=0
Rl35 (\6\:E \7\:E) resistor r=79.5379 c=0
Rl28 (\3\:E \4\:E) resistor r=47.8762 c=0
Rl27 (\1\:E \2\:E) resistor r=66.5405 c=0
Rl5 (Ckb \2\:Ckb) resistor r=47.2519 c=0
Rl20 (\10\:Ckb \11\:Ckb) resistor r=143.429 c=0
Rl21 (\11\:Ckb \12\:Ckb) resistor r=50.6918 c=0
Rl6 (\2\:Ckb \3\:Ckb) resistor r=184.159 c=0
Rl10 (\3\:Ckb \7\:Ckb) resistor r=30.4507 c=0
Rl11 (\4\:Ckb \8\:Ckb) resistor r=145.387 c=0
Rl7 (\3\:Ckb \4\:Ckb) resistor r=181.607 c=0
Rl12 (\5\:Ckb \9\:Ckb) resistor r=34.3295 c=0
Rl9 (\5\:Ckb \6\:Ckb) resistor r=2.0166 c=0
Rl8 (\4\:Ckb \5\:Ckb) resistor r=54.7169 c=0
Rl22 (\7\:CKbb \8\:CKbb) resistor r=24.2328 c=0
Rl19 (\5\:CKbb \6\:CKbb) resistor r=72.2327 c=0
Rl13 (\3\:CKbb \4\:CKbb) resistor r=48.7697 c=0
Rl4 (CKbb \2\:CKbb) resistor r=31.9251 c=0
Rl16 (n20 \2\:n20) resistor r=37.3411 c=0
Rl18 (\2\:n20 \4\:n20) resistor r=87.3411 c=0
Rl17 (\2\:n20 \3\:n20) resistor r=3.1183 c=0
Rl14 (mout \2\:mout) resistor r=79.5379 c=0
Rl15 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl25 (n30 \2\:n30) resistor r=26.098 c=0
Rl26 (\2\:n30 \3\:n30) resistor r=53.0211 c=0
Rl47 (\12\:qbint \13\:qbint) resistor r=153.412 c=0
Rl46 (\11\:qbint \12\:qbint) resistor r=36.2715 c=0
Rl23 (\2\:qbint qbint) resistor r=81.9251 c=0
Rl24 (\2\:qbint \3\:qbint) resistor r=24.2328 c=0
Rl29 (Eb \2\:Eb) resistor r=76.8484 c=0
Rl31 (\2\:Eb \4\:Eb) resistor r=70.8353 c=0
Rl30 (\2\:Eb \3\:Eb) resistor r=136.516 c=0
Rz10 (\4\:QN \3\:QN) resistor r=75 c=0
Rz16 (\20\:VSS \19\:VSS) resistor r=75 c=0
Rz17 (\22\:VSS \21\:VSS) resistor r=75 c=0
Rz18 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz19 (\26\:VSS \25\:VSS) resistor r=75 c=0
Rz20 (\1\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz21 (\8\:VDD \4\:VDD) resistor r=18.75 c=0
Rz22 (\11\:VDD \4\:VDD) resistor r=6.25 c=0
Rz9 (\4\:Q \3\:Q) resistor r=75 c=0
Rz1 (\15\:Ckb \16\:Ckb) resistor r=75 c=0
Rz4 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz2 (\9\:n20 \10\:n20) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\6\:mout \7\:mout) resistor r=75 c=0
Rz5 (\7\:n30 \8\:n30) resistor r=75 c=0
Rz11 (\18\:qbint \17\:qbint) resistor r=75 c=0
Rz8 (\5\:Eb \6\:Eb) resistor r=75 c=0
Rz12 (\8\:qint \7\:qint) resistor r=75 c=0
Ry10 (\2\:QN \1\:QN) resistor r=20.6667 c=0
Ry13 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry14 (\3\:VSS \1\:VSS) resistor r=31 c=0
Ry15 (\7\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry16 (\11\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry20 (\18\:VDD \17\:VDD) resistor r=62 c=0
Ry21 (\20\:VDD \19\:VDD) resistor r=62 c=0
Ry22 (\22\:VDD \21\:VDD) resistor r=62 c=0
Ry23 (\24\:VDD \23\:VDD) resistor r=62 c=0
Ry9 (\2\:Q \1\:Q) resistor r=20.6667 c=0
Ry1 (\17\:Ckb \18\:Ckb) resistor r=62 c=0
Ry4 (\15\:CKbb \16\:CKbb) resistor r=62 c=0
Ry2 (\7\:n20 \8\:n20) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\5\:Db \6\:Db) resistor r=62 c=0
Ry3 (\8\:mout \9\:mout) resistor r=62 c=0
Ry5 (\5\:n30 \6\:n30) resistor r=62 c=0
Ry11 (\24\:qbint \23\:qbint) resistor r=62 c=0
Ry8 (\9\:Eb \10\:Eb) resistor r=62 c=0
Ry12 (\12\:qint \11\:qint) resistor r=62 c=0
Rx12 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\1\:CK \5\:CK) resistor r=45 c=0
Rx14 (\4\:E \8\:E) resistor r=45 c=0
Rx15 (\2\:E \10\:E) resistor r=45 c=0
Rx16 (\6\:E \11\:E) resistor r=45 c=0
Rx2 (\6\:Ckb \13\:Ckb) resistor r=45 c=0
Rx5 (\12\:Ckb \19\:Ckb) resistor r=45 c=0
Rx6 (Ckb \20\:Ckb) resistor r=45 c=0
Rx7 (\5\:CKbb \9\:CKbb) resistor r=45 c=0
Rx8 (\4\:CKbb \11\:CKbb) resistor r=45 c=0
Rx9 (\8\:CKbb \17\:CKbb) resistor r=45 c=0
Rx10 (\2\:CKbb \18\:CKbb) resistor r=45 c=0
Rx3 (\3\:n20 \5\:n20) resistor r=45 c=0
Rx4 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\2\:n30 \4\:n30) resistor r=45 c=0
Rx17 (\14\:qbint \11\:qbint) resistor r=45 c=0
Rx18 (\20\:qbint \2\:qbint) resistor r=45 c=0
Rx13 (Eb \8\:Eb) resistor r=45 c=0
Rx21 (\10\:qint qint) resistor r=45 c=0
mn20 (\15\:Ckb \3\:CK \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.5e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn21 (\13\:CKbb \9\:Ckb \25\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.102e-14 ps=6.1e-07 pd=5.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.45e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn25 (\7\:Db \7\:Ckb \9\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.77e-14 ad=3.117e-14 ps=8.1e-07 pd=7.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.15e-07 sb=1.96414e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn36 (\9\:n20 \3\:CKbb net411 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=3.77e-14 ps=4.1e-07 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.2e-07 sb=1.92207e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn35 (net411 \3\:mout \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.09e-14 ad=8.7e-15 ps=1.38e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.25e-07 sb=1.90759e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn30 (\6\:mout \4\:n20 \23\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.09e-14 ad=2.32e-14 ps=1.38e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=8.9e-07 sb=1.71155e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn40 (\6\:mout \6\:CKbb \7\:n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.32e-14 ps=6.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.095e-06 sb=1.50655e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn51 (\7\:n30 \10\:Ckb net415 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.682e-14 ad=2.32e-14 ps=6.6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.3e-06 sb=1.30155e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn50 (net415 \3\:qbint \21\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=4.632e-14 ad=2.682e-14 ps=9.7e-07 pd=6.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.53e-06 sb=1.07155e-06 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
mn45 (\17\:qbint \3\:n30 \21\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.633e-14 ad=6.493e-14 ps=9.7e-07 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.05654e-06 sb=5.64808e-07 sd=160n sca=12.8392 \
        scb=0.0126987 scc=0.00074151 m=(1)
mn1 (\17\:qbint \3\:Eb Db VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.538e-14 ad=6.493e-14 ps=6.4e-07 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.79103e-06 sb=5.2e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn3 (Db \3\:E n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=1.233e-14 \
        ad=2.537e-14 ps=4.6e-07 pd=6.4e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.82138e-06 sb=3e-07 sd=160n sca=12.9138 scb=0.0133404 \
        scc=0.000640143 m=(1)
mn2 (n0 \1\:D \19\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.605e-14 ad=1.233e-14 ps=1.32e-06 pd=4.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.83931e-06 sb=1.7e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
mn0 (\5\:Eb \7\:E \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.205e-14 ad=2.03e-14 ps=1.47e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.365e-06 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mn55_1__rcx (\3\:Q \4\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.493e-14 ad=4.68e-14 ps=1.47e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.01058e-07 sb=9.96058e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
mn57 (\3\:QN qint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=8.493e-14 ad=4.16e-14 ps=1.47e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.91058e-07 sb=5.06058e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
mn56 (\7\:qint \12\:qbint \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=8.205e-14 ad=2.03e-14 ps=1.47e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.365e-06 sb=1.4e-07 sd=160n sca=14.7993 \
        scb=0.0157101 scc=0.000964917 m=(1)
mp21 (\15\:CKbb \8\:Ckb \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=18.8843 \
        scb=0.0193686 scc=0.00092718 m=(1)
mp25 (\7\:n20 CKbb \5\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.80349e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp36 (\7\:n20 \2\:Ckb net342 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.398e-14 ad=3.44e-14 ps=5.6e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.67953e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp30 (\8\:mout n20 \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.091e-13 ad=6.127e-14 ps=1.9e-06 pd=1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.2e-07 sb=1.33221e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp35 (net342 mout \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.091e-13 ad=1.397e-14 ps=1.9e-06 pd=5.6e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.55e-07 sb=1.59721e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp40 (\5\:n30 \11\:Ckb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.127e-14 ad=3.44e-14 ps=1e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.05e-06 sb=1.00221e-06 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp51 (\5\:n30 \7\:CKbb net362 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.255e-06 sb=7.97209e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp50 (net362 qbint \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.412e-14 ad=1.29e-14 ps=1.33e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.36e-06 sb=6.92209e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp45 (\23\:qbint n30 \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.412e-14 ad=7.908e-14 ps=1.33e-06 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=9.74872e-07 sb=5.05962e-07 sd=160n sca=30.5009 \
        scb=0.0202006 scc=0.00336097 m=(1)
mp1 (\23\:qbint \1\:E \3\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.978e-14 ad=7.908e-14 ps=8e-07 pd=1.25e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.02721e-06 sb=5.05e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp3 (\3\:Db \4\:Eb n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.978e-14 ps=5.5e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.20186e-06 sb=2.75e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp2 (n1 \3\:D \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.715e-14 ad=1.29e-14 ps=1.28e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.26535e-06 sb=1.7e-07 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp0 (\9\:Eb \5\:E \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.18e-14 ad=5.053e-14 ps=1.22e-06 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.35e-07 sb=1.29e-06 sd=160n sca=22.8495 \
        scb=0.0214046 scc=0.00242442 m=(1)
mp55_1__rcx (\1\:Q \4\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=7.002e-14 ad=7.02e-14 ps=1.175e-06 pd=1.14e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.38462e-07 sb=9.19551e-07 sd=160n sca=17.2385 \
        scb=0.0152696 scc=0.00137893 m=(2)
mp57 (\1\:QN qint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.68e-14 ad=6.24e-14 ps=1.145e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.83462e-07 sb=4.74551e-07 sd=160n sca=17.6585 \
        scb=0.0154026 scc=0.00137896 m=(2)
mp56 (\11\:qint \13\:qbint \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.385e-06 sb=1.4e-07 sd=160n sca=27.7871 \
        scb=0.0280637 scc=0.00253496 m=(1)
ends EDFFX2
// End of subcircuit definition.

// Generated for: spectre (May  9 14:50:22 2012 )
// Library name: gsclib045
// Cell name: EDFFX4
// View name: extracted

simulator lang=spectre

subckt EDFFX4 CK D E Q QN VDD VSS
mp20 (\13\:Ckb \3\:CK \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=3.01e-14 ps=8.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.9e-07 sd=160n sca=18.237 scb=0.0193375 \
        scc=0.000503065 m=(1)
mp21 (\16\:CKbb \8\:Ckb \29\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.408e-14 ad=3.01e-14 ps=8.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.9e-07 sb=1.4e-07 sd=160n sca=12.3202 \
        scb=0.00940859 scc=0.000103219 m=(1)
C1 (D VSS) capacitor c=6.31333e-17
C2 (QN VSS) capacitor c=1.82453e-17
C3 (CK VSS) capacitor c=7.77309e-17
C4 (VDD VSS) capacitor c=4.68104e-16
C5 (E VSS) capacitor c=5.50773e-17
C6 (Q VSS) capacitor c=3.04737e-17
C7 (Ckb VSS) capacitor c=7.63163e-17
C8 (CKbb VSS) capacitor c=3.00345e-17
C9 (n20 VSS) capacitor c=4.36774e-17
C10 (Db VSS) capacitor c=1.00395e-16
C11 (mout VSS) capacitor c=7.34712e-17
C12 (n30 VSS) capacitor c=9.33498e-17
C13 (net415 VSS) capacitor c=1.86478e-18
C14 (qbint VSS) capacitor c=6.43507e-17
C15 (n0 VSS) capacitor c=1.42475e-18
C16 (Eb VSS) capacitor c=3.36581e-17
C17 (qint VSS) capacitor c=2.92753e-16
C18 (net342 VSS) capacitor c=1.62677e-18
C19 (net362 VSS) capacitor c=4.16618e-18
C20 (n1 VSS) capacitor c=1.84799e-18
C21 (\19\:qbint VSS) capacitor c=5.05344e-17
C22 (\4\:qbint VSS) capacitor c=2.87004e-16
C23 (\5\:E VSS) capacitor c=5.37021e-17
C24 (\1\:E VSS) capacitor c=2.51446e-17
C25 (\2\:Eb VSS) capacitor c=6.89892e-17
C26 (\1\:D VSS) capacitor c=6.31871e-17
C27 (\7\:CKbb VSS) capacitor c=5.08545e-17
C28 (\2\:Ckb VSS) capacitor c=1.28476e-16
C29 (\3\:Ckb VSS) capacitor c=1.42397e-16
C30 (\8\:Ckb VSS) capacitor c=4.99458e-17
C31 (\3\:CK VSS) capacitor c=4.33233e-17
C32 (\17\:qbint VSS) capacitor c=2.28469e-17
C33 (\7\:E VSS) capacitor c=3.70376e-17
C34 (\3\:Eb VSS) capacitor c=4.43107e-17
C35 (\3\:E VSS) capacitor c=7.21617e-17
C36 (\3\:D VSS) capacitor c=5.12556e-17
C37 (\3\:qbint VSS) capacitor c=3.42149e-17
C38 (\5\:CKbb VSS) capacitor c=5.84344e-17
C39 (\3\:n20 VSS) capacitor c=4.06887e-17
C40 (\3\:mout VSS) capacitor c=5.0111e-17
C41 (\3\:CKbb VSS) capacitor c=8.39002e-17
C42 (\7\:Ckb VSS) capacitor c=2.3158e-17
C43 (\9\:Ckb VSS) capacitor c=2.26156e-17
C44 (\1\:CK VSS) capacitor c=3.74374e-17
C45 (\18\:qbint VSS) capacitor c=4.67076e-17
C46 (\6\:E VSS) capacitor c=3.31141e-17
C47 (\4\:E VSS) capacitor c=1.61322e-17
C48 (\4\:Eb VSS) capacitor c=3.14892e-17
C49 (\2\:D VSS) capacitor c=5.3365e-17
C50 (\4\:n30 VSS) capacitor c=2.20513e-17
C51 (\2\:qbint VSS) capacitor c=4.80888e-17
C52 (\8\:CKbb VSS) capacitor c=5.40292e-17
C53 (\6\:CKbb VSS) capacitor c=2.27863e-17
C54 (\2\:n20 VSS) capacitor c=3.43827e-17
C55 (\2\:mout VSS) capacitor c=5.13567e-17
C56 (\4\:CKbb VSS) capacitor c=2.44166e-17
C57 (\2\:CKbb VSS) capacitor c=4.15922e-17
C58 (\6\:Ckb VSS) capacitor c=5.36806e-17
C59 (\2\:CK VSS) capacitor c=5.21007e-17
C60 (\20\:qint VSS) capacitor c=6.23875e-17
C61 (\1\:VDD VSS) capacitor c=3.68129e-16
C62 (\1\:QN VSS) capacitor c=1.48979e-16
C63 (\1\:Q VSS) capacitor c=1.57752e-16
C64 (\5\:Eb VSS) capacitor c=7.0672e-17
C65 (\21\:qbint VSS) capacitor c=1.23418e-16
C66 (\8\:Db VSS) capacitor c=3.08299e-17
C67 (\33\:qbint VSS) capacitor c=6.16569e-17
C68 (\13\:n30 VSS) capacitor c=1.20082e-19
C69 (\4\:mout VSS) capacitor c=6.57318e-17
C70 (\26\:VDD VSS) capacitor c=6.98363e-17
C71 (\8\:n20 VSS) capacitor c=4.25507e-17
C72 (\3\:Db VSS) capacitor c=3.2774e-16
C73 (\16\:CKbb VSS) capacitor c=8.3445e-17
C74 (\29\:VDD VSS) capacitor c=2.77851e-17
C75 (\13\:Ckb VSS) capacitor c=7.65706e-17
C76 (\4\:VDD VSS) capacitor c=1.45337e-16
C77 (\16\:qint VSS) capacitor c=3.39235e-17
C78 (\10\:Eb VSS) capacitor c=7.01862e-17
C79 (\25\:qbint VSS) capacitor c=2.07296e-16
C80 (\6\:Db VSS) capacitor c=9.69368e-17
C81 (\31\:qbint VSS) capacitor c=2.00855e-17
C82 (\11\:n30 VSS) capacitor c=7.76735e-17
C83 (\8\:mout VSS) capacitor c=3.26083e-17
C84 (\6\:n20 VSS) capacitor c=5.08721e-17
C85 (\13\:CKbb VSS) capacitor c=1.09758e-16
C86 (\10\:Ckb VSS) capacitor c=1.92009e-17
C87 (\4\:Ckb VSS) capacitor c=5.58699e-17
C88 (\5\:n30 VSS) capacitor c=9.10313e-17
C89 (\2\:E VSS) capacitor c=4.10978e-17
C90 (\4\:CK VSS) capacitor c=3.00528e-17
C91 (\12\:Ckb VSS) capacitor c=7.35291e-17
C92 (\15\:Ckb VSS) capacitor c=4.86746e-17
C93 (\4\:n20 VSS) capacitor c=7.50177e-17
C94 (\5\:n20 VSS) capacitor c=6.29533e-17
C95 (\6\:mout VSS) capacitor c=5.79422e-17
C96 (\7\:mout VSS) capacitor c=5.99909e-17
C97 (\9\:CKbb VSS) capacitor c=8.94298e-17
C98 (\10\:CKbb VSS) capacitor c=1.26042e-16
C99 (\11\:CKbb VSS) capacitor c=8.32433e-17
C100 (\12\:CKbb VSS) capacitor c=7.21155e-17
C101 (\15\:CKbb VSS) capacitor c=7.13572e-17
C102 (\9\:n30 VSS) capacitor c=7.29262e-17
C103 (\10\:n30 VSS) capacitor c=1.01923e-16
C104 (\4\:D VSS) capacitor c=5.57316e-17
C105 (\5\:Db VSS) capacitor c=2.68859e-16
C106 (\7\:Eb VSS) capacitor c=1.02097e-16
C107 (\8\:Eb VSS) capacitor c=2.93687e-17
C108 (\9\:Eb VSS) capacitor c=7.70715e-17
C109 (\9\:E VSS) capacitor c=5.42294e-17
C110 (\10\:E VSS) capacitor c=2.01465e-17
C111 (\20\:qbint VSS) capacitor c=9.58075e-17
C112 (\4\:Q VSS) capacitor c=1.34942e-16
C113 (\4\:QN VSS) capacitor c=1.26285e-16
C114 (\23\:qbint VSS) capacitor c=1.63753e-16
C115 (\24\:qbint VSS) capacitor c=2.10134e-16
C116 (\27\:qbint VSS) capacitor c=1.32953e-16
C117 (\29\:qbint VSS) capacitor c=4.37082e-17
C118 (\30\:qbint VSS) capacitor c=2.95541e-17
C119 (\18\:qint VSS) capacitor c=3.82918e-17
C120 (\19\:qint VSS) capacitor c=3.58767e-17
C121 (\10\:VDD VSS) capacitor c=6.64153e-17
C122 (\28\:VDD VSS) capacitor c=2.45377e-17
Rk22 (\4\:D D) resistor r=0.03526 c=0
Rk43 (\1\:QN QN) resistor r=0.02532 c=0
Rk44 (QN \4\:QN) resistor r=0.2812 c=0
Rk3 (\4\:CK CK) resistor r=0.01803 c=0
Rk88 (\1\:VDD \9\:VDD) resistor r=0.3158 c=0
Rk89 (\9\:VDD \10\:VDD) resistor r=0.3058 c=0
Rk92 (\10\:VDD \13\:VDD) resistor r=0.5121 c=0
Rk99 (\13\:VDD \27\:VDD) resistor r=0.3692 c=0
Rk100 (\13\:VDD \28\:VDD) resistor r=0.5391 c=0
Rk101 (\28\:VDD \30\:VDD) resistor r=0.1744 c=0
Rk103 (\31\:VDD VDD) resistor r=0.04991 c=0
Rk102 (\28\:VDD \31\:VDD) resistor r=0.1127 c=0
Rk31 (\8\:E \9\:E) resistor r=0.001297 c=0
Rk34 (\10\:E E) resistor r=0.003305 c=0
Rk33 (\9\:E \10\:E) resistor r=0.1142 c=0
Rk32 (\10\:E \11\:E) resistor r=0.001297 c=0
Rk37 (\1\:Q Q) resistor r=0.00338 c=0
Rk38 (Q \4\:Q) resistor r=0.2935 c=0
Rk59 (\2\:VSS \3\:VSS) resistor r=0.1102 c=0
Rk66 (\3\:VSS \10\:VSS) resistor r=0.5128 c=0
Rk69 (\10\:VSS \13\:VSS) resistor r=0.4613 c=0
Rk70 (\13\:VSS \14\:VSS) resistor r=0.03492 c=0
Rk71 (\14\:VSS \15\:VSS) resistor r=0.569 c=0
Rk73 (\16\:VSS VSS) resistor r=0.04991 c=0
Rk72 (\15\:VSS \16\:VSS) resistor r=0.09763 c=0
Rk81 (\14\:VSS \32\:VSS) resistor r=0.1229 c=0
Rk82 (\15\:VSS \34\:VSS) resistor r=0.2846 c=0
Rk4 (\11\:Ckb \12\:Ckb) resistor r=0.09749 c=0
Rk5 (\12\:Ckb \14\:Ckb) resistor r=0.6273 c=0
Rk6 (\12\:Ckb \15\:Ckb) resistor r=0.2017 c=0
Rk13 (\9\:CKbb \10\:CKbb) resistor r=0.5389 c=0
Rk14 (\10\:CKbb \11\:CKbb) resistor r=0.5003 c=0
Rk15 (\11\:CKbb \12\:CKbb) resistor r=0.2237 c=0
Rk16 (\12\:CKbb \14\:CKbb) resistor r=0.3037 c=0
Rk17 (\12\:CKbb \15\:CKbb) resistor r=0.3894 c=0
Rk18 (\14\:CKbb \17\:CKbb) resistor r=0.6438 c=0
Rk7 (\4\:n20 \5\:n20) resistor r=0.3382 c=0
Rk8 (\5\:n20 \7\:n20) resistor r=0.2526 c=0
Rk9 (\5\:n20 \9\:n20) resistor r=0.1688 c=0
Rk23 (\2\:Db \4\:Db) resistor r=0.6131 c=0
Rk24 (\4\:Db \5\:Db) resistor r=2.1284 c=0
Rk25 (\5\:Db \7\:Db) resistor r=0.4704 c=0
Rk26 (\5\:Db \9\:Db) resistor r=0.03526 c=0
Rk10 (\5\:mout \6\:mout) resistor r=0.3093 c=0
Rk11 (\6\:mout \7\:mout) resistor r=0.309 c=0
Rk12 (\6\:mout \9\:mout) resistor r=0.135 c=0
Rk19 (\9\:n30 \10\:n30) resistor r=0.4482 c=0
Rk20 (\10\:n30 \12\:n30) resistor r=0.4237 c=0
Rk21 (\10\:n30 \14\:n30) resistor r=0.03453 c=0
Rk35 (\20\:qbint \22\:qbint) resistor r=0.4768 c=0
Rk48 (\23\:qbint \24\:qbint) resistor r=1.0513 c=0
Rk49 (\24\:qbint \26\:qbint) resistor r=0.9532 c=0
Rk50 (\26\:qbint \27\:qbint) resistor r=0.8797 c=0
Rk51 (\27\:qbint \28\:qbint) resistor r=0.0618 c=0
Rk52 (\28\:qbint \29\:qbint) resistor r=0.1843 c=0
Rk53 (\24\:qbint \30\:qbint) resistor r=0.2363 c=0
Rk54 (\27\:qbint \32\:qbint) resistor r=0.08109 c=0
Rk55 (\28\:qbint \34\:qbint) resistor r=0.2832 c=0
Rk27 (\6\:Eb \7\:Eb) resistor r=0.3848 c=0
Rk28 (\7\:Eb \8\:Eb) resistor r=0.2027 c=0
Rk29 (\7\:Eb \9\:Eb) resistor r=0.4689 c=0
Rk30 (\9\:Eb \11\:Eb) resistor r=0.3055 c=0
Rk56 (\17\:qint \18\:qint) resistor r=0.2457 c=0
Rk57 (\18\:qint \19\:qint) resistor r=0.2602 c=0
Rk58 (\18\:qint \21\:qint) resistor r=0.1449 c=0
Rl28 (\1\:D \2\:D) resistor r=35.796 c=0
Rl29 (\2\:D \3\:D) resistor r=120.479 c=0
Rl2 (\2\:CK \3\:CK) resistor r=155.002 c=0
Rl1 (\1\:CK \2\:CK) resistor r=99.2328 c=0
Rl35 (\5\:E \6\:E) resistor r=102.931 c=0
Rl36 (\6\:E \7\:E) resistor r=66.0764 c=0
Rl32 (\1\:E \2\:E) resistor r=67.9709 c=0
Rl33 (\2\:E \3\:E) resistor r=209.283 c=0
Rl34 (\2\:E \4\:E) resistor r=16.1277 c=0
Rl10 (Ckb \2\:Ckb) resistor r=202.977 c=0
Rl11 (\2\:Ckb \3\:Ckb) resistor r=397.208 c=0
Rl17 (\6\:Ckb \9\:Ckb) resistor r=45.6101 c=0
Rl12 (\3\:Ckb \4\:Ckb) resistor r=247.62 c=0
Rl15 (\4\:Ckb \7\:Ckb) resistor r=30.4507 c=0
Rl16 (\5\:Ckb \8\:Ckb) resistor r=204.928 c=0
Rl14 (\5\:Ckb \6\:Ckb) resistor r=14.7598 c=0
Rl13 (\4\:Ckb \5\:Ckb) resistor r=150.075 c=0
Rl18 (\7\:CKbb \8\:CKbb) resistor r=47.3097 c=0
Rl9 (\5\:CKbb \6\:CKbb) resistor r=46.8456 c=0
Rl4 (\3\:CKbb \4\:CKbb) resistor r=46.8456 c=0
Rl3 (CKbb \2\:CKbb) resistor r=62.9746 c=0
Rl7 (n20 \2\:n20) resistor r=50.6918 c=0
Rl8 (\2\:n20 \3\:n20) resistor r=91.0764 c=0
Rl5 (mout \2\:mout) resistor r=112.23 c=0
Rl6 (\2\:mout \3\:mout) resistor r=29.5379 c=0
Rl23 (n30 \4\:n30) resistor r=9.7447 c=0
Rl24 (\5\:n30 n30) resistor r=31.6073 c=0
Rl64 (\18\:qbint \19\:qbint) resistor r=97.3098 c=0
Rl63 (\18\:qbint \17\:qbint) resistor r=28.1859 c=0
Rl19 (\2\:qbint qbint) resistor r=108.848 c=0
Rl20 (\2\:qbint \3\:qbint) resistor r=30.0021 c=0
Rl30 (Eb \2\:Eb) resistor r=45.6844 c=0
Rl31 (\3\:Eb \4\:Eb) resistor r=26.1559 c=0
Rz25 (\1\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz26 (\9\:VDD \4\:VDD) resistor r=12.5 c=0
Rz27 (\10\:VDD \4\:VDD) resistor r=37.5 c=0
Rz28 (\13\:VDD \4\:VDD) resistor r=6.8182 c=0
Rz29 (\31\:VDD \4\:VDD) resistor r=37.5 c=0
Rz23 (\32\:VSS \31\:VSS) resistor r=75 c=0
Rz24 (\34\:VSS \33\:VSS) resistor r=75 c=0
Rz1 (\10\:Ckb \11\:Ckb) resistor r=75 c=0
Rz4 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz2 (\6\:n20 \7\:n20) resistor r=75 c=0
Rz6 (Db \2\:Db) resistor r=75 c=0
Rz7 (\6\:Db \7\:Db) resistor r=75 c=0
Rz3 (\8\:mout \9\:mout) resistor r=75 c=0
Rz5 (\12\:n30 \11\:n30) resistor r=75 c=0
Rz13 (\26\:qbint \25\:qbint) resistor r=75 c=0
Rz14 (\32\:qbint \31\:qbint) resistor r=75 c=0
Rz8 (\10\:Eb \11\:Eb) resistor r=75 c=0
Rz15 (\17\:qint \16\:qint) resistor r=75 c=0
Ry29 (\27\:VDD \26\:VDD) resistor r=62 c=0
Ry30 (\30\:VDD \29\:VDD) resistor r=62 c=0
Ry16 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry17 (\3\:VSS \1\:VSS) resistor r=4.1333 c=0
Ry19 (\10\:VSS \1\:VSS) resistor r=62 c=0
Ry20 (\13\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry21 (\16\:VSS \1\:VSS) resistor r=31 c=0
Ry1 (\13\:Ckb \14\:Ckb) resistor r=62 c=0
Ry4 (\16\:CKbb \17\:CKbb) resistor r=62 c=0
Ry2 (\8\:n20 \9\:n20) resistor r=62 c=0
Ry6 (\3\:Db \4\:Db) resistor r=62 c=0
Ry7 (\8\:Db \9\:Db) resistor r=62 c=0
Ry3 (\4\:mout \5\:mout) resistor r=62 c=0
Ry5 (\14\:n30 \13\:n30) resistor r=62 c=0
Ry9 (\22\:qbint \21\:qbint) resistor r=62 c=0
Ry14 (\34\:qbint \33\:qbint) resistor r=62 c=0
Ry8 (\5\:Eb \6\:Eb) resistor r=62 c=0
Ry15 (\21\:qint \20\:qint) resistor r=20.6667 c=0
Rx10 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx13 (\4\:E \8\:E) resistor r=45 c=0
Rx14 (\6\:E \11\:E) resistor r=45 c=0
Rx2 (\6\:Ckb \15\:Ckb) resistor r=45 c=0
Rx5 (\8\:CKbb \9\:CKbb) resistor r=45 c=0
Rx6 (\6\:CKbb \10\:CKbb) resistor r=45 c=0
Rx7 (\4\:CKbb \11\:CKbb) resistor r=45 c=0
Rx8 (\2\:CKbb \15\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx4 (\2\:mout \7\:mout) resistor r=45 c=0
Rx9 (\9\:n30 \4\:n30) resistor r=45 c=0
Rx15 (\20\:qbint \4\:qbint) resistor r=45 c=0
Rx16 (\23\:qbint \18\:qbint) resistor r=45 c=0
Rx17 (\29\:qbint \2\:qbint) resistor r=45 c=0
Rx18 (\30\:qbint \4\:qbint) resistor r=45 c=0
Rx11 (Eb \8\:Eb) resistor r=45 c=0
Rx12 (\4\:Eb \9\:Eb) resistor r=45 c=0
Rx19 (\19\:qint qint) resistor r=45 c=0
mn20 (\10\:Ckb \1\:CK \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn21 (\13\:CKbb \9\:Ckb \33\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.465e-14 ps=6.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.7e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn25 (Db \7\:Ckb \6\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.93e-14 ad=2.03e-14 ps=9.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=17.8702 scb=0.0189183 \
        scc=0.00156031 m=(1)
mn36 (\6\:n20 \3\:CKbb net411 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=9.42e-15 ad=4.93e-14 ps=4.2e-07 pd=9.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.25e-07 sb=1.88828e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn30 (\8\:mout \3\:n20 \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=7.03e-14 ad=3.987e-14 ps=1.37e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=9e-07 sb=1.69948e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn35 (net411 \3\:mout \31\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.03e-14 ad=9.42e-15 ps=1.37e-06 pd=4.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=6.35e-07 sb=1.85414e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn40 (\8\:mout \5\:CKbb \11\:n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=3.987e-14 ps=6.1e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.22e-06 sb=1.37948e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn51 (\11\:n30 Ckb net415 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.247e-14 ad=2.32e-14 ps=6e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.425e-06 sb=1.17448e-06 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn50 (net415 \3\:qbint \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.535e-14 ad=2.247e-14 ps=7.9e-07 pd=6e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.625e-06 sb=9.74483e-07 sd=160n sca=17.8702 \
        scb=0.0189183 scc=0.00156031 m=(1)
mn45 (\31\:qbint \5\:n30 \10\:VSS VSS) g45n1svt w=(2.05e-07) l=4.5e-08 \
        nf=1 as=3.264e-14 ad=3.28e-14 ps=7.65e-07 pd=7.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35366e-06 sb=7.5061e-07 sd=160n sca=17.1738 \
        scb=0.0176382 scc=0.00148475 m=(2)
mn2 (n0 \3\:D \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.992e-14 ad=1.885e-14 ps=7.4e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55155e-06 sb=5.2e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn3 (\6\:Db \3\:E n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=1.885e-14 ad=2.32e-14 ps=5.5e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.60586e-06 sb=3.45e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn1 (\25\:qbint \3\:Eb \6\:Db VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.66948e-06 sb=1.4e-07 sd=160n sca=13.6097 \
        scb=0.014254 scc=0.000755054 m=(1)
mn0 (\10\:Eb \7\:E \3\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.765e-14 ad=2.03e-14 ps=1.6e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mn55_1__rcx (\4\:Q \4\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.611e-14 ad=4.16e-14 ps=1.6e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.31058e-07 sb=2e-06 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(4)
mn57_1__rcx (\4\:QN qint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=8.665e-14 ad=5.135e-14 ps=1.445e-06 pd=9.15e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.17106e-06 sb=1.165e-06 sd=160n \
        sca=17.5885 scb=0.0172826 scc=0.00162584 m=(4)
mn56 (\16\:qint \17\:qbint \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=5.98e-14 ad=3.64e-14 ps=9.8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(1)
mp25 (\8\:n20 CKbb \3\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp36 (\8\:n20 \3\:Ckb net342 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.505e-14 ad=3.44e-14 ps=5.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp35 (net342 mout \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=1.505e-14 ps=8.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.6e-07 sb=2e-06 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp30 (\4\:mout n20 \26\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.73e-14 ad=6.342e-14 ps=8.7e-07 pd=1.02e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.25e-07 sb=2e-06 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp40 (\13\:n30 \2\:Ckb \4\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.342e-14 ad=3.44e-14 ps=1.02e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.065e-06 sb=1.685e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp51 (\13\:n30 \7\:CKbb net362 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=2.903e-14 ad=3.44e-14 ps=7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.27e-06 sb=1.48e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp50 (net362 qbint \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.465e-14 ad=2.902e-14 ps=1.58e-06 pd=7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.45e-06 sb=1.3e-06 sd=160n sca=13.4114 \
        scb=0.012694 scc=0.000544005 m=(1)
mp45_1__rcx (\33\:qbint n30 \10\:VDD VDD) g45p1svt w=(3.1e-07) l=4.5e-08 \
        nf=1 as=9.465e-14 ad=4.96e-14 ps=1.58e-06 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.24153e-06 sb=8.32742e-07 sd=160n sca=12.3129 \
        scb=0.0108562 scc=0.00039161 m=(2)
mp2 (n1 \1\:D \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.465e-14 ad=1.29e-14 ps=1.58e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.65e-07 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp3 (\8\:Db \2\:Eb n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=5.912e-14 ps=5.5e-07 pd=9.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=4.6e-07 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp1 (\21\:qbint \1\:E \8\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=5.912e-14 ad=3.01e-14 ps=9.8e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.4e-07 sd=160n sca=13.4114 scb=0.012694 \
        scc=0.000544005 m=(1)
mp0 (\5\:Eb \5\:E \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=13.9534 scb=0.0134231 \
        scc=0.000640578 m=(1)
mp55_1__rcx (\1\:Q \4\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.314e-14 ad=6.63e-14 ps=1.115e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.82e-06 sd=160n sca=12.2138 \
        scb=0.0106342 scc=0.00038358 m=(4)
mp57_1__rcx (\1\:QN qint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=6.63e-14 ps=1.1e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.10955e-06 sb=9.8e-07 sd=160n sca=12.2138 \
        scb=0.0106342 scc=0.00038358 m=(4)
mp56 (\20\:qint \19\:qbint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.91923e-06 sb=1.4e-07 sd=160n sca=16.2631 \
        scb=0.0157178 scc=0.000443168 m=(1)
ends EDFFX4
// End of subcircuit definition.

// Generated for: spectre (May  9 14:50:59 2012 )
// Library name: gsclib045
// Cell name: EDFFXL
// View name: extracted

simulator lang=spectre

subckt EDFFXL CK D E Q QN VDD VSS
mp20 (\14\:Ckb \3\:CK \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.408e-14 ad=3.01e-14 ps=8.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.9e-07 sd=160n sca=18.237 scb=0.0193375 \
        scc=0.000503065 m=(1)
mp21 (\18\:CKbb \7\:Ckb \23\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.408e-14 ad=3.01e-14 ps=8.4e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.9e-07 sb=1.4e-07 sd=160n sca=12.3202 \
        scb=0.00940859 scc=0.000103219 m=(1)
C1 (CK VSS) capacitor c=7.77821e-17
C2 (QN VSS) capacitor c=2.8102e-17
C3 (VDD VSS) capacitor c=3.68413e-16
C4 (Q VSS) capacitor c=1.93725e-17
C5 (Ckb VSS) capacitor c=2.31561e-17
C6 (CKbb VSS) capacitor c=4.07323e-17
C7 (n20 VSS) capacitor c=4.1116e-17
C8 (Db VSS) capacitor c=3.07472e-16
C9 (net411 VSS) capacitor c=1.27961e-19
C10 (mout VSS) capacitor c=3.33685e-17
C11 (n30 VSS) capacitor c=5.03895e-17
C12 (qbint VSS) capacitor c=1.79412e-17
C13 (Eb VSS) capacitor c=3.00416e-17
C14 (n0 VSS) capacitor c=3.1646e-18
C15 (qint VSS) capacitor c=3.46181e-17
C16 (net342 VSS) capacitor c=6.17825e-18
C17 (net362 VSS) capacitor c=4.46496e-19
C18 (n1 VSS) capacitor c=6.74446e-18
C19 (\5\:qbint VSS) capacitor c=1.93022e-17
C20 (\11\:qbint VSS) capacitor c=2.0462e-17
C21 (\5\:E VSS) capacitor c=3.0774e-17
C22 (\1\:D VSS) capacitor c=3.40083e-17
C23 (\1\:E VSS) capacitor c=5.24387e-17
C24 (\4\:qbint VSS) capacitor c=4.85442e-17
C25 (\7\:CKbb VSS) capacitor c=5.97017e-17
C26 (\10\:Ckb VSS) capacitor c=7.20397e-17
C27 (\5\:Ckb VSS) capacitor c=5.51408e-17
C28 (\7\:Ckb VSS) capacitor c=4.79563e-17
C29 (\3\:CK VSS) capacitor c=4.33339e-17
C30 (\3\:qint VSS) capacitor c=2.50083e-17
C31 (\10\:qbint VSS) capacitor c=1.57077e-17
C32 (\8\:qbint VSS) capacitor c=1.16096e-17
C33 (\7\:E VSS) capacitor c=3.81791e-17
C34 (\3\:D VSS) capacitor c=3.0842e-17
C35 (\3\:E VSS) capacitor c=3.5992e-17
C36 (\3\:Eb VSS) capacitor c=5.35348e-17
C37 (\3\:n30 VSS) capacitor c=2.40317e-17
C38 (\3\:qbint VSS) capacitor c=5.72676e-17
C39 (\9\:Ckb VSS) capacitor c=8.40522e-17
C40 (\5\:CKbb VSS) capacitor c=2.50972e-17
C41 (\3\:n20 VSS) capacitor c=3.11569e-17
C42 (\3\:mout VSS) capacitor c=4.62319e-17
C43 (\3\:CKbb VSS) capacitor c=4.19268e-17
C44 (\8\:Ckb VSS) capacitor c=2.60413e-17
C45 (\1\:CK VSS) capacitor c=3.63573e-17
C46 (\2\:qint VSS) capacitor c=2.01093e-17
C47 (\9\:qbint VSS) capacitor c=1.48971e-17
C48 (\6\:E VSS) capacitor c=2.38628e-17
C49 (\2\:D VSS) capacitor c=3.36408e-17
C50 (\4\:Eb VSS) capacitor c=3.02703e-17
C51 (\4\:E VSS) capacitor c=4.0245e-17
C52 (\2\:E VSS) capacitor c=2.48457e-17
C53 (\2\:n30 VSS) capacitor c=3.92903e-17
C54 (\8\:CKbb VSS) capacitor c=4.15527e-17
C55 (\6\:CKbb VSS) capacitor c=3.16874e-17
C56 (\11\:Ckb VSS) capacitor c=2.83719e-17
C57 (\2\:n20 VSS) capacitor c=3.11714e-17
C58 (\2\:mout VSS) capacitor c=3.62637e-17
C59 (\4\:CKbb VSS) capacitor c=2.02756e-17
C60 (\6\:Ckb VSS) capacitor c=2.45295e-17
C61 (\2\:CKbb VSS) capacitor c=4.05936e-17
C62 (\4\:Ckb VSS) capacitor c=5.44241e-17
C63 (\2\:CK VSS) capacitor c=5.33791e-17
C64 (\3\:QN VSS) capacitor c=2.08133e-17
C65 (\13\:VDD VSS) capacitor c=1.83871e-17
C66 (\7\:qint VSS) capacitor c=2.56835e-17
C67 (\15\:VDD VSS) capacitor c=3.76229e-17
C68 (\3\:Q VSS) capacitor c=4.39289e-17
C69 (\5\:Eb VSS) capacitor c=6.15196e-17
C70 (\17\:VDD VSS) capacitor c=3.3643e-17
C71 (\17\:qbint VSS) capacitor c=3.6864e-17
C72 (\19\:VDD VSS) capacitor c=1.05402e-17
C73 (\7\:n30 VSS) capacitor c=7.04047e-17
C74 (\8\:mout VSS) capacitor c=5.74589e-17
C75 (\21\:VDD VSS) capacitor c=3.15005e-17
C76 (\6\:n20 VSS) capacitor c=4.9548e-17
C77 (\3\:Db VSS) capacitor c=3.06822e-16
C78 (\18\:CKbb VSS) capacitor c=8.01223e-17
C79 (\23\:VDD VSS) capacitor c=2.83776e-17
C80 (\14\:Ckb VSS) capacitor c=7.68195e-17
C81 (\1\:VDD VSS) capacitor c=1.18049e-16
C82 (\1\:QN VSS) capacitor c=3.62705e-17
C83 (\5\:qint VSS) capacitor c=3.5801e-17
C84 (\1\:Q VSS) capacitor c=3.46184e-17
C85 (\7\:Eb VSS) capacitor c=1.22324e-16
C86 (\7\:Db VSS) capacitor c=6.87333e-17
C87 (\13\:qbint VSS) capacitor c=1.43155e-16
C88 (\4\:n30 VSS) capacitor c=3.58883e-17
C89 (\6\:mout VSS) capacitor c=5.08224e-17
C90 (\8\:n20 VSS) capacitor c=3.74463e-17
C91 (\5\:Db VSS) capacitor c=7.21814e-17
C92 (\13\:CKbb VSS) capacitor c=1.03074e-16
C93 (\16\:Ckb VSS) capacitor c=1.93491e-17
C94 (\2\:Ckb VSS) capacitor c=4.62456e-17
C95 (\2\:qbint VSS) capacitor c=2.98608e-17
C96 (\2\:Eb VSS) capacitor c=5.44632e-17
C97 (\6\:qbint VSS) capacitor c=1.01581e-17
C98 (\7\:qbint VSS) capacitor c=9.60383e-18
C99 (\4\:CK VSS) capacitor c=3.16178e-17
C100 (\12\:Ckb VSS) capacitor c=5.2587e-17
C101 (\13\:Ckb VSS) capacitor c=7.64204e-17
C102 (\4\:n20 VSS) capacitor c=6.96504e-17
C103 (\5\:n20 VSS) capacitor c=6.45083e-17
C104 (\18\:Ckb VSS) capacitor c=1.15213e-16
C105 (\19\:Ckb VSS) capacitor c=1.17816e-16
C106 (\4\:mout VSS) capacitor c=6.20046e-17
C107 (\5\:mout VSS) capacitor c=6.25582e-17
C108 (\9\:CKbb VSS) capacitor c=3.27957e-17
C109 (\10\:CKbb VSS) capacitor c=1.15629e-16
C110 (\11\:CKbb VSS) capacitor c=1.09537e-16
C111 (\12\:CKbb VSS) capacitor c=6.13346e-17
C112 (\15\:CKbb VSS) capacitor c=3.52667e-17
C113 (\16\:CKbb VSS) capacitor c=1.85291e-17
C114 (\17\:CKbb VSS) capacitor c=7.99976e-17
C115 (\6\:n30 VSS) capacitor c=6.4083e-17
C116 (\9\:n30 VSS) capacitor c=5.85304e-17
C117 (\5\:D VSS) capacitor c=7.0589e-17
C118 (\6\:D VSS) capacitor c=7.23005e-17
C119 (\8\:E VSS) capacitor c=8.37159e-17
C120 (\9\:E VSS) capacitor c=1.29568e-16
C121 (\10\:E VSS) capacitor c=4.94373e-17
C122 (\11\:E VSS) capacitor c=1.17715e-16
C123 (\9\:Eb VSS) capacitor c=1.19494e-16
C124 (\12\:qbint VSS) capacitor c=1.41106e-16
C125 (\15\:qbint VSS) capacitor c=4.98664e-17
C126 (\16\:qbint VSS) capacitor c=5.30188e-17
C127 (\4\:qint VSS) capacitor c=4.13563e-17
C128 (\3\:VDD VSS) capacitor c=1.07522e-18
C129 (\4\:VDD VSS) capacitor c=1.02457e-17
C130 (\6\:VDD VSS) capacitor c=2.71301e-17
C131 (\7\:VDD VSS) capacitor c=3.04021e-17
C132 (\9\:VDD VSS) capacitor c=1.37473e-17
C133 (\11\:VDD VSS) capacitor c=1.68812e-17
Rk28 (\4\:D \5\:D) resistor r=0.01193 c=0
Rk29 (\6\:D D) resistor r=0.01193 c=0
Rk30 (\5\:D \6\:D) resistor r=0.01198 c=0
Rk3 (\4\:CK CK) resistor r=0.01799 c=0
Rk45 (\2\:QN QN) resistor r=0.2459 c=0
Rk46 (QN \4\:QN) resistor r=0.1533 c=0
Rk47 (\2\:VDD \3\:VDD) resistor r=0.07752 c=0
Rk48 (\3\:VDD \4\:VDD) resistor r=0.2653 c=0
Rk49 (\4\:VDD \5\:VDD) resistor r=0.3583 c=0
Rk50 (\5\:VDD \6\:VDD) resistor r=0.04994 c=0
Rk51 (\6\:VDD \7\:VDD) resistor r=0.5286 c=0
Rk52 (\7\:VDD \8\:VDD) resistor r=0.2731 c=0
Rk53 (\8\:VDD \9\:VDD) resistor r=0.2981 c=0
Rk54 (\9\:VDD \10\:VDD) resistor r=0.3032 c=0
Rk55 (\10\:VDD \11\:VDD) resistor r=0.3382 c=0
Rk57 (\12\:VDD VDD) resistor r=0.04989 c=0
Rk56 (\11\:VDD \12\:VDD) resistor r=0.1126 c=0
Rk58 (\3\:VDD \14\:VDD) resistor r=0.3336 c=0
Rk59 (\4\:VDD \16\:VDD) resistor r=0.4169 c=0
Rk60 (\6\:VDD \18\:VDD) resistor r=0.149 c=0
Rk61 (\7\:VDD \20\:VDD) resistor r=0.07369 c=0
Rk62 (\9\:VDD \22\:VDD) resistor r=0.1224 c=0
Rk63 (\11\:VDD \24\:VDD) resistor r=0.1736 c=0
Rk33 (\9\:E E) resistor r=0.7475 c=0
Rk31 (\8\:E \9\:E) resistor r=0.4181 c=0
Rk32 (\9\:E \10\:E) resistor r=0.2745 c=0
Rk34 (E \11\:E) resistor r=0.002705 c=0
Rk37 (\2\:Q Q) resistor r=0.03458 c=0
Rk38 (Q \4\:Q) resistor r=0.1761 c=0
Rk64 (\2\:VSS \3\:VSS) resistor r=0.08504 c=0
Rk65 (\3\:VSS \4\:VSS) resistor r=0.1151 c=0
Rk66 (\4\:VSS \5\:VSS) resistor r=0.1277 c=0
Rk67 (\5\:VSS \6\:VSS) resistor r=0.4233 c=0
Rk68 (\6\:VSS \7\:VSS) resistor r=0.04994 c=0
Rk69 (\7\:VSS \8\:VSS) resistor r=0.5087 c=0
Rk70 (\8\:VSS \9\:VSS) resistor r=0.5946 c=0
Rk71 (\3\:VSS \11\:VSS) resistor r=0.2803 c=0
Rk72 (\5\:VSS \13\:VSS) resistor r=0.07369 c=0
Rk73 (\6\:VSS \15\:VSS) resistor r=0.139 c=0
Rk74 (\8\:VSS \17\:VSS) resistor r=0.3556 c=0
Rk75 (\9\:VSS \18\:VSS) resistor r=0.604 c=0
Rk77 (\19\:VSS VSS) resistor r=0.04989 c=0
Rk76 (\18\:VSS \19\:VSS) resistor r=0.09758 c=0
Rk78 (\9\:VSS \21\:VSS) resistor r=0.1919 c=0
Rk79 (\18\:VSS \23\:VSS) resistor r=0.2823 c=0
Rk4 (\12\:Ckb \13\:Ckb) resistor r=0.264 c=0
Rk5 (\13\:Ckb \15\:Ckb) resistor r=0.6247 c=0
Rk6 (\13\:Ckb \17\:Ckb) resistor r=0.097 c=0
Rk10 (\18\:Ckb \19\:Ckb) resistor r=0.7787 c=0
Rk14 (\9\:CKbb \10\:CKbb) resistor r=0.06544 c=0
Rk15 (\10\:CKbb \11\:CKbb) resistor r=1.0271 c=0
Rk16 (\11\:CKbb \12\:CKbb) resistor r=0.206 c=0
Rk17 (\12\:CKbb \14\:CKbb) resistor r=0.2701 c=0
Rk18 (\10\:CKbb \15\:CKbb) resistor r=0.1694 c=0
Rk19 (\11\:CKbb \16\:CKbb) resistor r=0.03536 c=0
Rk20 (\12\:CKbb \17\:CKbb) resistor r=0.3682 c=0
Rk21 (\14\:CKbb \19\:CKbb) resistor r=0.6437 c=0
Rk7 (\4\:n20 \5\:n20) resistor r=0.418 c=0
Rk8 (\5\:n20 \7\:n20) resistor r=0.2991 c=0
Rk9 (\5\:n20 \9\:n20) resistor r=0.1276 c=0
Rk25 (\2\:Db \4\:Db) resistor r=2.2342 c=0
Rk26 (\4\:Db \6\:Db) resistor r=0.4026 c=0
Rk27 (\2\:Db \8\:Db) resistor r=0.4021 c=0
Rk11 (\4\:mout \5\:mout) resistor r=0.2686 c=0
Rk12 (\5\:mout \7\:mout) resistor r=0.2496 c=0
Rk13 (\5\:mout \9\:mout) resistor r=0.1967 c=0
Rk22 (\5\:n30 \6\:n30) resistor r=0.1777 c=0
Rk23 (\6\:n30 \8\:n30) resistor r=0.3393 c=0
Rk24 (\6\:n30 \9\:n30) resistor r=0.2477 c=0
Rk39 (\12\:qbint \14\:qbint) resistor r=1.1577 c=0
Rk40 (\14\:qbint \15\:qbint) resistor r=0.2845 c=0
Rk41 (\15\:qbint \16\:qbint) resistor r=0.1978 c=0
Rk42 (\15\:qbint \18\:qbint) resistor r=0.09309 c=0
Rk35 (\6\:Eb \8\:Eb) resistor r=0.4001 c=0
Rk36 (\8\:Eb \9\:Eb) resistor r=0.7067 c=0
Rk43 (\4\:qint \6\:qint) resistor r=0.2017 c=0
Rk44 (\6\:qint \8\:qint) resistor r=0.2148 c=0
Rl30 (\1\:D \2\:D) resistor r=81.461 c=0
Rl31 (\2\:D \3\:D) resistor r=37.2302 c=0
Rl2 (\2\:CK \3\:CK) resistor r=155.002 c=0
Rl1 (\1\:CK \2\:CK) resistor r=99.2328 c=0
Rl32 (\5\:E \6\:E) resistor r=56.461 c=0
Rl33 (\6\:E \7\:E) resistor r=62.2302 c=0
Rl26 (\3\:E \4\:E) resistor r=29.5379 c=0
Rl25 (\1\:E \2\:E) resistor r=60.3072 c=0
Rl18 (\9\:Ckb \10\:Ckb) resistor r=238.027 c=0
Rl19 (\10\:Ckb \11\:Ckb) resistor r=101.436 c=0
Rl8 (\5\:Ckb \6\:Ckb) resistor r=50.6918 c=0
Rl10 (\4\:Ckb \8\:Ckb) resistor r=57.1486 c=0
Rl4 (Ckb \2\:Ckb) resistor r=30.4507 c=0
Rl7 (\2\:Ckb \5\:Ckb) resistor r=168.774 c=0
Rl9 (\3\:Ckb \7\:Ckb) resistor r=193.39 c=0
Rl6 (\3\:Ckb \4\:Ckb) resistor r=14.7598 c=0
Rl5 (\2\:Ckb \3\:Ckb) resistor r=155.844 c=0
Rl17 (\7\:CKbb \8\:CKbb) resistor r=47.0254 c=0
Rl16 (\5\:CKbb \6\:CKbb) resistor r=29.5379 c=0
Rl11 (\3\:CKbb \4\:CKbb) resistor r=64.6174 c=0
Rl3 (CKbb \2\:CKbb) resistor r=39.1533 c=0
Rl14 (n20 \2\:n20) resistor r=89.1533 c=0
Rl15 (\2\:n20 \3\:n20) resistor r=29.5379 c=0
Rl12 (mout \2\:mout) resistor r=24.2328 c=0
Rl13 (\2\:mout \3\:mout) resistor r=91.5405 c=0
Rl23 (n30 \2\:n30) resistor r=85.7134 c=0
Rl24 (\2\:n30 \3\:n30) resistor r=26.098 c=0
Rl37 (\8\:qbint \9\:qbint) resistor r=29.5379 c=0
Rl20 (qbint \2\:qbint) resistor r=1.2713 c=0
Rl22 (\2\:qbint \4\:qbint) resistor r=36.2526 c=0
Rl21 (\2\:qbint \3\:qbint) resistor r=99.7141 c=0
Rl34 (\5\:qbint \6\:qbint) resistor r=44.4949 c=0
Rl38 (\6\:qbint \10\:qbint) resistor r=47.7584 c=0
Rl39 (\7\:qbint \11\:qbint) resistor r=35.772 c=0
Rl36 (\7\:qbint \8\:qbint) resistor r=53.0797 c=0
Rl35 (\6\:qbint \7\:qbint) resistor r=77.7612 c=0
Rl27 (Eb \2\:Eb) resistor r=23.5324 c=0
Rl28 (\2\:Eb \3\:Eb) resistor r=149.587 c=0
Rl29 (\2\:Eb \4\:Eb) resistor r=33.1028 c=0
Rl40 (qint \2\:qint) resistor r=133.848 c=0
Rl41 (\2\:qint \3\:qint) resistor r=26.1559 c=0
Rz12 (\1\:QN \2\:QN) resistor r=75 c=0
Rz13 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz14 (\1\:VDD \5\:VDD) resistor r=6.25 c=0
Rz15 (\1\:VDD \8\:VDD) resistor r=15 c=0
Rz16 (\1\:VDD \10\:VDD) resistor r=10.7143 c=0
Rz17 (\1\:VDD \12\:VDD) resistor r=37.5 c=0
Rz9 (\1\:Q \2\:Q) resistor r=75 c=0
Rz18 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz19 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz20 (\14\:VSS \15\:VSS) resistor r=75 c=0
Rz21 (\16\:VSS \17\:VSS) resistor r=75 c=0
Rz22 (\20\:VSS \21\:VSS) resistor r=75 c=0
Rz23 (\22\:VSS \23\:VSS) resistor r=75 c=0
Rz1 (\16\:Ckb \17\:Ckb) resistor r=75 c=0
Rz4 (\13\:CKbb \14\:CKbb) resistor r=75 c=0
Rz2 (\8\:n20 \9\:n20) resistor r=75 c=0
Rz6 (\5\:Db \6\:Db) resistor r=75 c=0
Rz7 (\7\:Db \8\:Db) resistor r=75 c=0
Rz3 (\6\:mout \7\:mout) resistor r=75 c=0
Rz5 (\4\:n30 \5\:n30) resistor r=75 c=0
Rz10 (\13\:qbint \14\:qbint) resistor r=75 c=0
Rz8 (\7\:Eb \8\:Eb) resistor r=75 c=0
Rz11 (\5\:qint \6\:qint) resistor r=75 c=0
Ry12 (\3\:QN \4\:QN) resistor r=62 c=0
Ry13 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry14 (\15\:VDD \16\:VDD) resistor r=62 c=0
Ry15 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry16 (\19\:VDD \20\:VDD) resistor r=62 c=0
Ry17 (\21\:VDD \22\:VDD) resistor r=62 c=0
Ry18 (\23\:VDD \24\:VDD) resistor r=62 c=0
Ry9 (\3\:Q \4\:Q) resistor r=62 c=0
Ry19 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry20 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry21 (\1\:VSS \7\:VSS) resistor r=6.2 c=0
Ry22 (\1\:VSS \9\:VSS) resistor r=5.1667 c=0
Ry23 (\1\:VSS \19\:VSS) resistor r=31 c=0
Ry1 (\14\:Ckb \15\:Ckb) resistor r=62 c=0
Ry4 (\18\:CKbb \19\:CKbb) resistor r=62 c=0
Ry2 (\6\:n20 \7\:n20) resistor r=62 c=0
Ry6 (Db \2\:Db) resistor r=62 c=0
Ry7 (\3\:Db \4\:Db) resistor r=62 c=0
Ry3 (\8\:mout \9\:mout) resistor r=62 c=0
Ry5 (\7\:n30 \8\:n30) resistor r=62 c=0
Ry10 (\17\:qbint \18\:qbint) resistor r=62 c=0
Ry8 (\5\:Eb \6\:Eb) resistor r=62 c=0
Ry11 (\7\:qint \8\:qint) resistor r=62 c=0
Rx12 (\2\:D \4\:D) resistor r=45 c=0
Rx1 (\2\:CK \4\:CK) resistor r=45 c=0
Rx13 (\4\:E \8\:E) resistor r=45 c=0
Rx14 (\2\:E \10\:E) resistor r=45 c=0
Rx15 (\6\:E \11\:E) resistor r=45 c=0
Rx2 (\4\:Ckb \12\:Ckb) resistor r=45 c=0
Rx4 (\11\:Ckb \18\:Ckb) resistor r=45 c=0
Rx5 (\6\:Ckb \19\:Ckb) resistor r=45 c=0
Rx7 (\6\:CKbb \9\:CKbb) resistor r=45 c=0
Rx8 (\8\:CKbb \15\:CKbb) resistor r=45 c=0
Rx9 (\4\:CKbb \16\:CKbb) resistor r=45 c=0
Rx10 (\2\:CKbb \17\:CKbb) resistor r=45 c=0
Rx3 (\2\:n20 \4\:n20) resistor r=45 c=0
Rx6 (\2\:mout \4\:mout) resistor r=45 c=0
Rx11 (\2\:n30 \9\:n30) resistor r=45 c=0
Rx17 (\9\:qbint \12\:qbint) resistor r=45 c=0
Rx18 (qbint \16\:qbint) resistor r=45 c=0
Rx16 (\4\:Eb \9\:Eb) resistor r=45 c=0
Rx19 (\2\:qint \4\:qint) resistor r=45 c=0
mn20 (\16\:Ckb \1\:CK \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn21 (\13\:CKbb \8\:Ckb \22\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.32e-14 ad=2.465e-14 ps=6.1e-07 pd=6.3e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.7e-07 sd=160n sca=10.7143 \
        scb=0.0101371 scc=0.000327098 m=(1)
mn25 (\5\:Db Ckb \8\:n20 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.422e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn36 (\8\:n20 \3\:CKbb net411 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.9e-14 ad=4.422e-14 ps=6.9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.9e-07 sb=2e-06 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn35 (net411 \3\:mout \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.97e-14 ad=2.9e-14 ps=1.36e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=2e-06 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn30 (\6\:mout \3\:n20 \20\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=6.97e-14 ad=5.22e-14 ps=1.36e-06 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=2e-06 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn40 (\6\:mout \5\:CKbb \4\:n30 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.075e-14 ad=5.22e-14 ps=9.9e-07 pd=1.01e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.405e-06 sb=2e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn50 (net415 \3\:qbint \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.19e-14 ad=8.7e-15 ps=7.3e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.905e-06 sb=1.605e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn51 (\4\:n30 \9\:Ckb net415 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=5.075e-14 ps=4.1e-07 pd=9.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.8e-06 sb=1.71e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn45 (\13\:qbint \3\:n30 \16\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=3.19e-14 ad=2.61e-14 ps=7.3e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.34e-06 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn1 (\13\:qbint \3\:Eb \7\:Db VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.553e-14 ad=2.61e-14 ps=7.8e-07 pd=6.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.115e-06 sd=160n sca=22.3376 \
        scb=0.0224607 scc=0.00248252 m=(1)
mn3 (\7\:Db \3\:E n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.77e-14 ad=3.553e-14 ps=8.1e-07 pd=7.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=8.25e-07 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn2 (n0 \3\:D \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.888e-14 ad=3.77e-14 ps=1.49e-06 pd=8.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5.2e-07 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn0 (\7\:Eb \7\:E \14\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=7.888e-14 ad=2.9e-14 ps=1.49e-06 pd=6.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=2e-07 sd=160n sca=22.3376 scb=0.0224607 \
        scc=0.00248252 m=(1)
mn55 (\1\:Q \8\:qbint \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=5.625e-14 ad=2.03e-14 ps=1.66e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.65e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn56 (\5\:qint \10\:qbint \12\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=5.625e-14 ad=2.03e-14 ps=1.66e-06 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.65e-07 sb=1.4e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn57 (\1\:QN \3\:qint \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.248e-14 ad=2.755e-14 ps=6e-07 pd=6.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.55e-07 sb=1.9e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
mp25 (\6\:n20 CKbb \3\:Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.655e-14 ad=3.44e-14 ps=7.7e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.7e-07 sb=2e-06 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp36 (\6\:n20 \5\:Ckb net342 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.773e-14 ad=3.44e-14 ps=1.06e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.75e-07 sb=2e-06 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp30 (\8\:mout n20 \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.39e-14 ad=9.997e-14 ps=1.48e-06 pd=1.36e-06 nrd=1.16667 \
        nrs=1.16667 sa=1e-06 sb=2e-06 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp35 (net342 mout \21\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=8.39e-14 ad=6.773e-14 ps=1.48e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=7.35e-07 sb=2e-06 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp40 (\7\:n30 \10\:Ckb \8\:mout VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.997e-14 ad=4.837e-14 ps=1.36e-06 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.51e-06 sb=1.98e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp51 (\7\:n30 \7\:CKbb net362 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.72e-14 ad=4.837e-14 ps=5.9e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.78e-06 sb=1.71e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp50 (net362 \4\:qbint \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=9.35e-14 ad=1.72e-14 ps=1.64e-06 pd=5.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.905e-06 sb=1.585e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp45 (\17\:qbint n30 \19\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.35e-14 ad=3.87e-14 ps=1.64e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.32e-06 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp1 (\17\:qbint \1\:E Db VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.87e-14 ps=7.5e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.095e-06 sd=160n sca=15.2551 \
        scb=0.0150251 scc=0.000885438 m=(1)
mp3 (Db Eb n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=7.418e-14 \
        ad=3.44e-14 ps=1.12e-06 pd=7.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=2e-06 sb=8.9e-07 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp2 (n1 \1\:D \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.093e-14 ad=7.418e-14 ps=1.51e-06 pd=1.12e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=5e-07 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp0 (\5\:Eb \5\:E \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=9.093e-14 ad=3.87e-14 ps=1.51e-06 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.8e-07 sd=160n sca=15.2551 scb=0.0150251 \
        scc=0.000885438 m=(1)
mp55 (\3\:Q \11\:qbint \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.73e-14 ad=3.01e-14 ps=8.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.05e-07 sd=160n sca=45.7906 \
        scb=0.0283307 scc=0.00588417 m=(1)
mp56 (\7\:qint \5\:qbint \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=4.73e-14 ad=3.01e-14 ps=8.7e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.05e-07 sb=1.4e-07 sd=160n sca=46.3496 \
        scb=0.0285354 scc=0.00588424 m=(1)
mp57 (\3\:QN qint \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.87e-14 ps=7.1e-07 pd=7.9e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.8e-07 sd=160n sca=24.9702 \
        scb=0.0291896 scc=0.0015765 m=(1)
ends EDFFXL
// End of subcircuit definition.

// Generated for: spectre (May  9 14:55:28 2012 )
// Library name: gsclib045
// Cell name: FSWNX1
// View name: extracted

simulator lang=spectre

subckt FSWNX1 ExtVSS PSOn PSOn_out VDD VSS
mp0 (\106\:n0 pso \3\:VDD VDD) g45p1svt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.2e-14 ad=7.275e-14 ps=1.22e-06 pd=1.23e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.48667e-07 sd=160n sca=18.9162 \
        scb=0.0187423 scc=0.000867404 m=(2)
NM1 (ExtVSS \2\:n0 VSS ExtVSS) g45n1hvt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.2e-14 ad=4.8e-14 ps=8.8e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.9124 scb=0.0109939 \
        scc=0.000240529 m=(2)
C1 (VDD ExtVSS) capacitor c=1.11498e-16
C2 (VSS ExtVSS) capacitor c=2.88036e-16
C3 (PSOn ExtVSS) capacitor c=5.50819e-17
C4 (PSOn_out ExtVSS) capacitor c=4.05909e-17
C5 (n0 ExtVSS) capacitor c=8.33847e-17
C6 (pso ExtVSS) capacitor c=9.6981e-17
C7 (\3\:PSOn ExtVSS) capacitor c=4.83348e-17
C8 (\9\:pso ExtVSS) capacitor c=4.75616e-17
C9 (\4\:PSOn ExtVSS) capacitor c=4.44168e-17
C10 (\8\:pso ExtVSS) capacitor c=3.38813e-17
C11 (\6\:pso ExtVSS) capacitor c=1.16965e-16
C12 (\1\:PSOn ExtVSS) capacitor c=2.18931e-17
C13 (\5\:pso ExtVSS) capacitor c=2.12596e-17
C14 (\16\:pso ExtVSS) capacitor c=4.39882e-17
C15 (\106\:n0 ExtVSS) capacitor c=8.91918e-17
C16 (\4\:PSOn_out ExtVSS) capacitor c=4.98909e-17
C17 (\19\:VDD ExtVSS) capacitor c=7.54078e-17
C18 (\13\:VDD ExtVSS) capacitor c=2.92778e-16
C19 (\1\:VDD ExtVSS) capacitor c=3.12517e-16
C20 (\12\:pso ExtVSS) capacitor c=3.72216e-17
C21 (\102\:n0 ExtVSS) capacitor c=6.88609e-17
C22 (\2\:PSOn_out ExtVSS) capacitor c=3.86985e-17
C23 (VSS ExtVSS) capacitor c=3.62194e-15
C24 (ExtVSS ExtVSS) capacitor c=1.93903e-15
C25 (ExtVSS ExtVSS) capacitor c=1.95429e-15
C26 (\2\:n0 ExtVSS) capacitor c=1.83807e-15
C27 (\11\:pso ExtVSS) capacitor c=7.14565e-18
C28 (\2\:PSOn ExtVSS) capacitor c=3.53518e-17
C29 (\104\:n0 ExtVSS) capacitor c=5.51167e-17
C30 (\105\:n0 ExtVSS) capacitor c=8.3284e-17
C31 (\1\:PSOn_out ExtVSS) capacitor c=2.50002e-17
C32 (\14\:pso ExtVSS) capacitor c=4.60305e-17
C33 (\15\:pso ExtVSS) capacitor c=3.42431e-17
C34 (\3\:VDD ExtVSS) capacitor c=1.62464e-16
Rk77 (\2\:VDD \3\:VDD) resistor r=0.1431 c=0
Rk80 (\3\:VDD \6\:VDD) resistor r=0.1029 c=0
Rk82 (\7\:VDD VDD) resistor r=0.2512 c=0
Rk81 (\6\:VDD \7\:VDD) resistor r=0.7041 c=0
Rk84 (\8\:VDD VDD) resistor r=0.3216 c=0
Rk83 (VDD \8\:VDD) resistor r=0.9558 c=0
Rk87 (\14\:VDD \15\:VDD) resistor r=0.2487 c=0
Rk88 (\15\:VDD \16\:VDD) resistor r=0.1029 c=0
Rk90 (\17\:VDD VDD) resistor r=0.2512 c=0
Rk89 (\16\:VDD \17\:VDD) resistor r=0.7041 c=0
Rk92 (\18\:VDD VDD) resistor r=0.3216 c=0
Rk91 (VDD \18\:VDD) resistor r=0.9558 c=0
Rk93 (\15\:VDD \20\:VDD) resistor r=0.3503 c=0
Rk37 (\54\:ExtVSS ExtVSS) resistor r=1.1412 c=0
Rk1 (\2\:ExtVSS ExtVSS) resistor r=0.6052 c=0
Rk70 (PSOn_out \1\:PSOn_out) resistor r=0.0575 c=0
Rk71 (\1\:PSOn_out \3\:PSOn_out) resistor r=0.2484 c=0
Rk72 (\1\:PSOn_out \5\:PSOn_out) resistor r=0.289 c=0
Rk33 (\103\:n0 \104\:n0) resistor r=0.2733 c=0
Rk34 (\104\:n0 \105\:n0) resistor r=0.4418 c=0
Rk35 (\104\:n0 \107\:n0) resistor r=0.33 c=0
Rk73 (\13\:pso \14\:pso) resistor r=0.2605 c=0
Rk74 (\14\:pso \15\:pso) resistor r=0.1719 c=0
Rk75 (\14\:pso \17\:pso) resistor r=0.2894 c=0
Rl113 (\2\:PSOn \3\:PSOn) resistor r=69.8745 c=0
Rl114 (\2\:PSOn \4\:PSOn) resistor r=78.3972 c=0
Rl112 (\1\:PSOn \2\:PSOn) resistor r=78.6409 c=0
Rl1 (\2\:n0 n0) resistor r=127.7 c=0
Rl108 (\8\:pso \9\:pso) resistor r=142.156 c=0
Rl105 (pso \6\:pso) resistor r=71.1857 c=0
Rl107 (\6\:pso \8\:pso) resistor r=117.602 c=0
Rl104 (pso \5\:pso) resistor r=6.5368 c=0
Rl111 (pso \11\:pso) resistor r=21.3783 c=0
Rl110 (\11\:pso \6\:pso) resistor r=44.6457 c=0
Rz47 (\2\:VDD \1\:VDD) resistor r=25 c=0
Rz48 (\3\:VDD \1\:VDD) resistor r=37.5 c=0
Rz49 (\6\:VDD \1\:VDD) resistor r=37.5 c=0
Rz50 (\7\:VDD \1\:VDD) resistor r=6.25 c=0
Rz51 (\8\:VDD \1\:VDD) resistor r=6.25 c=0
Rz52 (\14\:VDD \13\:VDD) resistor r=15 c=0
Rz53 (\16\:VDD \13\:VDD) resistor r=37.5 c=0
Rz54 (\17\:VDD \13\:VDD) resistor r=6.25 c=0
Rz55 (\18\:VDD \13\:VDD) resistor r=6.25 c=0
Rz1 (\2\:ExtVSS \1\:ExtVSS) resistor r=37.5 c=0
Rz45 (\2\:PSOn_out \3\:PSOn_out) resistor r=37.5 c=0
Rz22 (\103\:n0 \102\:n0) resistor r=37.5 c=0
Rz46 (\13\:pso \12\:pso) resistor r=37.5 c=0
Ry10 (\20\:VDD \19\:VDD) resistor r=20.6667 c=0
Ry6 (\4\:PSOn_out \5\:PSOn_out) resistor r=20.6667 c=0
Ry3 (\107\:n0 \106\:n0) resistor r=20.6667 c=0
Ry7 (\17\:pso \16\:pso) resistor r=20.6667 c=0
Rx3 (\1\:PSOn PSOn) resistor r=45 c=0
Rx1 (\105\:n0 n0) resistor r=11.25 c=0
Rx2 (\15\:pso \5\:pso) resistor r=45 c=0
mn0 (\54\:ExtVSS \6\:pso \102\:n0 ExtVSS) g45n1svt w=(3e-07) l=4.5e-08 \
        nf=1 as=4.85e-14 ad=4.8e-14 ps=9.3e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.48667e-07 sd=160n sca=11.7145 \
        scb=0.0111322 scc=0.000596114 m=(2)
NM0 (\1\:ExtVSS \8\:pso \2\:PSOn_out ExtVSS) g45n1svt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.4994 \
        scb=0.0122912 scc=0.000683921 m=(1)
NM2 (\54\:ExtVSS \4\:PSOn \12\:pso ExtVSS) g45n1svt w=(2.6e-07) \
        l=4.5e-08 nf=1 as=3.64e-14 ad=5.5e-14 ps=8e-07 pd=9.8e-07 \
        nrd=1.16667 nrs=1.16667 sa=5.8e-07 sb=1.4e-07 sd=160n sca=11.0409 \
        scb=0.0104003 scc=0.000454168 m=(1)
NM1_2__rcx (ExtVSS \2\:n0 VSS ExtVSS) g45n1hvt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.2e-14 ad=4.8e-14 ps=8.8e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=3.55731 \
        scb=0.000119604 scc=4.49056e-09 m=(2)
NM1_4__rcx (ExtVSS \2\:n0 VSS ExtVSS) g45n1hvt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.768e-14 ad=4.8e-14 ps=9.1789e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=7.82774 \
        scb=0.00401892 scc=2.05211e-05 m=(38)
NM1_6__rcx (ExtVSS \2\:n0 VSS ExtVSS) g45n1hvt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.768e-14 ad=4.8e-14 ps=9.1789e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=3.55731 \
        scb=0.000119604 scc=4.49056e-09 m=(38)
PM1 (\4\:PSOn_out \9\:pso \19\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=19.4801 \
        scb=0.0194426 scc=0.000970731 m=(1)
PM2 (\16\:pso \3\:PSOn \3\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=8.25e-14 ps=1.06e-06 pd=1.28e-06 nrd=1.16667 \
        nrs=1.16667 sa=5.8e-07 sb=1.4e-07 sd=160n sca=17.2987 \
        scb=0.0157992 scc=0.000772171 m=(1)
ends FSWNX1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:56:07 2012 )
// Library name: gsclib045
// Cell name: FSWX1
// View name: extracted

simulator lang=spectre

subckt FSWX1 ExtVSS PSO PSO_out VDD VSS
mp0 (\118\:n0 \1\:PSO \19\:VDD VDD) g45p1svt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.2e-14 ad=6.3e-14 ps=1.22e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=18.9162 \
        scb=0.0187423 scc=0.000867404 m=(2)
NM1 (ExtVSS \7\:n0 VSS ExtVSS) g45n1hvt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.2e-14 ad=4.8e-14 ps=8.8e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=11.9124 scb=0.0109939 \
        scc=0.000240529 m=(2)
C1 (VSS ExtVSS) capacitor c=2.87703e-16
C2 (PSO ExtVSS) capacitor c=2.28299e-17
C3 (PSO_out ExtVSS) capacitor c=3.74743e-16
C4 (VDD ExtVSS) capacitor c=1.03478e-16
C5 (n0 ExtVSS) capacitor c=3.14823e-16
C6 (\1\:PSO ExtVSS) capacitor c=1.79647e-16
C7 (\35\:n0 ExtVSS) capacitor c=5.08794e-17
C8 (\118\:n0 ExtVSS) capacitor c=8.72221e-17
C9 (\1\:VDD ExtVSS) capacitor c=3.0468e-16
C10 (\17\:VDD ExtVSS) capacitor c=3.00576e-16
C11 (\114\:n0 ExtVSS) capacitor c=6.73126e-17
C12 (VSS ExtVSS) capacitor c=3.7167e-15
C13 (ExtVSS ExtVSS) capacitor c=1.9255e-15
C14 (ExtVSS ExtVSS) capacitor c=1.9496e-15
C15 (\6\:n0 ExtVSS) capacitor c=5.892e-17
C16 (\7\:n0 ExtVSS) capacitor c=1.81814e-15
C17 (\116\:n0 ExtVSS) capacitor c=5.66414e-17
C18 (\117\:n0 ExtVSS) capacitor c=7.09723e-17
C19 (\8\:PSO ExtVSS) capacitor c=5.14387e-17
C20 (\3\:VDD ExtVSS) capacitor c=2.11488e-16
C21 (\19\:VDD ExtVSS) capacitor c=1.36294e-16
Rk44 (PSO \8\:PSO) resistor r=0.05823 c=0
Rk47 (\57\:ExtVSS ExtVSS) resistor r=0.6558 c=0
Rk5 (\1\:ExtVSS ExtVSS) resistor r=1.1715 c=0
Rk81 (\2\:VDD \3\:VDD) resistor r=0.03762 c=0
Rk86 (\3\:VDD \8\:VDD) resistor r=0.1032 c=0
Rk88 (\9\:VDD VDD) resistor r=0.2518 c=0
Rk87 (\8\:VDD \9\:VDD) resistor r=0.7058 c=0
Rk90 (\10\:VDD VDD) resistor r=0.3224 c=0
Rk89 (VDD \10\:VDD) resistor r=0.9582 c=0
Rk94 (\18\:VDD \19\:VDD) resistor r=0.1435 c=0
Rk97 (\19\:VDD \22\:VDD) resistor r=0.1032 c=0
Rk99 (\23\:VDD VDD) resistor r=0.2518 c=0
Rk98 (\22\:VDD \23\:VDD) resistor r=0.7058 c=0
Rk101 (\24\:VDD VDD) resistor r=0.3224 c=0
Rk100 (VDD \24\:VDD) resistor r=0.9582 c=0
Rk1 (\115\:n0 \116\:n0) resistor r=0.2767 c=0
Rk2 (\116\:n0 \117\:n0) resistor r=0.3941 c=0
Rk3 (\116\:n0 \119\:n0) resistor r=0.3337 c=0
Rl5 (\6\:PSO \1\:PSO) resistor r=4.4477 c=0
Rl11 (\6\:n0 n0) resistor r=41.5959 c=0
Rl40 (\6\:n0 \35\:n0) resistor r=54.3811 c=0
Rl12 (\7\:n0 \6\:n0) resistor r=82.8994 c=0
Rz49 (\2\:VDD \1\:VDD) resistor r=75 c=0
Rz50 (\3\:VDD \1\:VDD) resistor r=18.75 c=0
Rz52 (\8\:VDD \1\:VDD) resistor r=37.5 c=0
Rz53 (\9\:VDD \1\:VDD) resistor r=6.25 c=0
Rz54 (\10\:VDD \1\:VDD) resistor r=6.25 c=0
Rz55 (\18\:VDD \17\:VDD) resistor r=25 c=0
Rz56 (\19\:VDD \17\:VDD) resistor r=37.5 c=0
Rz57 (\22\:VDD \17\:VDD) resistor r=37.5 c=0
Rz58 (\23\:VDD \17\:VDD) resistor r=6.25 c=0
Rz59 (\24\:VDD \17\:VDD) resistor r=6.25 c=0
Rz1 (\115\:n0 \114\:n0) resistor r=37.5 c=0
Ry1 (\119\:n0 \118\:n0) resistor r=20.6667 c=0
Rx2 (\8\:PSO \6\:PSO) resistor r=22.5 c=0
Rx1 (\117\:n0 \35\:n0) resistor r=11.25 c=0
mn0 (\1\:ExtVSS \1\:PSO \114\:n0 ExtVSS) g45n1svt w=(3e-07) l=4.5e-08 \
        nf=1 as=4.2e-14 ad=4.8e-14 ps=8.8e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.7145 \
        scb=0.0111322 scc=0.000596114 m=(2)
NM0 (\57\:ExtVSS n0 PSO_out ExtVSS) g45n1svt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.5e-14 ad=4.8e-14 ps=9e-07 pd=9.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.55e-07 sd=160n sca=11.7145 scb=0.0111322 \
        scc=0.000596114 m=(4)
NM1_2__rcx (ExtVSS \7\:n0 VSS ExtVSS) g45n1hvt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.2e-14 ad=4.8e-14 ps=8.8e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=3.55731 \
        scb=0.000119604 scc=4.49056e-09 m=(2)
NM1_4__rcx (ExtVSS \7\:n0 VSS ExtVSS) g45n1hvt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.768e-14 ad=4.8e-14 ps=9.1789e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=7.82774 \
        scb=0.00401892 scc=2.05211e-05 m=(38)
NM1_6__rcx (ExtVSS \7\:n0 VSS ExtVSS) g45n1hvt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.768e-14 ad=4.8e-14 ps=9.1789e-07 pd=9.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=3.55731 \
        scb=0.000119604 scc=4.49056e-09 m=(38)
PM1 (PSO_out n0 \3\:VDD VDD) g45p1svt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.2e-14 ad=6.75e-14 ps=1.22e-06 pd=1.2e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=18.9162 \
        scb=0.0187423 scc=0.000867404 m=(4)
ends FSWX1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:56:44 2012 )
// Library name: gsclib045
// Cell name: HOLDX1
// View name: extracted

simulator lang=spectre

subckt HOLDX1 VDD VSS Y
mp0 (\13\:n0 \1\:Y \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=7.63e-14 ad=6.24e-14 ps=1.55e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.6e-07 sb=3.8109e-07 sd=160n sca=36.9908 \
        scb=0.0284138 scc=0.00351818 m=(1)
C1 (Y VSS) capacitor c=1.93864e-17
C2 (VDD VSS) capacitor c=4.77914e-17
C3 (n0 VSS) capacitor c=1.60476e-17
C4 (p1 VSS) capacitor c=1.96408e-18
C5 (p2 VSS) capacitor c=1.96408e-18
C6 (\7\:n0 VSS) capacitor c=8.79857e-18
C7 (\9\:n0 VSS) capacitor c=2.57787e-17
C8 (\1\:Y VSS) capacitor c=3.77374e-17
C9 (\5\:n0 VSS) capacitor c=1.23445e-17
C10 (\6\:n0 VSS) capacitor c=5.62188e-18
C11 (\8\:n0 VSS) capacitor c=1.96161e-17
C12 (\3\:Y VSS) capacitor c=3.62291e-17
C13 (\4\:n0 VSS) capacitor c=2.7657e-17
C14 (\2\:Y VSS) capacitor c=3.1338e-17
C15 (\6\:Y VSS) capacitor c=2.4192e-17
C16 (\1\:VDD VSS) capacitor c=2.10165e-17
C17 (\13\:n0 VSS) capacitor c=4.75994e-17
C18 (\4\:Y VSS) capacitor c=1.6527e-17
C19 (\11\:n0 VSS) capacitor c=3.43523e-17
C20 (\2\:n0 VSS) capacitor c=7.09634e-18
C21 (\3\:n0 VSS) capacitor c=2.67231e-18
C22 (\10\:n0 VSS) capacitor c=4.32406e-17
C23 (\8\:Y VSS) capacitor c=7.64581e-17
C24 (\4\:VDD VSS) capacitor c=1.8105e-17
Rk3 (\5\:Y Y) resistor r=0.1558 c=0
Rk4 (Y \7\:Y) resistor r=0.06457 c=0
Rk5 (\7\:Y \8\:Y) resistor r=0.4701 c=0
Rk7 (\4\:VDD VDD) resistor r=0.1979 c=0
Rk6 (\2\:VDD \4\:VDD) resistor r=0.2694 c=0
Rk8 (\2\:VSS \3\:VSS) resistor r=0.1159 c=0
Rk10 (\4\:VSS VSS) resistor r=0.04914 c=0
Rk9 (\3\:VSS \4\:VSS) resistor r=0.1307 c=0
Rk11 (\3\:VSS \6\:VSS) resistor r=0.07157 c=0
Rk1 (\10\:n0 \12\:n0) resistor r=0.3069 c=0
Rk2 (\12\:n0 \14\:n0) resistor r=0.352 c=0
Rl1 (\1\:Y \2\:Y) resistor r=24.2328 c=0
Rl2 (\2\:Y \3\:Y) resistor r=39.6174 c=0
Rl10 (\4\:n0 \9\:n0) resistor r=39.6174 c=0
Rl9 (\4\:n0 \8\:n0) resistor r=24.2328 c=0
Rl3 (n0 \2\:n0) resistor r=60.772 c=0
Rl6 (\2\:n0 \5\:n0) resistor r=28.0797 c=0
Rl8 (\3\:n0 \7\:n0) resistor r=59.2509 c=0
Rl7 (\3\:n0 \6\:n0) resistor r=26.5586 c=0
Rl5 (\3\:n0 \4\:n0) resistor r=34.9837 c=0
Rl4 (\2\:n0 \3\:n0) resistor r=30.0863 c=0
Rz2 (\4\:Y \5\:Y) resistor r=75 c=0
Rz4 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz1 (\11\:n0 \12\:n0) resistor r=75 c=0
Ry2 (\6\:Y \7\:Y) resistor r=62 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=20.6667 c=0
Ry5 (\1\:VSS \4\:VSS) resistor r=31 c=0
Ry1 (\13\:n0 \14\:n0) resistor r=20.6667 c=0
Rx2 (\2\:Y \8\:Y) resistor r=45 c=0
Rx1 (\4\:n0 \10\:n0) resistor r=45 c=0
mn0 (\11\:n0 \3\:Y \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.635e-14 ad=3.64e-14 ps=1.72e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.81635e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
mn3 (n1 \8\:n0 \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=6.635e-14 ad=8.7e-15 ps=1.72e-06 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.95e-07 sb=3.5e-07 sd=160n sca=23.279 \
        scb=0.0230742 scc=0.00267719 m=(1)
mn2 (n1 \6\:n0 n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=8.7e-15 ps=4.1e-07 pd=4.1e-07 nrd=1.16667 nrs=1.16667 sa=5e-07 \
        sb=2.45e-07 sd=160n sca=23.279 scb=0.0230742 scc=0.00267719 m=(1)
mn1 (\4\:Y \5\:n0 n2 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 as=8.7e-15 \
        ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.05e-07 sb=1.4e-07 sd=160n sca=23.279 scb=0.0230742 \
        scc=0.00267719 m=(1)
mp3 (p1 \9\:n0 \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=7.63e-14 ad=1.29e-14 ps=1.55e-06 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.15e-07 sb=3.5e-07 sd=160n sca=50.7542 \
        scb=0.0334718 scc=0.00592392 m=(1)
mp2 (p1 \7\:n0 p2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=1.29e-14 ps=5.5e-07 pd=5.5e-07 nrd=1.16667 nrs=1.16667 \
        sa=5.2e-07 sb=2.45e-07 sd=160n sca=53.0765 scb=0.0380162 \
        scc=0.00612638 m=(1)
mp1 (\6\:Y n0 p2 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 as=1.29e-14 \
        ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 nrs=1.16667 \
        sa=6.25e-07 sb=1.4e-07 sd=160n sca=59.8576 scb=0.0474724 \
        scc=0.00729056 m=(1)
ends HOLDX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:19:45 2012 )
// Library name: gsclib045
// Cell name: HSWDNX1
// View name: extracted

simulator lang=spectre

subckt HSWDNX1 ExtVDD PSO1n PSO1n_out PSO2n PSO2n_out VDD VSS
PM3 (\56\:VDD n2 \13\:ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 \
        nf=1 as=6.3e-14 ad=6.3e-14 ps=1.18e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.7101 \
        scb=0.0128174 scc=0.00128324 m=(1)
PM2 (\11\:n2 \4\:PSO2n \49\:ExtVDD ExtVDD) g45p1svt w=(4.5e-07) \
        l=4.5e-08 nf=1 as=6.3e-14 ad=6.3e-14 ps=1.18e-06 pd=1.18e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=34.1613 \
        scb=0.0368451 scc=0.00393009 m=(1)
C1 (PSO1n_out VSS) capacitor c=4.36094e-17
C2 (PSO1n VSS) capacitor c=3.00601e-17
C3 (ExtVDD VSS) capacitor c=1.97963e-15
C4 (VDD VSS) capacitor c=2.52086e-16
C5 (PSO2n_out VSS) capacitor c=7.07038e-17
C6 (PSO2n VSS) capacitor c=9.27895e-17
C7 (n2 VSS) capacitor c=3.84845e-17
C8 (n1 VSS) capacitor c=1.10474e-15
C9 (\1\:PSO1n VSS) capacitor c=2.70014e-16
C10 (\4\:PSO2n VSS) capacitor c=3.93995e-17
C11 (\1\:PSO2n VSS) capacitor c=3.10568e-17
C12 (\15\:n1 VSS) capacitor c=1.22827e-16
C13 (\4\:n2 VSS) capacitor c=1.05296e-17
C14 (\3\:PSO2n VSS) capacitor c=1.00381e-17
C15 (\1\:ExtVDD VSS) capacitor c=1.46365e-17
C16 (\2\:ExtVDD VSS) capacitor c=1.27397e-17
C17 (\1\:PSO1n_out VSS) capacitor c=8.16108e-17
C18 (\56\:VDD VSS) capacitor c=8.67037e-17
C19 (\13\:ExtVDD VSS) capacitor c=9.60834e-17
C20 (\3\:PSO2n_out VSS) capacitor c=5.63427e-17
C21 (\11\:n2 VSS) capacitor c=8.5926e-17
C22 (\49\:ExtVDD VSS) capacitor c=6.03592e-17
C23 (\3\:PSO1n_out VSS) capacitor c=8.33652e-17
C24 (\1\:PSO2n_out VSS) capacitor c=8.07898e-17
C25 (\13\:n2 VSS) capacitor c=5.90114e-17
C26 (\2\:PSO2n VSS) capacitor c=1.21786e-17
C27 (\2\:n2 VSS) capacitor c=1.28276e-16
C28 (VDD VSS) capacitor c=2.64852e-15
C29 (ExtVDD VSS) capacitor c=8.84892e-16
C30 (ExtVDD VSS) capacitor c=8.60587e-16
C31 (\62\:n1 VSS) capacitor c=1.09005e-16
C32 (\14\:PSO1n VSS) capacitor c=1.38424e-17
C33 (\15\:PSO1n VSS) capacitor c=4.23846e-17
C34 (\9\:n2 VSS) capacitor c=2.81939e-17
C35 (\10\:n2 VSS) capacitor c=3.87556e-17
C36 (\69\:n1 VSS) capacitor c=1.10468e-16
C37 (\70\:n1 VSS) capacitor c=4.0904e-16
C38 (\12\:ExtVDD VSS) capacitor c=6.49737e-17
C39 (\15\:ExtVDD VSS) capacitor c=2.42427e-16
C40 (\18\:ExtVDD VSS) capacitor c=4.69319e-17
C41 (\64\:ExtVDD VSS) capacitor c=2.50055e-16
C42 (\66\:ExtVDD VSS) capacitor c=3.37653e-16
C43 (\69\:ExtVDD VSS) capacitor c=4.56028e-17
C44 (\11\:VDD VSS) capacitor c=1.64008e-16
Rk19 (\2\:PSO1n_out PSO1n_out) resistor r=0.2134 c=0
Rk20 (PSO1n_out \4\:PSO1n_out) resistor r=0.3308 c=0
Rk3 (\13\:PSO1n PSO1n) resistor r=0.005212 c=0
Rk4 (PSO1n \14\:PSO1n) resistor r=0.005054 c=0
Rk5 (\13\:PSO1n \14\:PSO1n) resistor r=0.0151 c=0
Rk7 (\14\:PSO1n \15\:PSO1n) resistor r=0.01661 c=0
Rk6 (\15\:PSO1n \16\:PSO1n) resistor r=0.005212 c=0
Rk29 (ExtVDD \12\:ExtVDD) resistor r=0.1574 c=0
Rk30 (\12\:ExtVDD \14\:ExtVDD) resistor r=0.6617 c=0
Rk31 (\14\:ExtVDD \15\:ExtVDD) resistor r=0.426 c=0
Rk33 (\15\:ExtVDD \17\:ExtVDD) resistor r=0.3543 c=0
Rk34 (\17\:ExtVDD \18\:ExtVDD) resistor r=0.05305 c=0
Rk50 (\17\:ExtVDD \50\:ExtVDD) resistor r=0.2214 c=0
Rk61 (ExtVDD \64\:ExtVDD) resistor r=0.3296 c=0
Rk63 (\64\:ExtVDD \66\:ExtVDD) resistor r=0.259 c=0
Rk66 (\66\:ExtVDD \69\:ExtVDD) resistor r=0.05305 c=0
Rk91 (\11\:VDD VDD) resistor r=0.4233 c=0
Rk90 (VDD \11\:VDD) resistor r=0.4677 c=0
Rk114 (\11\:VDD \57\:VDD) resistor r=0.3808 c=0
Rk11 (\2\:PSO2n_out PSO2n_out) resistor r=0.4029 c=0
Rk12 (PSO2n_out \4\:PSO2n_out) resistor r=0.06067 c=0
Rk116 (\3\:VSS VSS) resistor r=0.2003 c=0
Rk115 (\2\:VSS \3\:VSS) resistor r=0.9528 c=0
Rk120 (\4\:VSS VSS) resistor r=0.12 c=0
Rk117 (VSS \4\:VSS) resistor r=0.4037 c=0
Rk129 (\21\:VSS VSS) resistor r=1.0027 c=0
Rk130 (VSS \22\:VSS) resistor r=0.1005 c=0
Rk134 (\23\:VSS VSS) resistor r=0.1425 c=0
Rk131 (\22\:VSS \23\:VSS) resistor r=0.6116 c=0
Rk135 (VSS \26\:VSS) resistor r=0.08029 c=0
Rk136 (\26\:VSS \27\:VSS) resistor r=0.06249 c=0
Rk139 (\26\:VSS \33\:VSS) resistor r=0.3085 c=0
Rk8 (\9\:n2 \10\:n2) resistor r=0.1621 c=0
Rk9 (\10\:n2 \12\:n2) resistor r=0.2722 c=0
Rk10 (\10\:n2 \14\:n2) resistor r=0.2146 c=0
Rk13 (\69\:n1 \70\:n1) resistor r=0.4476 c=0
Rl1 (\2\:ExtVDD \1\:ExtVDD) resistor r=52.0063 c=0
Rl4 (\2\:PSO2n \4\:PSO2n) resistor r=38.9859 c=0
Rl2 (\1\:PSO2n \2\:PSO2n) resistor r=59.6246 c=0
Rl3 (\2\:PSO2n \3\:PSO2n) resistor r=3.1183 c=0
Rl16 (\2\:n2 n2) resistor r=191.771 c=0
Rl18 (\2\:n2 \4\:n2) resistor r=9.0434 c=0
Rl36 (n1 \15\:n1) resistor r=314.651 c=0
Rl83 (\62\:n1 \15\:n1) resistor r=50.14 c=0
Rz5 (\4\:PSO1n_out \3\:PSO1n_out) resistor r=37.5 c=0
Rz2 (\2\:PSO2n_out \1\:PSO2n_out) resistor r=37.5 c=0
Rz14 (\33\:VSS \32\:VSS) resistor r=37.5 c=0
Rz1 (\14\:n2 \13\:n2) resistor r=37.5 c=0
Ry5 (\2\:PSO1n_out \1\:PSO1n_out) resistor r=20.6667 c=0
Ry8 (\14\:ExtVDD \13\:ExtVDD) resistor r=20.6667 c=0
Ry23 (\50\:ExtVDD \49\:ExtVDD) resistor r=20.6667 c=0
Ry67 (\57\:VDD \56\:VDD) resistor r=20.6667 c=0
Ry2 (\4\:PSO2n_out \3\:PSO2n_out) resistor r=20.6667 c=0
Ry71 (VSS \1\:VSS) resistor r=6.8889 c=0
Ry68 (\2\:VSS \1\:VSS) resistor r=8.8571 c=0
Ry69 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry70 (\4\:VSS \1\:VSS) resistor r=31 c=0
Ry72 (\21\:VSS \20\:VSS) resistor r=6.2 c=0
Ry73 (\22\:VSS \20\:VSS) resistor r=5.1667 c=0
Ry74 (\23\:VSS \20\:VSS) resistor r=31 c=0
Ry75 (\27\:VSS \20\:VSS) resistor r=10.3333 c=0
Ry1 (\12\:n2 \11\:n2) resistor r=20.6667 c=0
Rx2 (\16\:PSO1n \1\:PSO1n) resistor r=45 c=0
Rx5 (\18\:ExtVDD \1\:ExtVDD) resistor r=45 c=0
Rx6 (\69\:ExtVDD \2\:ExtVDD) resistor r=45 c=0
Rx1 (\3\:PSO2n PSO2n) resistor r=45 c=0
Rx3 (\9\:n2 \4\:n2) resistor r=45 c=0
Rx4 (\69\:n1 \15\:n1) resistor r=9 c=0
NM0_2__rcx (VSS \1\:PSO1n \70\:n1 VSS) g45n1svt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.5e-14 ad=4.8e-14 ps=9e-07 pd=9.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.55e-07 sd=160n sca=10.637 scb=0.00973476 \
        scc=0.000429831 m=(4)
NM1 (\32\:VSS \1\:PSO2n \13\:n2 VSS) g45n1svt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.2e-14 ad=4.2e-14 ps=8.8e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.2701 \
        scb=0.0157116 scc=0.00141809 m=(1)
NM3 (\23\:VSS \2\:n2 \1\:PSO2n_out VSS) g45n1svt w=(3e-07) l=4.5e-08 \
        nf=1 as=4.8e-14 ad=4.2e-14 ps=9.2e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=16.2701 \
        scb=0.0157116 scc=0.00141809 m=(2)
NM4 (\4\:VSS \62\:n1 \3\:PSO1n_out VSS) g45n1svt w=(3e-07) l=4.5e-08 \
        nf=1 as=4.8e-14 ad=4.2e-14 ps=9.2e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=15.667 \
        scb=0.0153545 scc=0.001049 m=(2)
PM1_2__rcx (\70\:n1 \1\:PSO1n \66\:ExtVDD ExtVDD) g45p1svt w=(4.5e-07) \
        l=4.5e-08 nf=1 as=7.2e-14 ad=6.75e-14 ps=1.22e-06 pd=1.2e-06 \
        nrd=1.16667 nrs=1.16667 sa=5.5e-07 sb=3.45e-07 sd=160n sca=18.7693 \
        scb=0.0154144 scc=0.00171488 m=(4)
PM5 (\3\:PSO2n_out \2\:n2 \15\:ExtVDD ExtVDD) g45p1svt w=(4.5e-07) \
        l=4.5e-08 nf=1 as=6.3e-14 ad=7.2e-14 ps=1.18e-06 pd=1.22e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=16.0001 \
        scb=0.0136275 scc=0.00128433 m=(2)
PM6 (\1\:PSO1n_out \62\:n1 \64\:ExtVDD ExtVDD) g45p1svt w=(4.5e-07) \
        l=4.5e-08 nf=1 as=6.3e-14 ad=7.2e-14 ps=1.18e-06 pd=1.22e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=16.5166 \
        scb=0.0139334 scc=0.0015954 m=(2)
PM0_1__rcx (VDD n1 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.02e-14 ad=7.2e-14 ps=1.212e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=37.8738 scb=0.0220613 \
        scc=0.00371947 m=(20)
PM0_21__rcx (VDD n1 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.071e-14 ad=7.2e-14 ps=1.21429e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.37e-06 sd=160n sca=35.2833 \
        scb=0.0187724 scc=0.00367895 m=(14)
PM0_23__rcx (VDD n1 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.071e-14 ad=7.2e-14 ps=1.21429e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.165e-06 sb=1.37e-06 sd=160n sca=4.07325 \
        scb=0.000378105 scc=2.57733e-07 m=(14)
ends HSWDNX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:22:44 2012 )
// Library name: gsclib045
// Cell name: HSWDX1
// View name: extracted

simulator lang=spectre

subckt HSWDX1 ExtVDD PSO1 PSO1_out PSO2 PSO2_out VDD VSS
PM3 (\56\:VDD n2 \13\:ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 \
        nf=1 as=6.3e-14 ad=6.3e-14 ps=1.18e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.0912 \
        scb=0.0107219 scc=0.000815487 m=(1)
PM8 (\16\:pso1n \1\:PSO1 \67\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=38.4244 \
        scb=0.0401517 scc=0.00462137 m=(1)
C1 (PSO1_out VSS) capacitor c=3.02562e-17
C2 (ExtVDD VSS) capacitor c=1.93345e-15
C3 (PSO1 VSS) capacitor c=4.46461e-17
C4 (PSO2 VSS) capacitor c=8.05999e-17
C5 (PSO2_out VSS) capacitor c=4.31599e-17
C6 (VDD VSS) capacitor c=2.98672e-16
C7 (pso2n VSS) capacitor c=3.53116e-17
C8 (n2 VSS) capacitor c=8.55724e-17
C9 (pso1n VSS) capacitor c=5.07265e-17
C10 (n1 VSS) capacitor c=1.11268e-15
C11 (\5\:pso2n VSS) capacitor c=2.97877e-17
C12 (\6\:pso2n VSS) capacitor c=3.25236e-17
C13 (\3\:PSO2 VSS) capacitor c=4.17307e-17
C14 (\1\:PSO1 VSS) capacitor c=3.57456e-17
C15 (\7\:pso1n VSS) capacitor c=2.7165e-17
C16 (\7\:pso2n VSS) capacitor c=3.30591e-17
C17 (\1\:PSO2 VSS) capacitor c=2.81448e-17
C18 (\4\:PSO1 VSS) capacitor c=2.87625e-17
C19 (\15\:n1 VSS) capacitor c=1.10462e-16
C20 (\2\:n2 VSS) capacitor c=8.7023e-17
C21 (\4\:pso2n VSS) capacitor c=1.10444e-17
C22 (\1\:ExtVDD VSS) capacitor c=1.57425e-17
C23 (\2\:ExtVDD VSS) capacitor c=9.02237e-18
C24 (\2\:PSO2 VSS) capacitor c=2.90335e-17
C25 (\3\:PSO1 VSS) capacitor c=1.45477e-17
C26 (\1\:VDD VSS) capacitor c=2.52495e-15
C27 (\3\:PSO1_out VSS) capacitor c=7.85367e-17
C28 (\89\:ExtVDD VSS) capacitor c=6.29969e-17
C29 (\56\:VDD VSS) capacitor c=9.1347e-17
C30 (\13\:ExtVDD VSS) capacitor c=1.29541e-16
C31 (\1\:PSO2_out VSS) capacitor c=8.42581e-17
C32 (\62\:n1 VSS) capacitor c=4.02396e-16
C33 (\46\:ExtVDD VSS) capacitor c=6.99237e-17
C34 (\5\:n2 VSS) capacitor c=1.0361e-16
C35 (\48\:ExtVDD VSS) capacitor c=7.89803e-17
C36 (\10\:pso2n VSS) capacitor c=7.97223e-17
C37 (\16\:pso1n VSS) capacitor c=7.22933e-17
C38 (\18\:ExtVDD VSS) capacitor c=6.1596e-17
C39 (\67\:ExtVDD VSS) capacitor c=5.70596e-17
C40 (\1\:PSO1_out VSS) capacitor c=6.39624e-17
C41 (\3\:PSO2_out VSS) capacitor c=4.13035e-17
C42 (\3\:n2 VSS) capacitor c=6.89055e-17
C43 (\12\:pso2n VSS) capacitor c=5.1348e-17
C44 (\19\:pso1n VSS) capacitor c=5.23295e-17
C45 (\2\:PSO1 VSS) capacitor c=1.77622e-17
C46 (\2\:pso2n VSS) capacitor c=2.46604e-17
C47 (\3\:pso2n VSS) capacitor c=2.02984e-17
C48 (\2\:pso1n VSS) capacitor c=2.75273e-17
C49 (\3\:pso1n VSS) capacitor c=2.72842e-16
C50 (VDD VSS) capacitor c=6.41421e-17
C51 (ExtVDD VSS) capacitor c=8.76837e-16
C52 (ExtVDD VSS) capacitor c=9.03303e-16
C53 (\5\:PSO1 VSS) capacitor c=2.6388e-17
C54 (\8\:pso2n VSS) capacitor c=3.44771e-17
C55 (\9\:pso2n VSS) capacitor c=4.47443e-17
C56 (\18\:pso1n VSS) capacitor c=5.3465e-17
C57 (\21\:pso1n VSS) capacitor c=5.04598e-17
C58 (\7\:n2 VSS) capacitor c=4.93836e-17
C59 (\70\:n1 VSS) capacitor c=7.23116e-17
C60 (\12\:ExtVDD VSS) capacitor c=6.45047e-17
C61 (\15\:ExtVDD VSS) capacitor c=7.62511e-17
C62 (\16\:ExtVDD VSS) capacitor c=4.65118e-17
C63 (\17\:ExtVDD VSS) capacitor c=5.89687e-17
C64 (\62\:ExtVDD VSS) capacitor c=6.25694e-17
C65 (\63\:ExtVDD VSS) capacitor c=3.82735e-16
C66 (\66\:ExtVDD VSS) capacitor c=3.79501e-17
C67 (\11\:VDD VSS) capacitor c=1.90608e-16
Rk19 (PSO1_out \2\:PSO1_out) resistor r=0.2779 c=0
Rk20 (PSO1_out \4\:PSO1_out) resistor r=0.2761 c=0
Rk29 (ExtVDD \12\:ExtVDD) resistor r=0.2032 c=0
Rk30 (\12\:ExtVDD \14\:ExtVDD) resistor r=0.5738 c=0
Rk31 (\14\:ExtVDD \15\:ExtVDD) resistor r=0.5917 c=0
Rk32 (\15\:ExtVDD \16\:ExtVDD) resistor r=0.3575 c=0
Rk33 (\16\:ExtVDD \17\:ExtVDD) resistor r=0.122 c=0
Rk34 (\17\:ExtVDD \19\:ExtVDD) resistor r=0.4259 c=0
Rk48 (\15\:ExtVDD \47\:ExtVDD) resistor r=0.244 c=0
Rk49 (\16\:ExtVDD \49\:ExtVDD) resistor r=0.233 c=0
Rk59 (ExtVDD \62\:ExtVDD) resistor r=0.4763 c=0
Rk60 (\62\:ExtVDD \63\:ExtVDD) resistor r=0.2821 c=0
Rk63 (\63\:ExtVDD \66\:ExtVDD) resistor r=0.1226 c=0
Rk64 (\66\:ExtVDD \68\:ExtVDD) resistor r=0.4894 c=0
Rk75 (\62\:ExtVDD \90\:ExtVDD) resistor r=0.2208 c=0
Rk2 (\5\:PSO1 PSO1) resistor r=0.01431 c=0
Rk113 (\3\:VSS VSS) resistor r=0.2001 c=0
Rk112 (\2\:VSS \3\:VSS) resistor r=1.0018 c=0
Rk114 (VSS \4\:VSS) resistor r=0.3557 c=0
Rk115 (\4\:VSS \5\:VSS) resistor r=0.1799 c=0
Rk118 (\5\:VSS \8\:VSS) resistor r=0.0549 c=0
Rk120 (\9\:VSS VSS) resistor r=0.225 c=0
Rk119 (\8\:VSS \9\:VSS) resistor r=0.1676 c=0
Rk121 (\4\:VSS \11\:VSS) resistor r=0.2253 c=0
Rk125 (\9\:VSS \19\:VSS) resistor r=0.2253 c=0
Rk126 (\21\:VSS VSS) resistor r=1.0516 c=0
Rk127 (VSS \22\:VSS) resistor r=0.1004 c=0
Rk129 (\23\:VSS VSS) resistor r=0.2365 c=0
Rk128 (\22\:VSS \23\:VSS) resistor r=0.6159 c=0
Rk131 (\23\:VSS \26\:VSS) resistor r=0.3103 c=0
Rk132 (VSS \28\:VSS) resistor r=0.3522 c=0
Rk133 (VSS \29\:VSS) resistor r=0.2177 c=0
Rk134 (\29\:VSS \31\:VSS) resistor r=0.3 c=0
Rk135 (\29\:VSS \32\:VSS) resistor r=0.2327 c=0
Rk11 (\2\:PSO2_out PSO2_out) resistor r=0.3878 c=0
Rk12 (PSO2_out \4\:PSO2_out) resistor r=0.02008 c=0
Rk86 (\1\:VDD VDD) resistor r=0.02132 c=0
Rk88 (\11\:VDD VDD) resistor r=0.6207 c=0
Rk87 (VDD \11\:VDD) resistor r=0.3908 c=0
Rk111 (\11\:VDD \57\:VDD) resistor r=0.3589 c=0
Rk3 (\8\:pso2n \9\:pso2n) resistor r=0.165 c=0
Rk4 (\9\:pso2n \11\:pso2n) resistor r=0.3003 c=0
Rk5 (\9\:pso2n \13\:pso2n) resistor r=0.2251 c=0
Rk9 (\4\:n2 \6\:n2) resistor r=0.4947 c=0
Rk10 (\4\:n2 \7\:n2) resistor r=0.1893 c=0
Rk6 (\17\:pso1n \18\:pso1n) resistor r=0.3047 c=0
Rk7 (\18\:pso1n \20\:pso1n) resistor r=0.2202 c=0
Rk8 (\18\:pso1n \21\:pso1n) resistor r=0.1554 c=0
Rk17 (\62\:n1 \70\:n1) resistor r=0.4316 c=0
Rl6 (\2\:ExtVDD \1\:ExtVDD) resistor r=52.7912 c=0
Rl1 (\1\:PSO1 \2\:PSO1) resistor r=80.5599 c=0
Rl3 (\2\:PSO1 \4\:PSO1) resistor r=61.6718 c=0
Rl2 (\2\:PSO1 \3\:PSO1) resistor r=3.1183 c=0
Rl5 (\2\:PSO2 \3\:PSO2) resistor r=72.3229 c=0
Rl4 (\1\:PSO2 \2\:PSO2) resistor r=53.4808 c=0
Rl7 (pso2n \2\:pso2n) resistor r=64.9794 c=0
Rl10 (\2\:pso2n \5\:pso2n) resistor r=58.7731 c=0
Rl11 (\3\:pso2n \6\:pso2n) resistor r=60.3603 c=0
Rl12 (\3\:pso2n \7\:pso2n) resistor r=66.1296 c=0
Rl9 (\3\:pso2n \4\:pso2n) resistor r=8.6686 c=0
Rl8 (\2\:pso2n \3\:pso2n) resistor r=147.121 c=0
Rl13 (n2 \2\:n2) resistor r=516.588 c=0
Rl14 (\2\:pso1n pso1n) resistor r=97.9777 c=0
Rl19 (\2\:pso1n \7\:pso1n) resistor r=67.7766 c=0
Rl15 (\3\:pso1n \2\:pso1n) resistor r=184.691 c=0
Rl41 (n1 \15\:n1) resistor r=286.043 c=0
Rz7 (\1\:PSO1_out \2\:PSO1_out) resistor r=37.5 c=0
Rz9 (\11\:VSS \10\:VSS) resistor r=37.5 c=0
Rz13 (\19\:VSS \18\:VSS) resistor r=37.5 c=0
Rz14 (\26\:VSS \25\:VSS) resistor r=37.5 c=0
Rz15 (\28\:VSS \27\:VSS) resistor r=37.5 c=0
Rz16 (\31\:VSS \30\:VSS) resistor r=37.5 c=0
Rz4 (\3\:PSO2_out \4\:PSO2_out) resistor r=37.5 c=0
Rz1 (\12\:pso2n \13\:pso2n) resistor r=37.5 c=0
Rz3 (\3\:n2 \4\:n2) resistor r=37.5 c=0
Rz2 (\20\:pso1n \19\:pso1n) resistor r=37.5 c=0
Ry7 (\3\:PSO1_out \4\:PSO1_out) resistor r=20.6667 c=0
Ry10 (\14\:ExtVDD \13\:ExtVDD) resistor r=20.6667 c=0
Ry11 (\19\:ExtVDD \18\:ExtVDD) resistor r=20.6667 c=0
Ry24 (\47\:ExtVDD \46\:ExtVDD) resistor r=20.6667 c=0
Ry25 (\49\:ExtVDD \48\:ExtVDD) resistor r=20.6667 c=0
Ry30 (\68\:ExtVDD \67\:ExtVDD) resistor r=20.6667 c=0
Ry41 (\90\:ExtVDD \89\:ExtVDD) resistor r=20.6667 c=0
Ry75 (VSS \20\:VSS) resistor r=12.4 c=0
Ry70 (\2\:VSS \1\:VSS) resistor r=7.75 c=0
Ry71 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry72 (\8\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry73 (\21\:VSS \20\:VSS) resistor r=5.6364 c=0
Ry74 (\22\:VSS \20\:VSS) resistor r=5.1667 c=0
Ry76 (\32\:VSS \20\:VSS) resistor r=15.5 c=0
Ry4 (\1\:PSO2_out \2\:PSO2_out) resistor r=20.6667 c=0
Ry69 (\57\:VDD \56\:VDD) resistor r=20.6667 c=0
Ry1 (\10\:pso2n \11\:pso2n) resistor r=20.6667 c=0
Ry3 (\5\:n2 \6\:n2) resistor r=20.6667 c=0
Ry2 (\17\:pso1n \16\:pso1n) resistor r=20.6667 c=0
Rx7 (\17\:ExtVDD \1\:ExtVDD) resistor r=45 c=0
Rx8 (\66\:ExtVDD \2\:ExtVDD) resistor r=45 c=0
Rx2 (\3\:PSO1 \5\:PSO1) resistor r=45 c=0
Rx1 (\2\:PSO2 PSO2) resistor r=45 c=0
Rx3 (\4\:pso2n \8\:pso2n) resistor r=45 c=0
Rx5 (\2\:n2 \7\:n2) resistor r=45 c=0
Rx4 (\21\:pso1n \3\:pso1n) resistor r=22.5 c=0
Rx6 (\70\:n1 \15\:n1) resistor r=22.5 c=0
NM5 (\19\:pso1n \4\:PSO1 \18\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=8.81533 \
        scb=0.00706435 scc=0.000179997 m=(1)
NM2 (\12\:pso2n \1\:PSO2 \30\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.8545 \
        scb=0.0148797 scc=0.00110433 m=(1)
NM0 (\62\:n1 \3\:pso1n \5\:VSS VSS) g45n1svt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.8e-14 ad=4.5e-14 ps=9.2e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.55e-07 sd=160n sca=9.749 scb=0.00848113 \
        scc=0.000308397 m=(4)
NM1 (\3\:n2 \7\:pso2n \27\:VSS VSS) g45n1svt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.2e-14 ad=4.2e-14 ps=8.8e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.8283 \
        scb=0.0135012 scc=0.000962877 m=(1)
NM3 (\3\:PSO2_out pso2n \25\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=14.8545 \
        scb=0.0148797 scc=0.00110433 m=(1)
NM4 (\1\:PSO1_out \7\:pso1n \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.271 \
        scb=0.00920849 scc=0.00026297 m=(1)
PM7 (\10\:pso2n \3\:PSO2 \18\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=28.2012 \
        scb=0.0315683 scc=0.00281009 m=(1)
PM1 (\62\:n1 \3\:pso1n \63\:ExtVDD ExtVDD) g45p1svt w=(4.5e-07) \
        l=4.5e-08 nf=1 as=7.2e-14 ad=6.75e-14 ps=1.22e-06 pd=1.2e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=18.5134 \
        scb=0.0151225 scc=0.00171389 m=(4)
PM2 (\5\:n2 \6\:pso2n \48\:ExtVDD ExtVDD) g45p1svt w=(4.5e-07) l=4.5e-08 \
        nf=1 as=6.3e-14 ad=6.3e-14 ps=1.18e-06 pd=1.18e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.3479 \
        scb=0.0114967 scc=0.000816483 m=(1)
PM5 (\1\:PSO2_out \5\:pso2n \46\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.1375 \
        scb=0.0121086 scc=0.000940231 m=(1)
PM6 (\3\:PSO1_out pso1n \89\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.3799 \
        scb=0.0113799 scc=0.000804813 m=(1)
PM0_44__rcx (\1\:VDD n1 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 \
        nf=1 as=7.065e-14 ad=7.155e-14 ps=1.214e-06 pd=1.218e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=4.07325 \
        scb=0.000378105 scc=2.57733e-07 m=(20)
PM0_41__rcx (\1\:VDD n1 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 \
        nf=1 as=7.136e-14 ad=7.136e-14 ps=1.21714e-06 pd=1.21714e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.165e-06 sb=1.37e-06 sd=160n \
        sca=4.07325 scb=0.000378105 scc=2.57733e-07 m=(14)
PM0_20__rcx (\1\:VDD n1 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 \
        nf=1 as=7.071e-14 ad=7.2e-14 ps=1.21429e-06 pd=1.22e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.165e-06 sb=1.37e-06 sd=160n \
        sca=4.07325 scb=0.000378105 scc=2.57733e-07 m=(14)
ends HSWDX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:23:34 2012 )
// Library name: gsclib045
// Cell name: HSWNX1
// View name: extracted

simulator lang=spectre

subckt HSWNX1 ExtVDD PSOn PSOn_out VDD VSS
PM0_76__rcx (VDD n0 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.125e-14 ad=7.125e-14 ps=1.21667e-06 pd=1.21667e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=3.86017 \
        scb=0.000251977 scc=7.90668e-08 m=(24)
PM1_1__rcx (\117\:n0 \1\:PSOn ExtVDD ExtVDD) g45p1svt w=(4.5e-07) \
        l=4.5e-08 nf=1 as=6.3e-14 ad=7.2e-14 ps=1.18e-06 pd=1.22e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=38.2885 \
        scb=0.039105 scc=0.00461576 m=(2)
C1 (PSOn_out VSS) capacitor c=3.8694e-16
C2 (ExtVDD VSS) capacitor c=3.01166e-15
C3 (VDD VSS) capacitor c=2.45724e-16
C4 (PSOn VSS) capacitor c=3.69461e-17
C5 (n0 VSS) capacitor c=1.68328e-15
C6 (\1\:PSOn VSS) capacitor c=1.48374e-16
C7 (\107\:n0 VSS) capacitor c=3.72923e-17
C8 (\117\:n0 VSS) capacitor c=9.10325e-17
C9 (\119\:n0 VSS) capacitor c=7.01374e-17
C10 (VDD VSS) capacitor c=4.33685e-15
C11 (ExtVDD VSS) capacitor c=1.2944e-15
C12 (ExtVDD VSS) capacitor c=2.47951e-15
C13 (\7\:PSOn VSS) capacitor c=3.92267e-17
C14 (\23\:n0 VSS) capacitor c=6.9834e-17
C15 (\24\:n0 VSS) capacitor c=2.72365e-16
C16 (\115\:n0 VSS) capacitor c=7.94877e-17
C17 (\116\:n0 VSS) capacitor c=6.33235e-17
Rk22 (ExtVDD ExtVDD) resistor r=0.3406 c=0
Rk140 (\3\:VSS VSS) resistor r=0.8533 c=0
Rk139 (\2\:VSS \3\:VSS) resistor r=0.7531 c=0
Rk141 (VSS \4\:VSS) resistor r=0.3517 c=0
Rk147 (\5\:VSS VSS) resistor r=0.02215 c=0
Rk142 (\4\:VSS \5\:VSS) resistor r=0.6098 c=0
Rk148 (VSS \10\:VSS) resistor r=0.1634 c=0
Rk153 (\19\:VSS VSS) resistor r=0.04996 c=0
Rk152 (\18\:VSS \19\:VSS) resistor r=1.1548 c=0
Rk157 (\20\:VSS VSS) resistor r=0.02215 c=0
Rk154 (VSS \20\:VSS) resistor r=1.1146 c=0
Rk100 (VDD VDD) resistor r=0.968 c=0
Rk1 (\7\:PSOn PSOn) resistor r=0.03836 c=0
Rk8 (\115\:n0 \116\:n0) resistor r=0.6439 c=0
Rk9 (\116\:n0 \118\:n0) resistor r=0.2962 c=0
Rk10 (\116\:n0 \120\:n0) resistor r=0.2367 c=0
Rl28 (\23\:n0 n0) resistor r=96.583 c=0
Rl112 (\23\:n0 \107\:n0) resistor r=64.081 c=0
Rl29 (\24\:n0 \23\:n0) resistor r=193.783 c=0
Rz3 (\120\:n0 \119\:n0) resistor r=37.5 c=0
Ry93 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry94 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry95 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry97 (\5\:VSS \1\:VSS) resistor r=15.5 c=0
Ry98 (\10\:VSS \1\:VSS) resistor r=15.5 c=0
Ry99 (\18\:VSS \17\:VSS) resistor r=5.6364 c=0
Ry100 (\19\:VSS \17\:VSS) resistor r=5.1667 c=0
Ry101 (\20\:VSS \17\:VSS) resistor r=5.1667 c=0
Ry3 (\118\:n0 \117\:n0) resistor r=20.6667 c=0
Rx1 (\7\:PSOn \1\:PSOn) resistor r=15 c=0
Rx2 (\115\:n0 \107\:n0) resistor r=9 c=0
NM4 (PSOn_out \24\:n0 \5\:VSS VSS) g45n1svt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.5e-14 ad=4.8e-14 ps=9e-07 pd=9.2e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=7.55e-07 sd=160n sca=8.78238 scb=0.00700085 \
        scc=0.000201997 m=(4)
NM0_1__rcx (\20\:VSS \1\:PSOn \119\:n0 VSS) g45n1svt w=(3e-07) l=4.5e-08 \
        nf=1 as=4.5e-14 ad=4.5e-14 ps=9e-07 pd=9e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=11.3599 \
        scb=0.0104786 scc=0.000506541 m=(2)
PM6_2__rcx (PSOn_out \24\:n0 ExtVDD ExtVDD) g45p1svt w=(4.5e-07) \
        l=4.5e-08 nf=1 as=7.2e-14 ad=6.75e-14 ps=1.22e-06 pd=1.2e-06 \
        nrd=1.16667 nrs=1.16667 sa=5.5e-07 sb=3.45e-07 sd=160n sca=16.2559 \
        scb=0.0139194 scc=0.00128532 m=(4)
PM0_73__rcx (VDD n0 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.2e-14 ad=7.2e-14 ps=1.22e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2e-06 sd=160n sca=3.86017 \
        scb=0.000251977 scc=7.90668e-08 m=(20)
PM0_68__rcx (VDD n0 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.2e-14 ad=7.1e-14 ps=1.22e-06 pd=1.21556e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=7.55e-07 sd=160n sca=16.9864 scb=0.0140904 \
        scc=0.00159544 m=(36)
ends HSWNX1
// End of subcircuit definition.

// Generated for: spectre (May  3 15:24:25 2012 )
// Library name: gsclib045
// Cell name: HSWX1
// View name: extracted

simulator lang=spectre

subckt HSWX1 ExtVDD PSO PSO_out VDD VSS
PM0 (VDD n0 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.1e-14 ad=7.2e-14 ps=1.21556e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=18.5135 scb=0.0195852 \
        scc=0.00148685 m=(36)
PM2 (\13\:pson \1\:PSO \82\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=40.4286 \
        scb=0.040773 scc=0.00487953 m=(1)
C1 (ExtVDD VSS) capacitor c=3.06086e-15
C2 (PSO_out VSS) capacitor c=2.65288e-17
C3 (VDD VSS) capacitor c=2.41042e-16
C4 (PSO VSS) capacitor c=4.43469e-17
C5 (pson VSS) capacitor c=4.84997e-17
C6 (n0 VSS) capacitor c=1.7841e-15
C7 (\1\:PSO VSS) capacitor c=4.52078e-17
C8 (\6\:pson VSS) capacitor c=1.21273e-16
C9 (\4\:pson VSS) capacitor c=5.12988e-17
C10 (\3\:PSO VSS) capacitor c=3.64683e-17
C11 (\23\:n0 VSS) capacitor c=5.73678e-17
C12 (\2\:PSO VSS) capacitor c=3.72462e-17
C13 (\3\:pson VSS) capacitor c=2.90094e-17
C14 (\3\:PSO_out VSS) capacitor c=9.00113e-17
C15 (\82\:ExtVDD VSS) capacitor c=1.10562e-16
C16 (\104\:n0 VSS) capacitor c=9.65988e-17
C17 (\13\:pson VSS) capacitor c=6.90622e-17
C18 (\1\:PSO_out VSS) capacitor c=7.19417e-17
C19 (\106\:n0 VSS) capacitor c=6.82536e-17
C20 (\16\:pson VSS) capacitor c=6.92389e-17
C21 (\11\:pson VSS) capacitor c=1.30616e-17
C22 (\2\:pson VSS) capacitor c=4.25303e-17
C23 (\5\:pson VSS) capacitor c=3.0819e-17
C24 (VDD VSS) capacitor c=4.28984e-15
C25 (ExtVDD VSS) capacitor c=5.05846e-16
C26 (ExtVDD VSS) capacitor c=2.75355e-15
C27 (\15\:pson VSS) capacitor c=4.01871e-17
C28 (\7\:PSO VSS) capacitor c=3.11443e-17
C29 (\102\:n0 VSS) capacitor c=6.29955e-17
C30 (\103\:n0 VSS) capacitor c=3.06215e-17
C31 (\19\:ExtVDD VSS) capacitor c=1.71766e-16
Rk21 (ExtVDD ExtVDD) resistor r=0.1153 c=0
Rk27 (ExtVDD \19\:ExtVDD) resistor r=0.1456 c=0
Rk65 (ExtVDD \83\:ExtVDD) resistor r=0.5915 c=0
Rk139 (\3\:VSS VSS) resistor r=0.04994 c=0
Rk138 (\2\:VSS \3\:VSS) resistor r=1.1544 c=0
Rk141 (\4\:VSS VSS) resistor r=0.02992 c=0
Rk140 (VSS \4\:VSS) resistor r=1.1546 c=0
Rk146 (\12\:VSS VSS) resistor r=0.04994 c=0
Rk145 (\11\:VSS \12\:VSS) resistor r=1.1544 c=0
Rk147 (VSS \13\:VSS) resistor r=1.1546 c=0
Rk149 (\14\:VSS VSS) resistor r=0.125 c=0
Rk148 (\13\:VSS \14\:VSS) resistor r=0.1303 c=0
Rk150 (\14\:VSS \16\:VSS) resistor r=0.2743 c=0
Rk8 (PSO_out \2\:PSO_out) resistor r=0.07766 c=0
Rk9 (\2\:PSO_out \4\:PSO_out) resistor r=0.5387 c=0
Rk99 (VDD VDD) resistor r=0.6117 c=0
Rk3 (\4\:PSO PSO) resistor r=0.003499 c=0
Rk4 (\5\:PSO PSO) resistor r=0.003499 c=0
Rk5 (\4\:PSO \5\:PSO) resistor r=0.01452 c=0
Rk7 (\5\:PSO \7\:PSO) resistor r=0.01694 c=0
Rk6 (\6\:PSO \7\:PSO) resistor r=0.003332 c=0
Rk1 (\14\:pson \15\:pson) resistor r=0.2805 c=0
Rk2 (\14\:pson \17\:pson) resistor r=0.5341 c=0
Rk10 (\102\:n0 \103\:n0) resistor r=0.3552 c=0
Rk11 (\103\:n0 \105\:n0) resistor r=0.32 c=0
Rk12 (\103\:n0 \107\:n0) resistor r=0.2103 c=0
Rl1 (\1\:PSO \2\:PSO) resistor r=62.6365 c=0
Rl2 (\2\:PSO \3\:PSO) resistor r=58.7903 c=0
Rl5 (\4\:pson pson) resistor r=153.846 c=0
Rl12 (\11\:pson \6\:pson) resistor r=39.7092 c=0
Rl3 (\2\:pson pson) resistor r=93.5977 c=0
Rl4 (\2\:pson \3\:pson) resistor r=63.5319 c=0
Rl7 (\5\:pson \6\:pson) resistor r=57.3013 c=0
Rl14 (\5\:pson \11\:pson) resistor r=15.1758 c=0
Rl6 (\5\:pson \2\:pson) resistor r=132.706 c=0
Rl37 (n0 \23\:n0) resistor r=247.291 c=0
Rz10 (\16\:VSS \15\:VSS) resistor r=37.5 c=0
Rz2 (\1\:PSO_out \2\:PSO_out) resistor r=37.5 c=0
Rz1 (\17\:pson \16\:pson) resistor r=37.5 c=0
Rz3 (\107\:n0 \106\:n0) resistor r=37.5 c=0
Ry30 (\83\:ExtVDD \82\:ExtVDD) resistor r=20.6667 c=0
Ry91 (\2\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry92 (\3\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry93 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry94 (\11\:VSS \10\:VSS) resistor r=5.6364 c=0
Ry95 (\12\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry96 (\13\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry2 (\3\:PSO_out \4\:PSO_out) resistor r=20.6667 c=0
Ry1 (\14\:pson \13\:pson) resistor r=20.6667 c=0
Ry3 (\105\:n0 \104\:n0) resistor r=20.6667 c=0
Rx2 (\2\:PSO \6\:PSO) resistor r=45 c=0
Rx1 (\15\:pson \3\:pson) resistor r=45 c=0
Rx3 (\102\:n0 \23\:n0) resistor r=15 c=0
NM2 (\15\:VSS \3\:PSO \16\:pson VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.22468 \
        scb=0.0071987 scc=0.000180033 m=(1)
NM0 (VSS \6\:pson \106\:n0 VSS) g45n1svt w=(3e-07) l=4.5e-08 nf=1 \
        as=4.8e-14 ad=4.2e-14 ps=9.2e-07 pd=8.8e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.6172 \
        scb=0.0114252 scc=0.000508261 m=(2)
NM4 (\1\:PSO_out \4\:pson \15\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1772 \
        scb=0.00801794 scc=0.000181716 m=(1)
PM1 (\104\:n0 \6\:pson \19\:ExtVDD ExtVDD) g45p1svt w=(4.5e-07) \
        l=4.5e-08 nf=1 as=6.3e-14 ad=7.2e-14 ps=1.18e-06 pd=1.22e-06 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=22.5241 \
        scb=0.0206307 scc=0.00192213 m=(2)
PM6 (\3\:PSO_out pson \82\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=26.2769 \
        scb=0.0231127 scc=0.00250765 m=(1)
PM0_30__rcx (VDD n0 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.2e-14 ad=7.2e-14 ps=1.22e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.575e-06 sb=2e-06 sd=160n sca=3.55421 \
        scb=0.000138381 scc=9.64541e-09 m=(8)
PM0_44__rcx (VDD n0 ExtVDD ExtVDD) g45p1hvt w=(4.5e-07) l=4.5e-08 nf=1 \
        as=7.1e-14 ad=7.2e-14 ps=1.21556e-06 pd=1.22e-06 nrd=1.16667 \
        nrs=1.16667 sa=2e-06 sb=1.78e-06 sd=160n sca=8.16604 \
        scb=0.00609017 scc=0.000206552 m=(36)
ends HSWX1
// End of subcircuit definition.

// Generated for: spectre (May  9 14:59:55 2012 )
// Library name: gsclib045
// Cell name: INVX1
// View name: extracted

simulator lang=spectre

subckt INVX1 A VDD VSS Y
mp0 (\1\:Y \1\:A \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=8.75e-14 ad=5.46e-14 ps=1.8e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.35e-07 sb=1.4e-07 sd=160n sca=58.4044 \
        scb=0.0588257 scc=0.00629162 m=(1)
C1 (Y VSS) capacitor c=3.28977e-17
C2 (A VSS) capacitor c=1.59268e-17
C3 (VDD VSS) capacitor c=1.8799e-17
C4 (\1\:A VSS) capacitor c=2.7373e-17
C5 (\4\:A VSS) capacitor c=2.19324e-17
C6 (\3\:A VSS) capacitor c=1.20351e-17
C7 (\1\:Y VSS) capacitor c=1.46588e-17
C8 (\4\:VDD VSS) capacitor c=3.59421e-18
C9 (\1\:VDD VSS) capacitor c=9.06775e-18
C10 (\3\:Y VSS) capacitor c=2.25113e-17
C11 (\2\:A VSS) capacitor c=1.03435e-17
C12 (\7\:A VSS) capacitor c=3.85321e-17
Rk4 (\2\:Y Y) resistor r=0.2245 c=0
Rk5 (Y \4\:Y) resistor r=0.1802 c=0
Rk1 (\5\:A A) resistor r=0.006551 c=0
Rk3 (\5\:A \7\:A) resistor r=0.01182 c=0
Rk2 (\6\:A \7\:A) resistor r=0.006551 c=0
Rk6 (\2\:VDD VDD) resistor r=0.09981 c=0
Rk8 (VDD \5\:VDD) resistor r=0.1328 c=0
Rk9 (\2\:VSS VSS) resistor r=0.09981 c=0
Rk11 (VSS \5\:VSS) resistor r=0.0999 c=0
Rl1 (\1\:A \2\:A) resistor r=61.2526 c=0
Rl3 (\2\:A \4\:A) resistor r=34.3295 c=0
Rl2 (\2\:A \3\:A) resistor r=2.7666 c=0
Rz1 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz3 (\1\:VDD VDD) resistor r=75 c=0
Rz2 (\1\:VDD \2\:VDD) resistor r=75 c=0
Rz4 (\4\:VSS \5\:VSS) resistor r=75 c=0
Ry1 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry2 (\4\:VDD \5\:VDD) resistor r=62 c=0
Ry4 (\1\:VSS VSS) resistor r=62 c=0
Ry3 (\1\:VSS \2\:VSS) resistor r=62 c=0
Rx1 (\3\:A \6\:A) resistor r=45 c=0
mn0 (\3\:Y \4\:A \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=6.395e-14 ad=3.64e-14 ps=1.44e-06 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.35e-07 sb=1.4e-07 sd=160n sca=14.4034 \
        scb=0.0144248 scc=0.00102063 m=(1)
ends INVX1
// End of subcircuit definition.

// Generated for: spectre (May  9 15:00:34 2012 )
// Library name: gsclib045
// Cell name: INVX12
// View name: extracted

simulator lang=spectre

subckt INVX12 A VDD VSS Y
mp0 (\1\:Y \1\:A VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.332e-14 ad=7.52e-14 ps=1.252e-06 pd=1.26e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.985e-06 sd=160n sca=40.6416 \
        scb=0.0369115 scc=0.00420297 m=(10)
C1 (A VSS) capacitor c=2.14952e-17
C2 (VDD VSS) capacitor c=5.12958e-16
C3 (Y VSS) capacitor c=3.02299e-17
C4 (\1\:A VSS) capacitor c=8.51306e-16
C5 (\16\:A VSS) capacitor c=2.26462e-17
C6 (\1\:Y VSS) capacitor c=6.35267e-16
C7 (\40\:A VSS) capacitor c=4.45199e-17
C8 (\4\:Y VSS) capacitor c=1.40454e-17
C9 (\5\:Y VSS) capacitor c=5.00442e-16
Rk5 (\40\:A A) resistor r=0.01622 c=0
Rk4 (\1\:A \40\:A) resistor r=0.2896 c=0
Rk17 (\4\:Y Y) resistor r=0.112 c=0
Rk7 (\1\:Y \4\:Y) resistor r=0.1589 c=0
Rk8 (\4\:Y \5\:Y) resistor r=0.07485 c=0
Rl15 (\1\:A \16\:A) resistor r=3.1164 c=0
Rx5 (\40\:A \16\:A) resistor r=45 c=0
mn0 (\5\:Y \1\:A VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.836e-14 ad=4.96e-14 ps=9.32e-07 pd=9.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.985e-06 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(10)
ends INVX12
// End of subcircuit definition.

// Generated for: spectre (May  9 15:01:11 2012 )
// Library name: gsclib045
// Cell name: INVX16
// View name: extracted

simulator lang=spectre

subckt INVX16 A VDD VSS Y
mp0 (\1\:Y \1\:A VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=7.12e-14 ps=1.20429e-06 pd=1.21e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=41.6034 scb=0.0375368 \
        scc=0.00435732 m=(14)
C1 (A VSS) capacitor c=2.14952e-17
C2 (VDD VSS) capacitor c=6.92632e-16
C3 (Y VSS) capacitor c=3.00574e-17
C4 (\1\:A VSS) capacitor c=1.23993e-15
C5 (\22\:A VSS) capacitor c=2.29307e-17
C6 (\1\:Y VSS) capacitor c=9.0721e-16
C7 (\56\:A VSS) capacitor c=4.33054e-17
C8 (\4\:Y VSS) capacitor c=1.52312e-17
C9 (\5\:Y VSS) capacitor c=7.23161e-16
Rk7 (\56\:A A) resistor r=0.01623 c=0
Rk6 (\1\:A \56\:A) resistor r=0.29 c=0
Rk23 (\4\:Y Y) resistor r=0.1123 c=0
Rk9 (\1\:Y \4\:Y) resistor r=0.1594 c=0
Rk10 (\4\:Y \5\:Y) resistor r=0.07507 c=0
Rl21 (\1\:A \22\:A) resistor r=3.1164 c=0
Rx7 (\56\:A \22\:A) resistor r=45 c=0
mn0 (\5\:Y \1\:A VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.636e-14 ad=4.72e-14 ps=9.0429e-07 pd=9.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.4223 scb=0.0158966 \
        scc=0.0014413 m=(14)
ends INVX16
// End of subcircuit definition.

// Generated for: spectre (May  9 15:01:49 2012 )
// Library name: gsclib045
// Cell name: INVX2
// View name: extracted

simulator lang=spectre

subckt INVX2 A VDD VSS Y
mp0 (\4\:Y \1\:A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.825e-14 ad=6.24e-14 ps=1.43e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-07 sb=3.45e-07 sd=160n sca=48.9834 \
        scb=0.0447567 scc=0.00505417 m=(2)
C1 (Y VSS) capacitor c=3.07124e-17
C2 (A VSS) capacitor c=1.57532e-17
C3 (VDD VSS) capacitor c=9.14586e-17
C4 (\1\:A VSS) capacitor c=9.79078e-17
C5 (\4\:A VSS) capacitor c=1.14819e-17
C6 (\4\:Y VSS) capacitor c=5.13253e-17
C7 (\2\:Y VSS) capacitor c=4.98714e-17
C8 (\10\:A VSS) capacitor c=4.07607e-17
C9 (\1\:Y VSS) capacitor c=2.90577e-17
Rk4 (Y \1\:Y) resistor r=0.09405 c=0
Rk5 (\1\:Y \3\:Y) resistor r=0.1734 c=0
Rk6 (\1\:Y \5\:Y) resistor r=0.2275 c=0
Rk1 (A \8\:A) resistor r=0.00395 c=0
Rk3 (\8\:A \10\:A) resistor r=0.0157 c=0
Rk2 (\9\:A \10\:A) resistor r=0.00395 c=0
Rl3 (\1\:A \4\:A) resistor r=4.3044 c=0
Rz1 (\3\:Y \2\:Y) resistor r=37.5 c=0
Ry1 (\5\:Y \4\:Y) resistor r=20.6667 c=0
Rx1 (\9\:A \4\:A) resistor r=45 c=0
mn0 (\2\:Y \1\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.862e-14 ad=4.16e-14 ps=1.13e-06 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.25e-07 sb=3.45e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(2)
ends INVX2
// End of subcircuit definition.

// Generated for: spectre (May  9 15:02:27 2012 )
// Library name: gsclib045
// Cell name: INVX20
// View name: extracted

simulator lang=spectre

subckt INVX20 A VDD VSS Y
mp0 (\1\:Y \1\:A VDD VDD) g45p1svt w=(4.6e-07) l=4.5e-08 nf=1 \
        as=7.306e-14 ad=7.306e-14 ps=1.23765e-06 pd=1.23765e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=41.0128 \
        scb=0.0371513 scc=0.00426262 m=(17)
C1 (A VSS) capacitor c=2.14952e-17
C2 (VDD VSS) capacitor c=8.14414e-16
C3 (Y VSS) capacitor c=1.59747e-17
C4 (\1\:A VSS) capacitor c=1.60168e-15
C5 (\27\:A VSS) capacitor c=2.29427e-17
C6 (\1\:Y VSS) capacitor c=1.14196e-15
C7 (\69\:A VSS) capacitor c=4.33159e-17
C8 (\4\:Y VSS) capacitor c=9.21431e-16
Rk9 (\69\:A A) resistor r=0.01623 c=0
Rk8 (\1\:A \69\:A) resistor r=0.29 c=0
Rk11 (\1\:Y Y) resistor r=0.1076 c=0
Rk12 (Y \4\:Y) resistor r=0.06532 c=0
Rl26 (\1\:A \27\:A) resistor r=3.1164 c=0
Rx9 (\69\:A \27\:A) resistor r=45 c=0
mn0 (\4\:Y \1\:A VSS VSS) g45n1svt w=(3.05e-07) l=4.5e-08 nf=1 \
        as=4.844e-14 ad=4.844e-14 ps=9.2765e-07 pd=9.2765e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2e-06 sd=160n sca=16.121 scb=0.0155296 \
        scc=0.00139557 m=(17)
ends INVX20
// End of subcircuit definition.

// Generated for: spectre (May  9 15:03:05 2012 )
// Library name: gsclib045
// Cell name: INVX3
// View name: extracted

simulator lang=spectre

subckt INVX3 A VDD VSS Y
mp0 (Y \1\:A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 as=6.89e-14 \
        ad=5.98e-14 ps=1.33333e-06 pd=1.08667e-06 nrd=1.16667 nrs=1.16667 \
        sa=1.25e-07 sb=5.5e-07 sd=160n sca=47.2615 scb=0.0418019 \
        scc=0.00515049 m=(3)
C1 (Y VSS) capacitor c=2.38936e-16
C2 (VDD VSS) capacitor c=1.46962e-16
C3 (\1\:A VSS) capacitor c=1.46348e-16
C4 (\5\:A VSS) capacitor c=9.14231e-18
C5 (\11\:A VSS) capacitor c=1.83097e-17
C6 (\12\:A VSS) capacitor c=3.12692e-17
Rk1 (A \11\:A) resistor r=0.006608 c=0
Rk3 (\11\:A \12\:A) resistor r=0.009723 c=0
Rk2 (\12\:A \13\:A) resistor r=0.006608 c=0
Rl4 (\1\:A \5\:A) resistor r=4.0454 c=0
Rx1 (\13\:A \5\:A) resistor r=45 c=0
mn0 (Y \1\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 as=4.852e-14 \
        ad=3.987e-14 ps=1.06e-06 pd=8.2667e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.25e-07 sb=5.5e-07 sd=160n sca=17.5885 scb=0.0172826 \
        scc=0.00162584 m=(3)
ends INVX3
// End of subcircuit definition.

// Generated for: spectre (Mar 21 15:01:42 2012 )
// Library name: gsclib045
// Cell name: INVX4
// View name: extracted

simulator lang=spectre

subckt INVX4 A VDD VSS Y
mp0 (\1\:Y \1\:A VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.312e-14 ad=6.24e-14 ps=1.24e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.35e-07 sd=160n sca=33.0928 \
        scb=0.0355004 scc=0.00312201 m=(4)
C1 (Y VSS) capacitor c=4.36483e-17
C2 (A VSS) capacitor c=1.98744e-17
C3 (VDD VSS) capacitor c=2.05232e-16
C4 (\1\:A VSS) capacitor c=1.89668e-16
C5 (\8\:A VSS) capacitor c=2.73049e-17
C6 (\1\:Y VSS) capacitor c=2.10367e-16
C7 (\16\:A VSS) capacitor c=6.48332e-17
C8 (\17\:A VSS) capacitor c=7.45499e-17
C9 (\18\:A VSS) capacitor c=2.85937e-17
C10 (\4\:Y VSS) capacitor c=1.70196e-16
Rk5 (\1\:Y Y) resistor r=0.2317 c=0
Rk6 (Y \4\:Y) resistor r=0.1855 c=0
Rk1 (\16\:A \17\:A) resistor r=0.2985 c=0
Rk3 (\18\:A A) resistor r=0.01631 c=0
Rk2 (\17\:A \18\:A) resistor r=0.2866 c=0
Rl7 (\1\:A \8\:A) resistor r=3.1164 c=0
Rx1 (\16\:A \1\:A) resistor r=45 c=0
Rx2 (\17\:A \1\:A) resistor r=45 c=0
Rx3 (\18\:A \8\:A) resistor r=45 c=0
mn0 (\4\:Y \1\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.496e-14 ad=4.16e-14 ps=9.925e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.35e-07 sd=160n sca=16.9678 \
        scb=0.0167861 scc=0.00150639 m=(4)
ends INVX4
// End of subcircuit definition.

// Generated for: spectre (May  9 15:04:20 2012 )
// Library name: gsclib045
// Cell name: INVX6
// View name: extracted

simulator lang=spectre

subckt INVX6 A VDD VSS Y
mp0 (\1\:Y \1\:A VDD VDD) g45p1svt w=(4.7e-07) l=4.5e-08 nf=1 \
        as=7.332e-14 ad=7.332e-14 ps=1.252e-06 pd=1.252e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.6e-07 sd=160n sca=40.6416 \
        scb=0.0369115 scc=0.00420297 m=(5)
C1 (A VSS) capacitor c=1.70381e-17
C2 (VDD VSS) capacitor c=2.79788e-16
C3 (Y VSS) capacitor c=1.47841e-17
C4 (\1\:A VSS) capacitor c=2.48138e-16
C5 (\9\:A VSS) capacitor c=2.06753e-17
C6 (\1\:Y VSS) capacitor c=3.28498e-16
C7 (\19\:A VSS) capacitor c=8.46344e-17
C8 (\20\:A VSS) capacitor c=1.02415e-16
C9 (\21\:A VSS) capacitor c=4.02484e-17
C10 (\4\:Y VSS) capacitor c=2.55428e-16
Rk1 (\19\:A \20\:A) resistor r=0.417 c=0
Rk3 (\21\:A A) resistor r=0.0229 c=0
Rk2 (\20\:A \21\:A) resistor r=0.3307 c=0
Rk5 (\1\:Y Y) resistor r=0.09507 c=0
Rk6 (Y \4\:Y) resistor r=0.06503 c=0
Rl8 (\1\:A \9\:A) resistor r=3.4936 c=0
Rx1 (\19\:A \1\:A) resistor r=45 c=0
Rx2 (\20\:A \1\:A) resistor r=45 c=0
Rx3 (\21\:A \9\:A) resistor r=45 c=0
mn0 (\4\:Y \1\:A VSS VSS) g45n1svt w=(3.1e-07) l=4.5e-08 nf=1 \
        as=4.836e-14 ad=4.836e-14 ps=9.32e-07 pd=9.32e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.6e-07 sd=160n sca=15.9751 \
        scb=0.0153507 scc=0.00137372 m=(5)
ends INVX6
// End of subcircuit definition.

// Generated for: spectre (May  9 15:04:58 2012 )
// Library name: gsclib045
// Cell name: INVX8
// View name: extracted

simulator lang=spectre

subckt INVX8 A VDD VSS Y
mp0 (\1\:Y \1\:A VDD VDD) g45p1svt w=(4.45e-07) l=4.5e-08 nf=1 \
        as=6.993e-14 ad=6.993e-14 ps=1.20429e-06 pd=1.20429e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.37e-06 sd=160n sca=41.6034 \
        scb=0.0375368 scc=0.00435732 m=(7)
C1 (A VSS) capacitor c=1.70267e-17
C2 (VDD VSS) capacitor c=3.55865e-16
C3 (Y VSS) capacitor c=1.39394e-17
C4 (\1\:A VSS) capacitor c=6.25746e-16
C5 (\23\:A VSS) capacitor c=2.06565e-17
C6 (\1\:Y VSS) capacitor c=4.44555e-16
C7 (\28\:A VSS) capacitor c=5.33506e-17
C8 (\4\:Y VSS) capacitor c=3.71979e-16
Rk4 (\28\:A A) resistor r=0.02293 c=0
Rk3 (\1\:A \28\:A) resistor r=0.4537 c=0
Rk6 (\1\:Y Y) resistor r=0.09525 c=0
Rk7 (Y \4\:Y) resistor r=0.06282 c=0
Rl22 (\1\:A \23\:A) resistor r=3.4936 c=0
Rx4 (\28\:A \23\:A) resistor r=45 c=0
mn0 (\4\:Y \1\:A VSS VSS) g45n1svt w=(2.95e-07) l=4.5e-08 nf=1 \
        as=4.636e-14 ad=4.636e-14 ps=9.0429e-07 pd=9.0429e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.37e-06 sd=160n sca=16.4223 \
        scb=0.0158966 scc=0.0014413 m=(7)
ends INVX8
// End of subcircuit definition.

// Generated for: spectre (May  9 15:05:37 2012 )
// Library name: gsclib045
// Cell name: INVXL
// View name: extracted

simulator lang=spectre

subckt INVXL A VDD VSS Y
mp0 (\3\:Y \1\:A \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=4.962e-14 ad=2.87e-14 ps=1.44e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.33488e-07 sd=160n sca=40.8937 \
        scb=0.0499242 scc=0.00347111 m=(1)
C1 (A VSS) capacitor c=1.47202e-17
C2 (VDD VSS) capacitor c=3.94367e-17
C3 (Y VSS) capacitor c=4.26332e-17
C4 (\1\:A VSS) capacitor c=3.04405e-17
C5 (\3\:A VSS) capacitor c=2.15613e-17
C6 (\2\:A VSS) capacitor c=3.42589e-17
C7 (\3\:Y VSS) capacitor c=1.83867e-17
C8 (\1\:VDD VSS) capacitor c=7.47867e-18
C9 (\1\:Y VSS) capacitor c=2.35751e-17
C10 (\4\:A VSS) capacitor c=3.73499e-17
Rk6 (\2\:VSS VSS) resistor r=0.1003 c=0
Rk8 (VSS \5\:VSS) resistor r=0.1077 c=0
Rk1 (A \4\:A) resistor r=0.01335 c=0
Rk4 (\2\:VDD VDD) resistor r=0.07089 c=0
Rk2 (Y \2\:Y) resistor r=0.1764 c=0
Rk3 (Y \4\:Y) resistor r=0.2302 c=0
Rl1 (\1\:A \2\:A) resistor r=117.519 c=0
Rl2 (\2\:A \3\:A) resistor r=67.5189 c=0
Rz3 (\4\:VSS \5\:VSS) resistor r=75 c=0
Rz1 (\1\:Y \2\:Y) resistor r=75 c=0
Ry4 (\1\:VSS VSS) resistor r=62 c=0
Ry3 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry2 (\1\:VDD \2\:VDD) resistor r=62 c=0
Ry1 (\3\:Y \4\:Y) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
mn0 (\1\:Y \3\:A \4\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=3.86e-14 ad=2.32e-14 ps=1.23e-06 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1e-07 sb=1.6e-07 sd=160n sca=10.4914 scb=0.00978575 \
        scc=0.000300434 m=(1)
ends INVXL
// End of subcircuit definition.

// Generated for: spectre (May  3 15:25:14 2012 )
// Library name: gsclib045
// Cell name: ISOHLDX1_OFF
// View name: extracted

simulator lang=spectre

subckt ISOHLDX1_OFF D ExtVDD ISO Q VDD VSS
mp10 (\9\:Qint \3\:n0 \9\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=8.06732 \
        scb=0.00478236 scc=5.37757e-05 m=(1)
C1 (VDD VSS) capacitor c=2.15254e-16
C2 (ISO VSS) capacitor c=2.34743e-17
C3 (D VSS) capacitor c=3.30725e-18
C4 (ExtVDD VSS) capacitor c=3.75175e-16
C5 (Q VSS) capacitor c=2.11001e-17
C6 (Qint VSS) capacitor c=6.26981e-17
C7 (n0 VSS) capacitor c=2.64569e-17
C8 (GNbb VSS) capacitor c=7.9914e-17
C9 (Qbint VSS) capacitor c=3.314e-17
C10 (GNb VSS) capacitor c=9.63083e-17
C11 (\3\:Qbint VSS) capacitor c=4.3306e-17
C12 (\1\:D VSS) capacitor c=6.68534e-17
C13 (\8\:Qint VSS) capacitor c=6.1435e-17
C14 (\5\:GNb VSS) capacitor c=1.0901e-16
C15 (\4\:GNb VSS) capacitor c=7.903e-17
C16 (\4\:Qint VSS) capacitor c=7.49526e-17
C17 (\1\:ISO VSS) capacitor c=4.25182e-17
C18 (\3\:n0 VSS) capacitor c=3.18646e-17
C19 (\3\:D VSS) capacitor c=5.47027e-17
C20 (\5\:Qint VSS) capacitor c=3.78299e-17
C21 (\3\:GNbb VSS) capacitor c=2.33529e-16
C22 (\3\:GNb VSS) capacitor c=2.60544e-17
C23 (\4\:ISO VSS) capacitor c=4.24677e-17
C24 (\2\:D VSS) capacitor c=5.27613e-17
C25 (\2\:Qbint VSS) capacitor c=4.05388e-17
C26 (\2\:GNbb VSS) capacitor c=1.70584e-16
C27 (\6\:n0 VSS) capacitor c=9.68848e-17
C28 (\5\:n0 VSS) capacitor c=9.62813e-17
C29 (\7\:Qint VSS) capacitor c=5.46151e-17
C30 (\2\:GNb VSS) capacitor c=7.89954e-17
C31 (\2\:Qint VSS) capacitor c=7.60215e-17
C32 (\2\:n0 VSS) capacitor c=3.147e-17
C33 (\4\:n0 VSS) capacitor c=3.34367e-17
C34 (\3\:Qint VSS) capacitor c=2.76694e-17
C35 (\1\:ExtVDD VSS) capacitor c=1.0357e-17
C36 (\2\:ExtVDD VSS) capacitor c=1.07465e-17
C37 (\3\:ISO VSS) capacitor c=2.6015e-17
C38 (\2\:Q VSS) capacitor c=4.98182e-17
C39 (\11\:ExtVDD VSS) capacitor c=9.65454e-17
C40 (\3\:ExtVDD VSS) capacitor c=1.64789e-16
C41 (\17\:n0 VSS) capacitor c=8.61026e-17
C42 (\6\:Qbint VSS) capacitor c=8.47478e-17
C43 (\13\:n0 VSS) capacitor c=3.87679e-17
C44 (\4\:GNbb VSS) capacitor c=6.24274e-17
C45 (\15\:ExtVDD VSS) capacitor c=5.3321e-17
C46 (\9\:ExtVDD VSS) capacitor c=4.11271e-17
C47 (\10\:GNb VSS) capacitor c=4.76774e-17
C48 (\9\:Qint VSS) capacitor c=6.29706e-17
C49 (\4\:Q VSS) capacitor c=4.3056e-17
C50 (\15\:n0 VSS) capacitor c=7.98742e-17
C51 (\8\:Qbint VSS) capacitor c=4.51732e-17
C52 (\7\:n0 VSS) capacitor c=2.35563e-17
C53 (\7\:GNbb VSS) capacitor c=7.1007e-17
C54 (\8\:GNb VSS) capacitor c=2.64431e-17
C55 (\12\:Qint VSS) capacitor c=4.67015e-17
C56 (ExtVDD VSS) capacitor c=4.32285e-17
C57 (\2\:ISO VSS) capacitor c=4.51571e-17
C58 (VDD VSS) capacitor c=3.36826e-16
C59 (\6\:Qint VSS) capacitor c=5.10475e-17
C60 (\5\:ISO VSS) capacitor c=1.98295e-17
C61 (\11\:Qint VSS) capacitor c=6.49894e-17
C62 (\6\:GNb VSS) capacitor c=2.13963e-17
C63 (\7\:GNb VSS) capacitor c=4.24553e-17
C64 (\14\:Qint VSS) capacitor c=5.62774e-17
C65 (\15\:Qint VSS) capacitor c=5.11953e-17
C66 (\9\:n0 VSS) capacitor c=1.06058e-16
C67 (\10\:n0 VSS) capacitor c=6.80734e-17
C68 (\11\:n0 VSS) capacitor c=4.62558e-17
C69 (\12\:n0 VSS) capacitor c=6.42384e-17
C70 (\6\:GNbb VSS) capacitor c=7.83962e-17
C71 (\19\:n0 VSS) capacitor c=4.7189e-17
C72 (\5\:ExtVDD VSS) capacitor c=1.249e-16
C73 (\6\:ExtVDD VSS) capacitor c=6.79658e-17
C74 (\4\:Qbint VSS) capacitor c=3.97851e-17
C75 (\5\:Qbint VSS) capacitor c=3.70431e-17
C76 (\13\:ExtVDD VSS) capacitor c=1.31109e-16
C77 (\14\:ExtVDD VSS) capacitor c=3.79995e-17
C78 (\4\:D VSS) capacitor c=2.6587e-17
C79 (\7\:D VSS) capacitor c=1.73667e-17
C80 (\1\:Q VSS) capacitor c=4.1449e-17
Rk48 (VSS VSS) resistor r=0.1315 c=0
Rk41 (\4\:VSS VSS) resistor r=0.4053 c=0
Rk40 (\2\:VSS \4\:VSS) resistor r=0.2955 c=0
Rk43 (\5\:VSS VSS) resistor r=0.05837 c=0
Rk42 (VSS \5\:VSS) resistor r=0.07233 c=0
Rk44 (VSS \6\:VSS) resistor r=0.3457 c=0
Rk45 (\5\:VSS \8\:VSS) resistor r=0.2443 c=0
Rk47 (\11\:VSS VSS) resistor r=0.3757 c=0
Rk46 (\10\:VSS \11\:VSS) resistor r=0.2252 c=0
Rk49 (VSS \12\:VSS) resistor r=0.1499 c=0
Rk50 (\11\:VSS \14\:VSS) resistor r=0.2532 c=0
Rk51 (VSS \16\:VSS) resistor r=0.3116 c=0
Rk52 (VDD VDD) resistor r=0.1825 c=0
Rk2 (\5\:ISO ISO) resistor r=0.01078 c=0
Rk1 (\5\:ISO \6\:ISO) resistor r=0.005784 c=0
Rk32 (\4\:D D) resistor r=0.005569 c=0
Rk33 (\5\:D D) resistor r=0.004796 c=0
Rk34 (\4\:D \5\:D) resistor r=0.01567 c=0
Rk36 (\5\:D \7\:D) resistor r=0.01791 c=0
Rk35 (\6\:D \7\:D) resistor r=0.005415 c=0
Rk24 (ExtVDD ExtVDD) resistor r=0.05871 c=0
Rk20 (\4\:ExtVDD \5\:ExtVDD) resistor r=1.009 c=0
Rk22 (\6\:ExtVDD ExtVDD) resistor r=0.6097 c=0
Rk21 (\5\:ExtVDD \6\:ExtVDD) resistor r=0.2428 c=0
Rk25 (\5\:ExtVDD \10\:ExtVDD) resistor r=0.195 c=0
Rk29 (\12\:ExtVDD \13\:ExtVDD) resistor r=0.9962 c=0
Rk30 (\13\:ExtVDD \14\:ExtVDD) resistor r=0.3188 c=0
Rk31 (\13\:ExtVDD \16\:ExtVDD) resistor r=0.2012 c=0
Rk37 (Q \1\:Q) resistor r=0.05749 c=0
Rk38 (\1\:Q \3\:Q) resistor r=0.2148 c=0
Rk39 (\1\:Q \5\:Q) resistor r=0.3212 c=0
Rk5 (\10\:Qint \11\:Qint) resistor r=0.3479 c=0
Rk6 (\11\:Qint \13\:Qint) resistor r=0.2772 c=0
Rk10 (\14\:Qint \15\:Qint) resistor r=0.2335 c=0
Rk11 (\8\:n0 \9\:n0) resistor r=0.1166 c=0
Rk12 (\9\:n0 \10\:n0) resistor r=0.2977 c=0
Rk13 (\10\:n0 \11\:n0) resistor r=0.2581 c=0
Rk14 (\9\:n0 \12\:n0) resistor r=0.6381 c=0
Rk15 (\12\:n0 \14\:n0) resistor r=0.1712 c=0
Rk18 (\16\:n0 \18\:n0) resistor r=0.5626 c=0
Rk19 (\18\:n0 \19\:n0) resistor r=0.236 c=0
Rk16 (\5\:GNbb \6\:GNbb) resistor r=0.4153 c=0
Rk17 (\6\:GNbb \8\:GNbb) resistor r=0.5498 c=0
Rk26 (\4\:Qbint \5\:Qbint) resistor r=0.1531 c=0
Rk27 (\5\:Qbint \7\:Qbint) resistor r=0.3602 c=0
Rk28 (\5\:Qbint \9\:Qbint) resistor r=0.2124 c=0
Rk7 (\6\:GNb \7\:GNb) resistor r=0.1628 c=0
Rk8 (\7\:GNb \9\:GNb) resistor r=0.1798 c=0
Rk9 (\7\:GNb \11\:GNb) resistor r=0.3665 c=0
Rl4 (\1\:ISO \2\:ISO) resistor r=96.7539 c=0
Rl6 (\2\:ISO \4\:ISO) resistor r=118.913 c=0
Rl5 (\2\:ISO \3\:ISO) resistor r=111.027 c=0
Rl22 (\1\:D \2\:D) resistor r=111.527 c=0
Rl23 (\2\:D \3\:D) resistor r=89.3683 c=0
Rl1 (\1\:ExtVDD \2\:ExtVDD) resistor r=111.507 c=0
Rl7 (Qint \2\:Qint) resistor r=95.2927 c=0
Rl9 (\2\:Qint \4\:Qint) resistor r=102.111 c=0
Rl8 (\2\:Qint \3\:Qint) resistor r=88.5327 c=0
Rl13 (\6\:Qint \8\:Qint) resistor r=79.7084 c=0
Rl11 (\5\:Qint \6\:Qint) resistor r=76.2993 c=0
Rl12 (\6\:Qint \7\:Qint) resistor r=151.936 c=0
Rl10 (\5\:n0 \6\:n0) resistor r=348.872 c=0
Rl2 (n0 \2\:n0) resistor r=34.5953 c=0
Rl3 (\3\:n0 \4\:n0) resistor r=42.2876 c=0
Rl14 (GNbb \2\:GNbb) resistor r=157.41 c=0
Rl15 (\2\:GNbb \3\:GNbb) resistor r=831.867 c=0
Rl20 (Qbint \2\:Qbint) resistor r=45.3288 c=0
Rl21 (\2\:Qbint \3\:Qbint) resistor r=86.0157 c=0
Rl19 (\4\:GNb \5\:GNb) resistor r=288.747 c=0
Rl16 (GNb \2\:GNb) resistor r=327.66 c=0
Rl18 (\2\:GNb \4\:GNb) resistor r=138.8 c=0
Rl17 (\2\:GNb \3\:GNb) resistor r=55.2084 c=0
Rz9 (\1\:VSS \2\:VSS) resistor r=75 c=0
Rz10 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz11 (\13\:VSS \14\:VSS) resistor r=37.5 c=0
Rz12 (\15\:VSS \16\:VSS) resistor r=75 c=0
Rz8 (\4\:Q \5\:Q) resistor r=37.5 c=0
Rz1 (\12\:Qint \13\:Qint) resistor r=75 c=0
Rz3 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz5 (\15\:n0 \16\:n0) resistor r=75 c=0
Rz4 (\7\:GNbb \8\:GNbb) resistor r=75 c=0
Rz7 (\8\:Qbint \9\:Qbint) resistor r=37.5 c=0
Rz2 (\8\:GNb \9\:GNb) resistor r=75 c=0
Ry12 (\3\:VSS \4\:VSS) resistor r=6.2 c=0
Ry13 (\3\:VSS \6\:VSS) resistor r=7.75 c=0
Ry14 (\9\:VSS \10\:VSS) resistor r=10.3333 c=0
Ry15 (\9\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry6 (\3\:ExtVDD \4\:ExtVDD) resistor r=20.6667 c=0
Ry7 (\9\:ExtVDD \10\:ExtVDD) resistor r=62 c=0
Ry9 (\11\:ExtVDD \12\:ExtVDD) resistor r=62 c=0
Ry10 (\15\:ExtVDD \16\:ExtVDD) resistor r=62 c=0
Ry11 (\2\:Q \3\:Q) resistor r=20.6667 c=0
Ry1 (\9\:Qint \10\:Qint) resistor r=62 c=0
Ry3 (\13\:n0 \14\:n0) resistor r=62 c=0
Ry5 (\17\:n0 \18\:n0) resistor r=62 c=0
Ry4 (\4\:GNbb \5\:GNbb) resistor r=62 c=0
Ry8 (\6\:Qbint \7\:Qbint) resistor r=20.6667 c=0
Ry2 (\10\:GNb \11\:GNb) resistor r=62 c=0
Rx1 (\3\:ISO \6\:ISO) resistor r=45 c=0
Rx14 (\2\:D \6\:D) resistor r=45 c=0
Rx11 (\1\:ExtVDD \6\:ExtVDD) resistor r=45 c=0
Rx13 (\2\:ExtVDD \14\:ExtVDD) resistor r=45 c=0
Rx2 (\3\:Qint \11\:Qint) resistor r=45 c=0
Rx4 (\7\:Qint \14\:Qint) resistor r=45 c=0
Rx5 (\2\:Qint \15\:Qint) resistor r=45 c=0
Rx6 (\2\:n0 \10\:n0) resistor r=45 c=0
Rx7 (\4\:n0 \11\:n0) resistor r=45 c=0
Rx8 (\5\:n0 \12\:n0) resistor r=45 c=0
Rx10 (\6\:n0 \19\:n0) resistor r=45 c=0
Rx9 (\2\:GNbb \6\:GNbb) resistor r=45 c=0
Rx12 (\2\:Qbint \4\:Qbint) resistor r=45 c=0
Rx3 (\2\:GNb \6\:GNb) resistor r=45 c=0
mn10 (\12\:Qint n0 \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.5e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn0 (\8\:GNb \4\:ISO \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn15 (net245 Qint \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.32e-14 ps=4.1e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn1 (\7\:GNbb \3\:GNb \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
mn16 (\7\:n0 \3\:GNbb net245 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=11.9911 \
        scb=0.0120555 scc=0.000498628 m=(1)
mn20 (\8\:Qbint \5\:Qint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(1)
mn6 (\15\:n0 GNb net257 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn5 (net257 \3\:D \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=8.70265 \
        scb=0.00681258 scc=0.000126945 m=(1)
mn21 (\4\:Q Qbint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=13.5771 \
        scb=0.0135427 scc=0.000870653 m=(1)
mp0 (\10\:GNb \1\:ISO \15\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=10.562 \
        scb=0.00932696 scc=0.000301954 m=(1)
mp15 (net212 \4\:Qint \9\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=1.29e-14 ad=3.44e-14 ps=5.5e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=2.45e-07 sd=160n sca=7.3911 \
        scb=0.00444086 scc=5.3555e-05 m=(1)
mp1 (\4\:GNbb \4\:GNb \15\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 \
        nrd=1.16667 nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1581 \
        scb=0.00920136 scc=0.000301923 m=(1)
mp16 (\13\:n0 \5\:GNb net212 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=4.5e-07 sb=1.4e-07 sd=160n sca=7.25669 \
        scb=0.00441124 scc=5.35516e-05 m=(1)
mp20 (\6\:Qbint \8\:Qint \3\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) \
        l=4.5e-08 nf=1 as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=12.2584 \
        scb=0.0109338 scc=0.000327977 m=(1)
mp6 (\17\:n0 GNbb net220 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=14.362 \
        scb=0.0146821 scc=0.000335334 m=(1)
mp5 (net220 \1\:D \11\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=18.9016 \
        scb=0.0220066 scc=0.000851274 m=(1)
mp21 (\2\:Q \3\:Qbint \3\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=19.6538 \
        scb=0.0228433 scc=0.00109838 m=(1)
ends ISOHLDX1_OFF
// End of subcircuit definition.

// Generated for: spectre (May  9 15:06:52 2012 )
// Library name: gsclib045
// Cell name: ISOHLDX1_ON
// View name: extracted

simulator lang=spectre

subckt ISOHLDX1_ON D ISO Q VDD VSS
mp0 (\11\:GNb \1\:ISO \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=18.0983 \
        scb=0.0191571 scc=0.000483339 m=(1)
C1 (D VSS) capacitor c=5.46968e-17
C2 (Q VSS) capacitor c=1.9319e-17
C3 (VDD VSS) capacitor c=2.59313e-16
C4 (ISO VSS) capacitor c=7.22349e-17
C5 (GNbb VSS) capacitor c=8.25382e-17
C6 (n0 VSS) capacitor c=3.01029e-17
C7 (GNb VSS) capacitor c=1.80931e-16
C8 (Qbint VSS) capacitor c=4.09882e-17
C9 (Qint VSS) capacitor c=3.68918e-17
C10 (\7\:Qint VSS) capacitor c=6.07473e-17
C11 (\1\:D VSS) capacitor c=4.64379e-17
C12 (\4\:GNb VSS) capacitor c=4.39823e-17
C13 (\1\:ISO VSS) capacitor c=3.59974e-17
C14 (\4\:Qbint VSS) capacitor c=4.74834e-17
C15 (\5\:Qint VSS) capacitor c=4.27446e-17
C16 (\6\:Qint VSS) capacitor c=6.44179e-17
C17 (\5\:GNbb VSS) capacitor c=6.52909e-17
C18 (\7\:n0 VSS) capacitor c=3.33735e-17
C19 (\3\:D VSS) capacitor c=3.89649e-17
C20 (\7\:GNb VSS) capacitor c=8.29913e-17
C21 (\6\:GNb VSS) capacitor c=2.25146e-17
C22 (\3\:ISO VSS) capacitor c=5.8949e-17
C23 (\3\:Qbint VSS) capacitor c=2.23267e-17
C24 (\3\:n0 VSS) capacitor c=9.07965e-17
C25 (\4\:Qint VSS) capacitor c=5.37767e-17
C26 (\3\:GNbb VSS) capacitor c=1.19946e-16
C27 (\6\:GNbb VSS) capacitor c=4.92628e-17
C28 (\2\:n0 VSS) capacitor c=4.61641e-17
C29 (\5\:n0 VSS) capacitor c=2.23877e-17
C30 (\4\:D VSS) capacitor c=4.30483e-17
C31 (\2\:D VSS) capacitor c=4.06846e-17
C32 (\6\:n0 VSS) capacitor c=8.116e-17
C33 (\2\:GNbb VSS) capacitor c=4.82239e-17
C34 (\4\:GNbb VSS) capacitor c=1.17282e-16
C35 (\3\:GNb VSS) capacitor c=5.01906e-17
C36 (\2\:ISO VSS) capacitor c=7.17556e-17
C37 (\4\:Q VSS) capacitor c=4.11668e-17
C38 (\9\:VDD VSS) capacitor c=7.70215e-17
C39 (\9\:Qbint VSS) capacitor c=6.75274e-17
C40 (\11\:VDD VSS) capacitor c=3.58806e-17
C41 (\15\:n0 VSS) capacitor c=7.76628e-17
C42 (\12\:Qint VSS) capacitor c=5.94044e-17
C43 (\15\:VDD VSS) capacitor c=6.81109e-17
C44 (\8\:n0 VSS) capacitor c=9.12771e-17
C45 (\12\:GNbb VSS) capacitor c=4.38501e-17
C46 (\17\:VDD VSS) capacitor c=5.01106e-17
C47 (\11\:GNb VSS) capacitor c=5.27146e-17
C48 (\1\:VDD VSS) capacitor c=5.52976e-17
C49 (\2\:Q VSS) capacitor c=5.78359e-17
C50 (\7\:Qbint VSS) capacitor c=6.25756e-17
C51 (\18\:n0 VSS) capacitor c=4.13749e-17
C52 (\10\:Qint VSS) capacitor c=8.44979e-17
C53 (\11\:n0 VSS) capacitor c=4.20625e-17
C54 (\10\:GNbb VSS) capacitor c=5.21951e-17
C55 (\8\:GNb VSS) capacitor c=3.90213e-17
C56 (\4\:n0 VSS) capacitor c=6.91643e-17
C57 (\2\:GNb VSS) capacitor c=1.4763e-16
C58 (\5\:GNb VSS) capacitor c=3.83632e-17
C59 (\2\:Qint VSS) capacitor c=5.60414e-17
C60 (\3\:Qint VSS) capacitor c=5.85309e-17
C61 (\2\:Qbint VSS) capacitor c=3.22034e-17
C62 (\10\:GNb VSS) capacitor c=6.42284e-17
C63 (\13\:GNb VSS) capacitor c=4.1368e-17
C64 (\7\:GNbb VSS) capacitor c=6.35714e-17
C65 (\14\:GNbb VSS) capacitor c=7.66107e-17
C66 (\10\:n0 VSS) capacitor c=9.14929e-17
C67 (\5\:D VSS) capacitor c=5.20165e-17
C68 (\6\:D VSS) capacitor c=5.37685e-17
C69 (\13\:n0 VSS) capacitor c=6.78489e-17
C70 (\14\:n0 VSS) capacitor c=7.86087e-17
C71 (\15\:GNbb VSS) capacitor c=6.06224e-17
C72 (\16\:GNbb VSS) capacitor c=7.28652e-17
C73 (\8\:Qint VSS) capacitor c=3.31493e-17
C74 (\9\:Qint VSS) capacitor c=8.59178e-17
C75 (\17\:n0 VSS) capacitor c=9.09205e-17
C76 (\5\:Qbint VSS) capacitor c=3.46351e-17
C77 (\6\:Qbint VSS) capacitor c=3.41417e-17
C78 (\1\:Q VSS) capacitor c=4.79901e-17
C79 (\3\:VDD VSS) capacitor c=1.13206e-17
C80 (\4\:VDD VSS) capacitor c=2.19559e-17
C81 (\6\:VDD VSS) capacitor c=5.46251e-18
C82 (\7\:VDD VSS) capacitor c=1.79267e-17
Rk13 (\5\:D D) resistor r=0.339 c=0
Rk14 (D \6\:D) resistor r=0.1252 c=0
Rk25 (Q \1\:Q) resistor r=0.03194 c=0
Rk26 (\1\:Q \3\:Q) resistor r=0.4954 c=0
Rk27 (\1\:Q \5\:Q) resistor r=0.2038 c=0
Rk28 (\2\:VDD \3\:VDD) resistor r=0.1002 c=0
Rk30 (\4\:VDD VDD) resistor r=0.3282 c=0
Rk29 (\3\:VDD \4\:VDD) resistor r=0.2229 c=0
Rk33 (\6\:VDD VDD) resistor r=0.1209 c=0
Rk32 (VDD \6\:VDD) resistor r=0.1162 c=0
Rk34 (VDD \7\:VDD) resistor r=0.3137 c=0
Rk35 (\7\:VDD \8\:VDD) resistor r=0.09264 c=0
Rk36 (\3\:VDD \10\:VDD) resistor r=0.2916 c=0
Rk37 (\4\:VDD \12\:VDD) resistor r=0.201 c=0
Rk38 (\6\:VDD \14\:VDD) resistor r=0.05664 c=0
Rk40 (\7\:VDD \18\:VDD) resistor r=0.2161 c=0
Rk1 (ISO \4\:ISO) resistor r=0.006492 c=0
Rk41 (\2\:VSS \3\:VSS) resistor r=0.1002 c=0
Rk43 (\4\:VSS VSS) resistor r=0.3282 c=0
Rk42 (\3\:VSS \4\:VSS) resistor r=0.2229 c=0
Rk46 (\6\:VSS VSS) resistor r=0.3016 c=0
Rk45 (VSS \6\:VSS) resistor r=0.1162 c=0
Rk47 (VSS \7\:VSS) resistor r=0.133 c=0
Rk48 (\7\:VSS \8\:VSS) resistor r=0.09264 c=0
Rk49 (\3\:VSS \10\:VSS) resistor r=0.2303 c=0
Rk50 (\4\:VSS \12\:VSS) resistor r=0.1734 c=0
Rk51 (\6\:VSS \14\:VSS) resistor r=0.04811 c=0
Rk53 (\7\:VSS \18\:VSS) resistor r=0.1842 c=0
Rk6 (\7\:GNbb \8\:GNbb) resistor r=0.02474 c=0
Rk7 (\8\:GNbb \9\:GNbb) resistor r=0.2741 c=0
Rk8 (\9\:GNbb \11\:GNbb) resistor r=0.3161 c=0
Rk9 (\8\:GNbb \13\:GNbb) resistor r=0.2153 c=0
Rk10 (\9\:GNbb \14\:GNbb) resistor r=0.02474 c=0
Rk16 (\15\:GNbb \16\:GNbb) resistor r=0.2385 c=0
Rk11 (\9\:n0 \10\:n0) resistor r=0.5834 c=0
Rk12 (\10\:n0 \12\:n0) resistor r=0.2209 c=0
Rk15 (\13\:n0 \14\:n0) resistor r=0.4788 c=0
Rk20 (\16\:n0 \17\:n0) resistor r=0.5935 c=0
Rk21 (\17\:n0 \19\:n0) resistor r=0.2568 c=0
Rk3 (\9\:GNb \10\:GNb) resistor r=0.3372 c=0
Rk4 (\10\:GNb \12\:GNb) resistor r=0.4523 c=0
Rk5 (\10\:GNb \13\:GNb) resistor r=0.1657 c=0
Rk22 (\5\:Qbint \6\:Qbint) resistor r=0.1544 c=0
Rk23 (\6\:Qbint \8\:Qbint) resistor r=0.393 c=0
Rk24 (\6\:Qbint \10\:Qbint) resistor r=0.2938 c=0
Rk17 (\8\:Qint \9\:Qint) resistor r=0.07731 c=0
Rk18 (\9\:Qint \11\:Qint) resistor r=0.4576 c=0
Rk19 (\9\:Qint \13\:Qint) resistor r=0.3397 c=0
Rl5 (\3\:D \4\:D) resistor r=24.2328 c=0
Rl4 (\1\:D \2\:D) resistor r=33.3841 c=0
Rl1 (\1\:ISO \2\:ISO) resistor r=71.8665 c=0
Rl2 (\2\:ISO \3\:ISO) resistor r=228.685 c=0
Rl18 (\5\:GNbb \6\:GNbb) resistor r=85.3829 c=0
Rl3 (GNbb \2\:GNbb) resistor r=140.087 c=0
Rl7 (\3\:GNbb \4\:GNbb) resistor r=338.212 c=0
Rl6 (n0 \2\:n0) resistor r=81.2354 c=0
Rl11 (\5\:n0 \7\:n0) resistor r=73.8039 c=0
Rl8 (\3\:n0 \4\:n0) resistor r=187.823 c=0
Rl9 (\4\:n0 \5\:n0) resistor r=9.6495 c=0
Rl10 (\4\:n0 \6\:n0) resistor r=145.209 c=0
Rl12 (GNb \2\:GNb) resistor r=587.01 c=0
Rl14 (\2\:GNb \4\:GNb) resistor r=120.618 c=0
Rl13 (\2\:GNb \3\:GNb) resistor r=40.6135 c=0
Rl17 (\5\:GNb \7\:GNb) resistor r=175.127 c=0
Rl16 (\5\:GNb \6\:GNb) resistor r=36.0502 c=0
Rl15 (\3\:GNb \5\:GNb) resistor r=90.3235 c=0
Rl25 (Qbint \2\:Qbint) resistor r=70.3096 c=0
Rl27 (\2\:Qbint \4\:Qbint) resistor r=145.333 c=0
Rl26 (\2\:Qbint \3\:Qbint) resistor r=1.2301 c=0
Rl19 (Qint \2\:Qint) resistor r=72.8903 c=0
Rl22 (\2\:Qint \5\:Qint) resistor r=147.89 c=0
Rl24 (\3\:Qint \7\:Qint) resistor r=129.936 c=0
Rl23 (\3\:Qint \6\:Qint) resistor r=184.481 c=0
Rl21 (\3\:Qint \4\:Qint) resistor r=97.8063 c=0
Rl20 (\2\:Qint \3\:Qint) resistor r=141.644 c=0
Rz7 (\2\:Q \3\:Q) resistor r=37.5 c=0
Rz9 (\1\:VDD VDD) resistor r=6.8182 c=0
Rz8 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz10 (\1\:VDD \8\:VDD) resistor r=37.5 c=0
Rz11 (\9\:VSS \10\:VSS) resistor r=37.5 c=0
Rz12 (\11\:VSS \12\:VSS) resistor r=75 c=0
Rz13 (\13\:VSS \14\:VSS) resistor r=75 c=0
Rz14 (\15\:VSS \14\:VSS) resistor r=75 c=0
Rz15 (\17\:VSS \18\:VSS) resistor r=75 c=0
Rz2 (\10\:GNbb \11\:GNbb) resistor r=75 c=0
Rz3 (\11\:n0 \12\:n0) resistor r=75 c=0
Rz5 (\18\:n0 \19\:n0) resistor r=75 c=0
Rz1 (\8\:GNb \9\:GNb) resistor r=75 c=0
Rz6 (\7\:Qbint \8\:Qbint) resistor r=37.5 c=0
Rz4 (\10\:Qint \11\:Qint) resistor r=75 c=0
Ry7 (\4\:Q \5\:Q) resistor r=20.6667 c=0
Ry8 (\9\:VDD \10\:VDD) resistor r=20.6667 c=0
Ry9 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry10 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry11 (\15\:VDD \14\:VDD) resistor r=62 c=0
Ry12 (\17\:VDD \18\:VDD) resistor r=62 c=0
Ry14 (\1\:VSS VSS) resistor r=5.6364 c=0
Ry13 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry15 (\1\:VSS \8\:VSS) resistor r=31 c=0
Ry2 (\12\:GNbb \13\:GNbb) resistor r=62 c=0
Ry3 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry5 (\15\:n0 \16\:n0) resistor r=62 c=0
Ry1 (\11\:GNb \12\:GNb) resistor r=62 c=0
Ry6 (\9\:Qbint \10\:Qbint) resistor r=20.6667 c=0
Ry4 (\12\:Qint \13\:Qint) resistor r=62 c=0
Rx6 (\2\:D \5\:D) resistor r=45 c=0
Rx7 (\4\:D \6\:D) resistor r=45 c=0
Rx1 (\2\:ISO \4\:ISO) resistor r=45 c=0
Rx3 (\2\:GNbb \7\:GNbb) resistor r=45 c=0
Rx4 (\4\:GNbb \14\:GNbb) resistor r=45 c=0
Rx10 (\3\:GNbb \15\:GNbb) resistor r=45 c=0
Rx11 (\6\:GNbb \16\:GNbb) resistor r=45 c=0
Rx5 (\6\:n0 \10\:n0) resistor r=45 c=0
Rx8 (\2\:n0 \13\:n0) resistor r=45 c=0
Rx9 (\5\:n0 \14\:n0) resistor r=45 c=0
Rx13 (\3\:n0 \17\:n0) resistor r=45 c=0
Rx2 (\3\:GNb \13\:GNb) resistor r=45 c=0
Rx14 (\3\:Qbint \5\:Qbint) resistor r=45 c=0
Rx12 (\4\:Qint \8\:Qint) resistor r=45 c=0
mn0 (\8\:GNb \3\:ISO \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=6.31271 \
        scb=0.00272743 scc=1.50943e-05 m=(1)
mn1 (\10\:GNbb \6\:GNb \17\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=6.31271 \
        scb=0.00272743 scc=1.50943e-05 m=(1)
mn6 (\11\:n0 \7\:GNb net257 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=6.31271 \
        scb=0.00272743 scc=1.50943e-05 m=(1)
mn5 (net257 \3\:D \15\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.31271 \
        scb=0.00272743 scc=1.50943e-05 m=(1)
mn10 (\10\:Qint \7\:n0 \13\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.31271 \
        scb=0.00272743 scc=1.50943e-05 m=(1)
mn16 (\18\:n0 \5\:GNbb net245 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=6.31271 \
        scb=0.00272743 scc=1.50943e-05 m=(1)
mn15 (net245 \6\:Qint \11\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.31271 \
        scb=0.00272743 scc=1.50943e-05 m=(1)
mn20 (\7\:Qbint \5\:Qint \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=7.39137 \
        scb=0.00470608 scc=6.95095e-05 m=(1)
mn21 (\2\:Q \4\:Qbint \9\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=7.39137 \
        scb=0.00470608 scc=6.95095e-05 m=(1)
mp1 (\12\:GNbb \4\:GNb \17\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=12.8783 \
        scb=0.0102763 scc=0.000121633 m=(1)
mp6 (\8\:n0 GNbb net220 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=10.5523 \
        scb=0.00801875 scc=0.000111755 m=(1)
mp5 (net220 \1\:D \15\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=10.4936 \
        scb=0.00800718 scc=0.000111754 m=(1)
mp10 (\12\:Qint n0 \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.4936 \
        scb=0.00800718 scc=0.000111754 m=(1)
mp16 (\15\:n0 GNb net212 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=10.4936 \
        scb=0.00800718 scc=0.000111754 m=(1)
mp15 (net212 \7\:Qint \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=10.5223 \
        scb=0.00801258 scc=0.000111754 m=(1)
mp20 (\9\:Qbint Qint \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=13.482 \
        scb=0.0113805 scc=0.000219474 m=(1)
mp21 (\4\:Q Qbint \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=18.1719 \
        scb=0.0193935 scc=0.000499405 m=(1)
ends ISOHLDX1_ON
// End of subcircuit definition.

// Generated for: spectre (Mar 22 12:55:49 2012 )
// Library name: gsclib045
// Cell name: ISOHX1_OFF
// View name: extracted

simulator lang=spectre

subckt ISOHX1_OFF A ExtVDD ISO VDD VSS Y
mp0 (n1 \1\:A \5\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=32.9181 \
        scb=0.0376829 scc=0.00281564 m=(1)
C1 (ExtVDD VSS) capacitor c=2.15993e-16
C2 (Y VSS) capacitor c=4.32049e-17
C3 (A VSS) capacitor c=2.03652e-17
C4 (VDD VSS) capacitor c=1.41663e-16
C5 (ISO VSS) capacitor c=2.48058e-17
C6 (n0 VSS) capacitor c=2.73996e-17
C7 (\3\:n0 VSS) capacitor c=4.42708e-17
C8 (\1\:ISO VSS) capacitor c=7.29421e-17
C9 (\1\:A VSS) capacitor c=6.44125e-17
C10 (\3\:ISO VSS) capacitor c=3.23002e-17
C11 (\3\:A VSS) capacitor c=5.11576e-17
C12 (\2\:n0 VSS) capacitor c=2.73373e-17
C13 (\2\:ISO VSS) capacitor c=5.3883e-17
C14 (\2\:A VSS) capacitor c=6.72046e-17
C15 (\1\:Y VSS) capacitor c=5.69351e-17
C16 (\1\:ExtVDD VSS) capacitor c=5.77881e-17
C17 (\8\:n0 VSS) capacitor c=6.84656e-17
C18 (\5\:ExtVDD VSS) capacitor c=1.19539e-16
C19 (\3\:Y VSS) capacitor c=5.66666e-17
C20 (\6\:n0 VSS) capacitor c=7.18505e-17
C21 (VDD VSS) capacitor c=1.61361e-16
C22 (\4\:A VSS) capacitor c=2.01654e-17
C23 (\5\:ISO VSS) capacitor c=9.89908e-18
C24 (\7\:ISO VSS) capacitor c=3.71349e-17
C25 (\4\:n0 VSS) capacitor c=7.37649e-17
C26 (\5\:n0 VSS) capacitor c=1.22845e-16
Rk8 (ExtVDD ExtVDD) resistor r=0.002413 c=0
Rk7 (\2\:ExtVDD ExtVDD) resistor r=0.4341 c=0
Rk10 (ExtVDD \6\:ExtVDD) resistor r=1.0207 c=0
Rk14 (Y \2\:Y) resistor r=0.2855 c=0
Rk15 (Y \4\:Y) resistor r=0.338 c=0
Rk1 (\4\:A A) resistor r=0.02992 c=0
Rk18 (VSS VSS) resistor r=0.08927 c=0
Rk17 (\3\:VSS VSS) resistor r=0.1226 c=0
Rk16 (\2\:VSS \3\:VSS) resistor r=0.4293 c=0
Rk19 (VSS \4\:VSS) resistor r=0.03402 c=0
Rk20 (\4\:VSS \5\:VSS) resistor r=0.06254 c=0
Rk21 (\5\:VSS \7\:VSS) resistor r=0.4305 c=0
Rk22 (\3\:VSS \9\:VSS) resistor r=0.2248 c=0
Rk23 (\5\:VSS \11\:VSS) resistor r=0.2051 c=0
Rk24 (\13\:VSS VSS) resistor r=0.5788 c=0
Rk26 (\14\:VSS VSS) resistor r=0.1035 c=0
Rk25 (VSS \14\:VSS) resistor r=0.09675 c=0
Rk27 (VDD VDD) resistor r=0.1725 c=0
Rk2 (\4\:ISO ISO) resistor r=0.003933 c=0
Rk3 (ISO \5\:ISO) resistor r=0.003933 c=0
Rk4 (\4\:ISO \5\:ISO) resistor r=0.03257 c=0
Rk6 (\5\:ISO \7\:ISO) resistor r=0.02268 c=0
Rk5 (\6\:ISO \7\:ISO) resistor r=0.003933 c=0
Rk11 (\4\:n0 \5\:n0) resistor r=0.4359 c=0
Rk12 (\5\:n0 \7\:n0) resistor r=0.3811 c=0
Rk13 (\5\:n0 \9\:n0) resistor r=0.427 c=0
Rl1 (\1\:A \2\:A) resistor r=102.646 c=0
Rl2 (\2\:A \3\:A) resistor r=166.884 c=0
Rl3 (\1\:ISO \2\:ISO) resistor r=155.766 c=0
Rl4 (\2\:ISO \3\:ISO) resistor r=82.6066 c=0
Rl5 (n0 \2\:n0) resistor r=45.3288 c=0
Rl6 (\2\:n0 \3\:n0) resistor r=133.743 c=0
Rz3 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=75 c=0
Rz5 (\8\:VSS \9\:VSS) resistor r=37.5 c=0
Rz6 (\10\:VSS \11\:VSS) resistor r=75 c=0
Rz2 (\6\:n0 \7\:n0) resistor r=75 c=0
Ry1 (\1\:ExtVDD \2\:ExtVDD) resistor r=20.6667 c=0
Ry2 (\5\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry4 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry6 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry7 (\12\:VSS \13\:VSS) resistor r=31 c=0
Ry8 (\12\:VSS \14\:VSS) resistor r=5.1667 c=0
Ry3 (\8\:n0 \9\:n0) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\2\:ISO \6\:ISO) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn0 (\6\:n0 \3\:A \6\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn1 (\6\:n0 \3\:ISO \10\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.32e-14 ps=5.7e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\3\:Y n0 \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.1772 scb=0.0118935 \
        scc=0.000630577 m=(1)
mp1 (\8\:n0 \1\:ISO n1 ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=27.5095 \
        scb=0.0294402 scc=0.00209822 m=(1)
mp2 (\1\:Y \3\:n0 \1\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=62.1058 \
        scb=0.0481534 scc=0.00692577 m=(1)
ends ISOHX1_OFF
// End of subcircuit definition.

// Generated for: spectre (May  3 15:26:01 2012 )
// Library name: gsclib045
// Cell name: ISOHX1_ON
// View name: extracted

simulator lang=spectre

subckt ISOHX1_ON A ISO VDD VSS Y
mp0 (n1 \3\:A \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=1.29e-14 ad=3.01e-14 ps=5.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=17.4272 \
        scb=0.0179257 scc=0.000390864 m=(1)
C1 (VDD VSS) capacitor c=8.31332e-17
C2 (Y VSS) capacitor c=6.38547e-17
C3 (A VSS) capacitor c=4.47293e-17
C4 (ISO VSS) capacitor c=5.26595e-17
C5 (n0 VSS) capacitor c=3.78722e-17
C6 (\3\:ISO VSS) capacitor c=5.8064e-17
C7 (\3\:A VSS) capacitor c=7.65357e-17
C8 (\3\:n0 VSS) capacitor c=4.47641e-17
C9 (\1\:ISO VSS) capacitor c=5.86812e-17
C10 (\1\:A VSS) capacitor c=4.08935e-17
C11 (\2\:n0 VSS) capacitor c=3.13449e-17
C12 (\4\:ISO VSS) capacitor c=8.59707e-17
C13 (\2\:A VSS) capacitor c=6.85275e-17
C14 (\4\:Y VSS) capacitor c=3.27477e-17
C15 (\1\:VDD VSS) capacitor c=1.03828e-16
C16 (\6\:n0 VSS) capacitor c=8.17501e-17
C17 (\6\:VDD VSS) capacitor c=2.64794e-17
C18 (\3\:VDD VSS) capacitor c=7.58858e-19
C19 (\2\:Y VSS) capacitor c=5.03602e-17
C20 (\8\:n0 VSS) capacitor c=7.14362e-17
C21 (\4\:n0 VSS) capacitor c=3.19173e-17
C22 (\5\:n0 VSS) capacitor c=6.9275e-17
C23 (\1\:Y VSS) capacitor c=1.88029e-17
C24 (\5\:VDD VSS) capacitor c=1.95128e-17
Rk13 (VDD VDD) resistor r=0.04493 c=0
Rk12 (\4\:VDD VDD) resistor r=0.004743 c=0
Rk11 (\2\:VDD \4\:VDD) resistor r=0.3787 c=0
Rk14 (VDD \5\:VDD) resistor r=0.1973 c=0
Rk15 (\5\:VDD \7\:VDD) resistor r=0.2836 c=0
Rk16 (\5\:VDD \8\:VDD) resistor r=0.05222 c=0
Rk7 (Y \1\:Y) resistor r=0.01335 c=0
Rk9 (Y \3\:Y) resistor r=0.3142 c=0
Rk10 (\1\:Y \5\:Y) resistor r=0.1452 c=0
Rk2 (\4\:A A) resistor r=0.004654 c=0
Rk19 (VSS VSS) resistor r=0.01248 c=0
Rk18 (\4\:VSS VSS) resistor r=0.1002 c=0
Rk17 (\2\:VSS \4\:VSS) resistor r=0.2827 c=0
Rk20 (VSS \5\:VSS) resistor r=0.1299 c=0
Rk21 (\5\:VSS \6\:VSS) resistor r=0.05722 c=0
Rk22 (\5\:VSS \8\:VSS) resistor r=0.2331 c=0
Rk3 (ISO \5\:ISO) resistor r=0.002412 c=0
Rk4 (\4\:n0 \5\:n0) resistor r=0.1025 c=0
Rk5 (\5\:n0 \7\:n0) resistor r=0.3941 c=0
Rk6 (\5\:n0 \9\:n0) resistor r=0.3877 c=0
Rl2 (\2\:A \3\:A) resistor r=153.685 c=0
Rl1 (\1\:A \2\:A) resistor r=89.8433 c=0
Rl4 (\2\:ISO \3\:ISO) resistor r=95.9008 c=0
Rl3 (\1\:ISO \2\:ISO) resistor r=196.188 c=0
Rl5 (\2\:ISO \4\:ISO) resistor r=0.6051 c=0
Rl6 (n0 \2\:n0) resistor r=58.6969 c=0
Rl7 (\2\:n0 \3\:n0) resistor r=101.357 c=0
Rz3 (\3\:VDD \4\:VDD) resistor r=15 c=0
Rz4 (\3\:VDD \8\:VDD) resistor r=75 c=0
Rz2 (\2\:Y \3\:Y) resistor r=37.5 c=0
Rz5 (\1\:VSS \2\:VSS) resistor r=37.5 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=75 c=0
Rz1 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry3 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry4 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry2 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry5 (\3\:VSS \4\:VSS) resistor r=15.5 c=0
Ry6 (\3\:VSS \6\:VSS) resistor r=31 c=0
Ry1 (\6\:n0 \7\:n0) resistor r=62 c=0
Rx1 (\2\:A \4\:A) resistor r=45 c=0
Rx2 (\4\:ISO \5\:ISO) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn0 (\8\:n0 \1\:A \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.32e-14 ad=2.03e-14 ps=6.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.8e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn1 (\8\:n0 \1\:ISO \1\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.32e-14 ps=9e-07 pd=6.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.75e-07 sd=160n sca=7.91544 \
        scb=0.00544522 scc=7.50774e-05 m=(1)
mn2 (\2\:Y \3\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.365e-14 ps=8e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.85385e-07 sb=1.4e-07 sd=160n sca=8.09546 scb=0.00588493 \
        scc=0.000117119 m=(1)
mp1 (\6\:n0 \3\:ISO n1 VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=1.29e-14 ps=7.1e-07 pd=5.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=14.7748 \
        scb=0.0128938 scc=0.000187084 m=(1)
mp2 (\4\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=18.5723 \
        scb=0.0189272 scc=0.00068777 m=(1)
ends ISOHX1_ON
// End of subcircuit definition.

// Generated for: spectre (Mar 22 12:57:33 2012 )
// Library name: gsclib045
// Cell name: ISOLX1_OFF
// View name: extracted

simulator lang=spectre

subckt ISOLX1_OFF A ExtVDD ISO VDD VSS Y
mp0 (\8\:n0 \3\:A \13\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=25.7248 \
        scb=0.0268097 scc=0.00266528 m=(1)
C1 (VDD VSS) capacitor c=1.57295e-16
C2 (ExtVDD VSS) capacitor c=3.23688e-16
C3 (ISO VSS) capacitor c=3.23615e-17
C4 (Y VSS) capacitor c=4.27586e-17
C5 (A VSS) capacitor c=1.71786e-17
C6 (n0 VSS) capacitor c=2.81513e-17
C7 (ison VSS) capacitor c=2.39185e-17
C8 (\3\:n0 VSS) capacitor c=5.13398e-17
C9 (\1\:ISO VSS) capacitor c=2.7309e-17
C10 (\3\:A VSS) capacitor c=3.94397e-17
C11 (\3\:ISO VSS) capacitor c=2.7928e-17
C12 (\3\:ison VSS) capacitor c=8.16894e-17
C13 (\1\:A VSS) capacitor c=6.90506e-17
C14 (\2\:n0 VSS) capacitor c=3.14116e-17
C15 (\1\:ExtVDD VSS) capacitor c=3.62702e-17
C16 (\2\:ExtVDD VSS) capacitor c=1.64159e-17
C17 (\2\:ISO VSS) capacitor c=3.4141e-17
C18 (\4\:ison VSS) capacitor c=8.6248e-17
C19 (\2\:A VSS) capacitor c=5.60088e-17
C20 (\1\:Y VSS) capacitor c=5.63384e-17
C21 (\7\:ExtVDD VSS) capacitor c=4.68216e-17
C22 (\4\:ExtVDD VSS) capacitor c=5.69038e-17
C23 (\11\:ExtVDD VSS) capacitor c=8.0696e-17
C24 (\6\:ison VSS) capacitor c=6.03258e-17
C25 (\8\:n0 VSS) capacitor c=7.38498e-17
C26 (\13\:ExtVDD VSS) capacitor c=7.16299e-17
C27 (\3\:Y VSS) capacitor c=5.61434e-17
C28 (\8\:ison VSS) capacitor c=5.97795e-17
C29 (\6\:n0 VSS) capacitor c=3.28604e-17
C30 (VDD VSS) capacitor c=1.66756e-16
C31 (\2\:ison VSS) capacitor c=7.73275e-17
C32 (\5\:A VSS) capacitor c=1.34546e-17
C33 (\7\:A VSS) capacitor c=3.64326e-17
C34 (\5\:ison VSS) capacitor c=3.6522e-17
C35 (\4\:ISO VSS) capacitor c=3.13356e-17
C36 (\6\:ISO VSS) capacitor c=6.60597e-18
C37 (\3\:ExtVDD VSS) capacitor c=2.29972e-17
C38 (\6\:ExtVDD VSS) capacitor c=1.62222e-17
C39 (\4\:n0 VSS) capacitor c=8.51439e-17
C40 (\5\:n0 VSS) capacitor c=1.2871e-16
Rk32 (VSS VSS) resistor r=0.0291 c=0
Rk27 (VSS VSS) resistor r=0.0291 c=0
Rk26 (\3\:VSS VSS) resistor r=0.1232 c=0
Rk25 (\2\:VSS \3\:VSS) resistor r=0.429 c=0
Rk28 (VSS \4\:VSS) resistor r=0.09723 c=0
Rk29 (\4\:VSS \6\:VSS) resistor r=0.3005 c=0
Rk30 (\3\:VSS \8\:VSS) resistor r=0.226 c=0
Rk31 (\10\:VSS VSS) resistor r=0.5526 c=0
Rk33 (VSS \11\:VSS) resistor r=0.09783 c=0
Rk34 (\11\:VSS \13\:VSS) resistor r=0.2859 c=0
Rk35 (VDD VDD) resistor r=0.1722 c=0
Rk16 (ExtVDD ExtVDD) resistor r=0.002425 c=0
Rk13 (\3\:ExtVDD \5\:ExtVDD) resistor r=0.3844 c=0
Rk15 (\8\:ExtVDD ExtVDD) resistor r=0.4363 c=0
Rk14 (\6\:ExtVDD \8\:ExtVDD) resistor r=0.2264 c=0
Rk18 (ExtVDD \12\:ExtVDD) resistor r=0.4672 c=0
Rk19 (\12\:ExtVDD \14\:ExtVDD) resistor r=0.6236 c=0
Rk8 (\4\:ISO \5\:ISO) resistor r=0.002341 c=0
Rk9 (ISO \6\:ISO) resistor r=0.002341 c=0
Rk10 (\4\:ISO \6\:ISO) resistor r=0.01479 c=0
Rk11 (\7\:ISO ISO) resistor r=0.002341 c=0
Rk12 (\6\:ISO \7\:ISO) resistor r=0.03273 c=0
Rk23 (Y \2\:Y) resistor r=0.287 c=0
Rk24 (Y \4\:Y) resistor r=0.3398 c=0
Rk1 (\4\:A A) resistor r=0.002577 c=0
Rk2 (A \5\:A) resistor r=0.002577 c=0
Rk3 (\4\:A \5\:A) resistor r=0.03637 c=0
Rk5 (\5\:A \7\:A) resistor r=0.0337 c=0
Rk4 (\6\:A \7\:A) resistor r=0.002577 c=0
Rk20 (\4\:n0 \5\:n0) resistor r=0.5891 c=0
Rk21 (\5\:n0 \7\:n0) resistor r=0.3245 c=0
Rk22 (\5\:n0 \9\:n0) resistor r=0.4006 c=0
Rk6 (\5\:ison \7\:ison) resistor r=0.3022 c=0
Rk7 (\7\:ison \9\:ison) resistor r=0.4318 c=0
Rl8 (\1\:ExtVDD \2\:ExtVDD) resistor r=200.144 c=0
Rl3 (\1\:ISO \2\:ISO) resistor r=75.732 c=0
Rl4 (\2\:ISO \3\:ISO) resistor r=65.5047 c=0
Rl2 (\2\:A \3\:A) resistor r=86.0157 c=0
Rl1 (\1\:A \2\:A) resistor r=143.75 c=0
Rl9 (n0 \2\:n0) resistor r=45.3288 c=0
Rl10 (\2\:n0 \3\:n0) resistor r=133.743 c=0
Rl5 (ison \2\:ison) resistor r=36.0502 c=0
Rl6 (\2\:ison \3\:ison) resistor r=225.795 c=0
Rl7 (\2\:ison \4\:ison) resistor r=434.485 c=0
Rz5 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz6 (\7\:VSS \8\:VSS) resistor r=37.5 c=0
Rz7 (\12\:VSS \13\:VSS) resistor r=75 c=0
Rz4 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz3 (\6\:n0 \7\:n0) resistor r=75 c=0
Rz1 (\8\:ison \9\:ison) resistor r=75 c=0
Ry8 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry9 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry10 (\9\:VSS \10\:VSS) resistor r=31 c=0
Ry11 (\9\:VSS \11\:VSS) resistor r=5.1667 c=0
Ry2 (\4\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry3 (\7\:ExtVDD \8\:ExtVDD) resistor r=20.6667 c=0
Ry4 (\11\:ExtVDD \12\:ExtVDD) resistor r=62 c=0
Ry5 (\13\:ExtVDD \14\:ExtVDD) resistor r=62 c=0
Ry7 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry6 (\8\:n0 \9\:n0) resistor r=62 c=0
Ry1 (\6\:ison \7\:ison) resistor r=62 c=0
Rx4 (\2\:ExtVDD \3\:ExtVDD) resistor r=45 c=0
Rx5 (\1\:ExtVDD \6\:ExtVDD) resistor r=45 c=0
Rx3 (\2\:ISO \5\:ISO) resistor r=45 c=0
Rx1 (\2\:A \6\:A) resistor r=45 c=0
Rx6 (\2\:n0 \4\:n0) resistor r=45 c=0
Rx2 (\4\:ison \5\:ison) resistor r=45 c=0
mn1 (\6\:n0 \1\:A net127 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn0 (net127 \3\:ison \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
NM1 (\12\:VSS \3\:ISO \8\:ison VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
mn2 (\3\:Y n0 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.1772 scb=0.0118935 \
        scc=0.000630577 m=(1)
mp1 (\8\:n0 ison \11\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.8522 \
        scb=0.00872809 scc=0.000103319 m=(1)
PM1 (\6\:ison \1\:ISO \4\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=27.9622 \
        scb=0.0254321 scc=0.00303076 m=(1)
mp2 (\1\:Y \3\:n0 \7\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.7882 \
        scb=0.0272171 scc=0.00268607 m=(1)
ends ISOLX1_OFF
// End of subcircuit definition.

// Generated for: spectre (May  3 15:26:45 2012 )
// Library name: gsclib045
// Cell name: ISOLX1_ON
// View name: extracted

simulator lang=spectre

subckt ISOLX1_ON A ISO VDD VSS Y
PM1 (\8\:ison \1\:ISO \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=20.0013 \
        scb=0.0219001 scc=0.000764007 m=(1)
C1 (ISO VSS) capacitor c=2.25055e-17
C2 (Y VSS) capacitor c=1.61876e-17
C3 (A VSS) capacitor c=5.89268e-17
C4 (VDD VSS) capacitor c=1.09486e-16
C5 (ison VSS) capacitor c=5.55444e-17
C6 (n0 VSS) capacitor c=4.26565e-17
C7 (\4\:A VSS) capacitor c=3.76437e-17
C8 (\1\:ISO VSS) capacitor c=4.98263e-17
C9 (\4\:n0 VSS) capacitor c=5.00825e-17
C10 (\3\:ison VSS) capacitor c=6.44757e-17
C11 (\1\:A VSS) capacitor c=8.1021e-17
C12 (\4\:ISO VSS) capacitor c=3.12891e-17
C13 (\3\:n0 VSS) capacitor c=1.72416e-17
C14 (\2\:ison VSS) capacitor c=8.04201e-17
C15 (\3\:A VSS) capacitor c=1.56668e-17
C16 (\3\:ISO VSS) capacitor c=1.64537e-17
C17 (\4\:Y VSS) capacitor c=4.90926e-17
C18 (\9\:VDD VSS) capacitor c=7.65461e-17
C19 (\5\:n0 VSS) capacitor c=7.0277e-17
C20 (\11\:VDD VSS) capacitor c=4.52305e-17
C21 (\8\:ison VSS) capacitor c=6.70895e-17
C22 (\7\:VDD VSS) capacitor c=2.9205e-17
C23 (\1\:VDD VSS) capacitor c=5.18885e-17
C24 (\2\:Y VSS) capacitor c=4.76602e-17
C25 (\8\:n0 VSS) capacitor c=8.79953e-17
C26 (\6\:ison VSS) capacitor c=4.58734e-17
C27 (\2\:ISO VSS) capacitor c=3.86685e-17
C28 (\2\:A VSS) capacitor c=4.77365e-17
C29 (\2\:n0 VSS) capacitor c=2.97591e-17
C30 (\5\:ISO VSS) capacitor c=3.79466e-17
C31 (\7\:A VSS) capacitor c=4.23264e-17
C32 (\4\:ison VSS) capacitor c=7.37181e-17
C33 (\5\:ison VSS) capacitor c=9.64092e-17
C34 (\7\:n0 VSS) capacitor c=1.37216e-16
C35 (\1\:Y VSS) capacitor c=6.21062e-17
C36 (\3\:VDD VSS) capacitor c=1.85195e-18
C37 (\5\:VDD VSS) capacitor c=3.41714e-18
Rk25 (VSS VSS) resistor r=0.02257 c=0
Rk24 (\3\:VSS VSS) resistor r=0.1475 c=0
Rk23 (\2\:VSS \3\:VSS) resistor r=0.08007 c=0
Rk26 (VSS \4\:VSS) resistor r=0.1006 c=0
Rk27 (\4\:VSS \6\:VSS) resistor r=0.3722 c=0
Rk28 (\3\:VSS \8\:VSS) resistor r=0.2343 c=0
Rk1 (ISO \5\:ISO) resistor r=0.01958 c=0
Rk11 (Y \1\:Y) resistor r=0.01258 c=0
Rk12 (\1\:Y \3\:Y) resistor r=0.3657 c=0
Rk13 (\1\:Y \5\:Y) resistor r=0.307 c=0
Rk5 (A \7\:A) resistor r=0.02394 c=0
Rk4 (\6\:A \7\:A) resistor r=0.00958 c=0
Rk15 (\3\:VDD VDD) resistor r=0.1074 c=0
Rk14 (\2\:VDD \3\:VDD) resistor r=0.08007 c=0
Rk16 (VDD \4\:VDD) resistor r=0.01279 c=0
Rk17 (\4\:VDD VDD) resistor r=0.04991 c=0
Rk18 (VDD \5\:VDD) resistor r=0.05022 c=0
Rk19 (\5\:VDD \6\:VDD) resistor r=0.1503 c=0
Rk20 (\6\:VDD \8\:VDD) resistor r=0.2942 c=0
Rk21 (\3\:VDD \10\:VDD) resistor r=0.2911 c=0
Rk22 (\5\:VDD \12\:VDD) resistor r=0.2157 c=0
Rk6 (\4\:ison \5\:ison) resistor r=0.3639 c=0
Rk7 (\5\:ison \7\:ison) resistor r=0.322 c=0
Rk8 (\5\:ison \9\:ison) resistor r=0.4231 c=0
Rk9 (\6\:n0 \7\:n0) resistor r=0.4908 c=0
Rk10 (\7\:n0 \9\:n0) resistor r=0.6663 c=0
Rl1 (\1\:ISO \2\:ISO) resistor r=207.409 c=0
Rl3 (\2\:ISO \4\:ISO) resistor r=94.9085 c=0
Rl2 (\2\:ISO \3\:ISO) resistor r=5.1123 c=0
Rl6 (\2\:A \4\:A) resistor r=94.4277 c=0
Rl4 (\1\:A \2\:A) resistor r=204.756 c=0
Rl5 (\2\:A \3\:A) resistor r=1.2666 c=0
Rl7 (ison \2\:ison) resistor r=170.329 c=0
Rl8 (\2\:ison \3\:ison) resistor r=114.56 c=0
Rl9 (n0 \2\:n0) resistor r=45.1626 c=0
Rl11 (\2\:n0 \4\:n0) resistor r=158.537 c=0
Rl10 (\2\:n0 \3\:n0) resistor r=1.2666 c=0
Rz7 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz8 (\7\:VSS \8\:VSS) resistor r=37.5 c=0
Rz3 (\2\:Y \3\:Y) resistor r=37.5 c=0
Rz4 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz5 (\1\:VDD \4\:VDD) resistor r=37.5 c=0
Rz6 (\1\:VDD \6\:VDD) resistor r=25 c=0
Rz1 (\6\:ison \7\:ison) resistor r=75 c=0
Rz2 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry7 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry8 (\1\:VSS \4\:VSS) resistor r=12.4 c=0
Ry3 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry4 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry5 (\9\:VDD \10\:VDD) resistor r=20.6667 c=0
Ry6 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry1 (\8\:ison \9\:ison) resistor r=62 c=0
Ry2 (\5\:n0 \6\:n0) resistor r=62 c=0
Rx1 (\3\:ISO \5\:ISO) resistor r=45 c=0
Rx2 (\3\:A \6\:A) resistor r=45 c=0
Rx3 (\2\:ison \4\:ison) resistor r=45 c=0
Rx4 (\3\:n0 \7\:n0) resistor r=45 c=0
NM1 (\5\:VSS \4\:ISO \6\:ison VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.67224 \
        scb=0.00331168 scc=2.36561e-05 m=(1)
mn1 (\8\:n0 \1\:A net127 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=4.8e-07 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
mn0 (net127 \3\:ison \7\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=8.7e-15 ps=9e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=3.75e-07 sd=160n sca=7.688 \
        scb=0.00504888 scc=6.29443e-05 m=(1)
mn2 (\2\:Y \4\:n0 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=3.64e-14 ps=9e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=3.29615e-07 sb=1.4e-07 sd=160n sca=7.96722 scb=0.00567143 \
        scc=0.000107411 m=(1)
mp0 (\5\:n0 \4\:A \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=5.8e-07 sd=160n sca=11.8775 \
        scb=0.00838325 scc=9.33327e-05 m=(1)
mp1 (\5\:n0 ison \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.44e-14 ps=1.16e-06 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=3.75e-07 sd=160n sca=12.762 \
        scb=0.00989291 scc=0.000101967 m=(1)
mp2 (\4\:Y n0 \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.82564e-07 sb=1.4e-07 sd=160n sca=20.4693 \
        scb=0.0229089 scc=0.000811692 m=(1)
ends ISOLX1_ON
// End of subcircuit definition.

// Generated for: spectre (Mar 22 12:59:14 2012 )
// Library name: gsclib045
// Cell name: ISONLX1_OFF
// View name: extracted

simulator lang=spectre

subckt ISONLX1_OFF A ExtVDD ISOn VDD VSS Y
mp0 (\8\:n0 \3\:A \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=41.5685 \
        scb=0.0460093 scc=0.00460132 m=(1)
C1 (ExtVDD VSS) capacitor c=1.73887e-16
C2 (Y VSS) capacitor c=4.32117e-17
C3 (A VSS) capacitor c=1.71959e-17
C4 (ISOn VSS) capacitor c=3.06945e-17
C5 (VDD VSS) capacitor c=1.4723e-16
C6 (n0 VSS) capacitor c=2.66641e-17
C7 (\3\:n0 VSS) capacitor c=4.47479e-17
C8 (\1\:ISOn VSS) capacitor c=4.75686e-17
C9 (\3\:A VSS) capacitor c=3.74724e-17
C10 (\3\:ISOn VSS) capacitor c=4.99975e-17
C11 (\1\:A VSS) capacitor c=8.15663e-17
C12 (\2\:n0 VSS) capacitor c=2.78276e-17
C13 (\2\:ISOn VSS) capacitor c=6.72352e-17
C14 (\2\:A VSS) capacitor c=6.34029e-17
C15 (\1\:Y VSS) capacitor c=5.69346e-17
C16 (\1\:ExtVDD VSS) capacitor c=5.84952e-17
C17 (\8\:ExtVDD VSS) capacitor c=2.85679e-17
C18 (\8\:n0 VSS) capacitor c=8.71235e-17
C19 (\6\:ExtVDD VSS) capacitor c=5.9046e-17
C20 (\3\:Y VSS) capacitor c=5.67205e-17
C21 (\6\:n0 VSS) capacitor c=5.59222e-17
C22 (VDD VSS) capacitor c=1.61124e-16
C23 (\5\:A VSS) capacitor c=8.23195e-18
C24 (\7\:A VSS) capacitor c=2.05157e-17
C25 (\4\:ISOn VSS) capacitor c=3.8115e-17
C26 (\5\:ExtVDD VSS) capacitor c=9.0917e-17
C27 (\4\:n0 VSS) capacitor c=7.38182e-17
C28 (\5\:n0 VSS) capacitor c=1.25696e-16
Rk8 (ExtVDD ExtVDD) resistor r=0.002415 c=0
Rk7 (\2\:ExtVDD ExtVDD) resistor r=0.4346 c=0
Rk10 (ExtVDD \5\:ExtVDD) resistor r=0.6065 c=0
Rk11 (\5\:ExtVDD \7\:ExtVDD) resistor r=0.4719 c=0
Rk12 (\5\:ExtVDD \9\:ExtVDD) resistor r=0.1755 c=0
Rk16 (Y \2\:Y) resistor r=0.2858 c=0
Rk17 (Y \4\:Y) resistor r=0.3384 c=0
Rk1 (\4\:A A) resistor r=0.002572 c=0
Rk2 (A \5\:A) resistor r=0.002572 c=0
Rk3 (\4\:A \5\:A) resistor r=0.03623 c=0
Rk5 (\5\:A \7\:A) resistor r=0.03357 c=0
Rk4 (\6\:A \7\:A) resistor r=0.002572 c=0
Rk6 (\4\:ISOn ISOn) resistor r=0.02874 c=0
Rk26 (VSS VSS) resistor r=0.02899 c=0
Rk20 (VSS VSS) resistor r=0.02899 c=0
Rk19 (\3\:VSS VSS) resistor r=0.1228 c=0
Rk18 (\2\:VSS \3\:VSS) resistor r=0.4273 c=0
Rk21 (VSS \4\:VSS) resistor r=0.09686 c=0
Rk22 (\4\:VSS \6\:VSS) resistor r=0.2993 c=0
Rk23 (\3\:VSS \8\:VSS) resistor r=0.2251 c=0
Rk25 (\10\:VSS VSS) resistor r=0.5505 c=0
Rk27 (VSS \11\:VSS) resistor r=0.09686 c=0
Rk24 (VDD VDD) resistor r=0.1715 c=0
Rk13 (\4\:n0 \5\:n0) resistor r=0.4396 c=0
Rk14 (\5\:n0 \7\:n0) resistor r=0.4501 c=0
Rk15 (\5\:n0 \9\:n0) resistor r=0.5184 c=0
Rl2 (\2\:A \3\:A) resistor r=82.2343 c=0
Rl1 (\1\:A \2\:A) resistor r=166.442 c=0
Rl3 (\1\:ISOn \2\:ISOn) resistor r=153.404 c=0
Rl4 (\2\:ISOn \3\:ISOn) resistor r=90.6165 c=0
Rl5 (n0 \2\:n0) resistor r=45.3288 c=0
Rl6 (\2\:n0 \3\:n0) resistor r=133.743 c=0
Rz3 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz4 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz5 (\7\:VSS \8\:VSS) resistor r=37.5 c=0
Rz2 (\6\:n0 \7\:n0) resistor r=75 c=0
Ry1 (\1\:ExtVDD \2\:ExtVDD) resistor r=20.6667 c=0
Ry2 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry3 (\8\:ExtVDD \9\:ExtVDD) resistor r=62 c=0
Ry5 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry6 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry7 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry8 (\9\:VSS \10\:VSS) resistor r=31 c=0
Ry9 (\9\:VSS \11\:VSS) resistor r=5.1667 c=0
Ry4 (\8\:n0 \9\:n0) resistor r=62 c=0
Rx1 (\2\:A \6\:A) resistor r=45 c=0
Rx2 (\2\:ISOn \4\:ISOn) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn1 (\6\:n0 \1\:A net127 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn0 (net127 \3\:ISOn \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=10.0732 \
        scb=0.00911402 scc=0.000253284 m=(1)
mn2 (\3\:Y n0 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.1772 scb=0.0118935 \
        scc=0.000630577 m=(1)
mp1 (\8\:n0 \1\:ISOn \8\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=26.6959 \
        scb=0.0279277 scc=0.00203937 m=(1)
mp2 (\1\:Y \3\:n0 \1\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=62.1058 \
        scb=0.0481534 scc=0.00692577 m=(1)
ends ISONLX1_OFF
// End of subcircuit definition.

// Generated for: spectre (May  3 15:27:35 2012 )
// Library name: gsclib045
// Cell name: ISONLX1_ON
// View name: extracted

simulator lang=spectre

subckt ISONLX1_ON A ISOn VDD VSS Y
mp1 (\6\:n0 \4\:ISOn \12\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.44e-14 ad=3.01e-14 ps=7.5e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=18.442 \
        scb=0.0195131 scc=0.00052448 m=(1)
C1 (VDD VSS) capacitor c=8.59345e-17
C2 (Y VSS) capacitor c=1.8098e-17
C3 (n0 VSS) capacitor c=4.68786e-17
C4 (\4\:A VSS) capacitor c=4.07149e-17
C5 (\4\:ISOn VSS) capacitor c=5.56152e-17
C6 (\3\:n0 VSS) capacitor c=2.83168e-17
C7 (\3\:A VSS) capacitor c=6.74632e-17
C8 (\1\:ISOn VSS) capacitor c=6.54775e-17
C9 (\2\:n0 VSS) capacitor c=3.03196e-17
C10 (\1\:A VSS) capacitor c=1.53915e-17
C11 (\3\:ISOn VSS) capacitor c=1.19539e-17
C12 (\4\:Y VSS) capacitor c=3.27176e-17
C13 (\8\:VDD VSS) capacitor c=5.16654e-17
C14 (\10\:VDD VSS) capacitor c=3.09973e-17
C15 (\6\:n0 VSS) capacitor c=7.45083e-17
C16 (\12\:VDD VSS) capacitor c=2.89264e-17
C17 (\1\:VDD VSS) capacitor c=3.29546e-17
C18 (\2\:Y VSS) capacitor c=6.65698e-17
C19 (\8\:n0 VSS) capacitor c=4.25045e-17
C20 (\2\:ISOn VSS) capacitor c=5.61053e-17
C21 (VDD VSS) capacitor c=1.30292e-18
C22 (\2\:A VSS) capacitor c=5.08772e-17
C23 (\5\:ISOn VSS) capacitor c=1.87889e-17
C24 (\6\:ISOn VSS) capacitor c=3.48269e-18
C25 (\7\:ISOn VSS) capacitor c=2.90504e-17
C26 (\5\:A VSS) capacitor c=3.57637e-17
C27 (\7\:A VSS) capacitor c=1.08192e-17
C28 (\8\:A VSS) capacitor c=2.99988e-17
C29 (\4\:n0 VSS) capacitor c=4.28728e-17
C30 (\5\:n0 VSS) capacitor c=1.03755e-16
C31 (\1\:Y VSS) capacitor c=4.24673e-17
C32 (\3\:VDD VSS) capacitor c=1.79024e-18
C33 (\6\:VDD VSS) capacitor c=1.44952e-18
Rk18 (\3\:VDD VDD) resistor r=0.04467 c=0
Rk17 (\2\:VDD \3\:VDD) resistor r=0.09004 c=0
Rk19 (VDD \4\:VDD) resistor r=0.01529 c=0
Rk20 (\4\:VDD VDD) resistor r=0.04998 c=0
Rk21 (VDD \5\:VDD) resistor r=0.101 c=0
Rk22 (\5\:VDD \6\:VDD) resistor r=0.1151 c=0
Rk23 (\6\:VDD \7\:VDD) resistor r=0.0349 c=0
Rk24 (\3\:VDD \9\:VDD) resistor r=0.2979 c=0
Rk25 (VDD \11\:VDD) resistor r=0.2749 c=0
Rk26 (\6\:VDD \13\:VDD) resistor r=0.2211 c=0
Rk1 (ISOn \5\:ISOn) resistor r=0.005145 c=0
Rk2 (ISOn \6\:ISOn) resistor r=0.002205 c=0
Rk3 (\5\:ISOn \6\:ISOn) resistor r=0.01642 c=0
Rk5 (\6\:ISOn \7\:ISOn) resistor r=0.01816 c=0
Rk4 (\7\:ISOn \8\:ISOn) resistor r=0.005145 c=0
Rk14 (Y \1\:Y) resistor r=0.02098 c=0
Rk15 (\1\:Y \3\:Y) resistor r=0.4671 c=0
Rk16 (\1\:Y \5\:Y) resistor r=0.1861 c=0
Rk29 (VSS VSS) resistor r=0.04011 c=0
Rk28 (\3\:VSS VSS) resistor r=0.06974 c=0
Rk27 (\2\:VSS \3\:VSS) resistor r=0.09004 c=0
Rk30 (VSS \4\:VSS) resistor r=0.1005 c=0
Rk31 (\4\:VSS \6\:VSS) resistor r=0.2665 c=0
Rk32 (\3\:VSS \8\:VSS) resistor r=0.2434 c=0
Rk6 (\5\:A \6\:A) resistor r=0.004889 c=0
Rk7 (A \7\:A) resistor r=0.001833 c=0
Rk8 (\5\:A \7\:A) resistor r=0.02582 c=0
Rk9 (A \8\:A) resistor r=0.004889 c=0
Rk10 (\7\:A \8\:A) resistor r=0.02381 c=0
Rk11 (\4\:n0 \5\:n0) resistor r=0.223 c=0
Rk12 (\5\:n0 \7\:n0) resistor r=0.6469 c=0
Rk13 (\5\:n0 \9\:n0) resistor r=0.2085 c=0
Rl3 (\2\:ISOn \4\:ISOn) resistor r=188.659 c=0
Rl1 (\1\:ISOn \2\:ISOn) resistor r=123.156 c=0
Rl2 (\2\:ISOn \3\:ISOn) resistor r=5.1123 c=0
Rl6 (\2\:A \4\:A) resistor r=122.181 c=0
Rl5 (\2\:A \3\:A) resistor r=173.318 c=0
Rl4 (\1\:A \2\:A) resistor r=5.1171 c=0
Rl7 (n0 \2\:n0) resistor r=139.441 c=0
Rl8 (\2\:n0 \3\:n0) resistor r=39.3066 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \4\:VDD) resistor r=75 c=0
Rz5 (\1\:VDD \5\:VDD) resistor r=37.5 c=0
Rz6 (\1\:VDD \7\:VDD) resistor r=75 c=0
Rz2 (\2\:Y \3\:Y) resistor r=37.5 c=0
Rz7 (\5\:VSS \6\:VSS) resistor r=75 c=0
Rz8 (\7\:VSS \8\:VSS) resistor r=37.5 c=0
Rz1 (\8\:n0 \9\:n0) resistor r=75 c=0
Ry3 (\8\:VDD \9\:VDD) resistor r=20.6667 c=0
Ry4 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry5 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry2 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry6 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry7 (\1\:VSS \4\:VSS) resistor r=15.5 c=0
Ry1 (\6\:n0 \7\:n0) resistor r=62 c=0
Rx1 (\3\:ISOn \8\:ISOn) resistor r=45 c=0
Rx2 (\1\:A \6\:A) resistor r=45 c=0
Rx3 (\2\:n0 \4\:n0) resistor r=45 c=0
mn0 (net127 \1\:ISOn \5\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=8.7e-15 ps=5.7e-07 pd=4.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=2.45e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn1 (\8\:n0 \3\:A net127 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=8.7e-15 ad=2.03e-14 ps=4.1e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.45e-07 sb=1.4e-07 sd=160n sca=6.83173 \
        scb=0.00357784 scc=2.82929e-05 m=(1)
mn2 (\2\:Y \3\:n0 \7\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=8.22858 scb=0.00610564 \
        scc=0.00012768 m=(1)
mp0 (\6\:n0 \4\:A \10\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=13.4311 \
        scb=0.0102779 scc=9.59767e-05 m=(1)
mp2 (\4\:Y n0 \8\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=19.5636 \
        scb=0.0214309 scc=0.000678705 m=(1)
ends ISONLX1_ON
// End of subcircuit definition.

// Generated for: spectre (May  3 15:28:25 2012 )
// Library name: gsclib045
// Cell name: LSHLX1_FROM
// View name: extracted

simulator lang=spectre

subckt LSHLX1_FROM A ExtVDD VDD VSS Y
mp0 (\7\:n0 \4\:A \5\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=85.3128 \
        scb=0.0561754 scc=0.010057 m=(1)
C1 (VDD VSS) capacitor c=9.25327e-17
C2 (Y VSS) capacitor c=2.40894e-17
C3 (ExtVDD VSS) capacitor c=1.61358e-16
C4 (A VSS) capacitor c=5.3285e-17
C5 (n0 VSS) capacitor c=2.72016e-17
C6 (\4\:n0 VSS) capacitor c=3.70727e-17
C7 (\4\:A VSS) capacitor c=2.74074e-17
C8 (\1\:A VSS) capacitor c=4.38676e-17
C9 (\3\:n0 VSS) capacitor c=1.34528e-17
C10 (\3\:A VSS) capacitor c=2.20652e-17
C11 (\2\:Y VSS) capacitor c=5.8772e-17
C12 (\1\:ExtVDD VSS) capacitor c=6.58343e-17
C13 (\5\:ExtVDD VSS) capacitor c=3.96505e-17
C14 (\7\:n0 VSS) capacitor c=7.11854e-17
C15 (\4\:Y VSS) capacitor c=3.42486e-17
C16 (\9\:n0 VSS) capacitor c=2.83587e-17
C17 (VDD VSS) capacitor c=1.43981e-16
C18 (\2\:A VSS) capacitor c=3.49094e-17
C19 (\2\:n0 VSS) capacitor c=1.47812e-17
C20 (\5\:n0 VSS) capacitor c=8.91639e-17
C21 (\6\:n0 VSS) capacitor c=9.34949e-17
C22 (\1\:Y VSS) capacitor c=3.66301e-17
Rk20 (VDD VDD) resistor r=0.3206 c=0
Rk14 (\3\:VSS VSS) resistor r=0.1177 c=0
Rk13 (\2\:VSS \3\:VSS) resistor r=0.4603 c=0
Rk15 (VSS \4\:VSS) resistor r=0.04845 c=0
Rk17 (\5\:VSS VSS) resistor r=0.2985 c=0
Rk16 (\4\:VSS \5\:VSS) resistor r=0.1276 c=0
Rk18 (\3\:VSS \7\:VSS) resistor r=0.2373 c=0
Rk19 (\5\:VSS \9\:VSS) resistor r=0.2236 c=0
Rk21 (\11\:VSS VSS) resistor r=0.5783 c=0
Rk23 (\12\:VSS VSS) resistor r=0.4265 c=0
Rk22 (VSS \12\:VSS) resistor r=0.04845 c=0
Rk10 (Y \1\:Y) resistor r=0.05657 c=0
Rk11 (\1\:Y \3\:Y) resistor r=0.3412 c=0
Rk12 (\1\:Y \5\:Y) resistor r=0.1954 c=0
Rk4 (ExtVDD ExtVDD) resistor r=0.002072 c=0
Rk3 (\2\:ExtVDD ExtVDD) resistor r=0.4254 c=0
Rk6 (ExtVDD \6\:ExtVDD) resistor r=0.4221 c=0
Rk7 (\5\:n0 \6\:n0) resistor r=0.575 c=0
Rk8 (\6\:n0 \8\:n0) resistor r=0.4339 c=0
Rk9 (\6\:n0 \10\:n0) resistor r=0.193 c=0
Rl3 (\2\:A \4\:A) resistor r=45.6656 c=0
Rl1 (\1\:A \2\:A) resistor r=206.123 c=0
Rl2 (\2\:A \3\:A) resistor r=83.5428 c=0
Rl4 (n0 \2\:n0) resistor r=67.093 c=0
Rl6 (\2\:n0 \4\:n0) resistor r=131.254 c=0
Rl5 (\2\:n0 \3\:n0) resistor r=3.1183 c=0
Rz4 (\6\:VSS \7\:VSS) resistor r=37.5 c=0
Rz5 (\8\:VSS \9\:VSS) resistor r=75 c=0
Rz3 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz2 (\9\:n0 \10\:n0) resistor r=75 c=0
Ry5 (\1\:VSS \2\:VSS) resistor r=62 c=0
Ry6 (\1\:VSS \4\:VSS) resistor r=5.1667 c=0
Ry7 (\10\:VSS \11\:VSS) resistor r=62 c=0
Ry8 (\10\:VSS \12\:VSS) resistor r=5.1667 c=0
Ry4 (\2\:Y \3\:Y) resistor r=20.6667 c=0
Ry1 (\1\:ExtVDD \2\:ExtVDD) resistor r=20.6667 c=0
Ry2 (\5\:ExtVDD \6\:ExtVDD) resistor r=62 c=0
Ry3 (\7\:n0 \8\:n0) resistor r=62 c=0
Rx1 (\3\:A A) resistor r=45 c=0
Rx2 (\3\:n0 \5\:n0) resistor r=45 c=0
mn0 (\9\:n0 \1\:A \8\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.7118 \
        scb=0.0116498 scc=0.000458536 m=(1)
NM0 (\4\:Y n0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=13.5771 scb=0.0135427 \
        scc=0.000870653 m=(1)
PM0 (\2\:Y \4\:n0 \1\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=54.0408 \
        scb=0.0503169 scc=0.00624446 m=(1)
ends LSHLX1_FROM
// End of subcircuit definition.

// Generated for: spectre (May  3 15:29:14 2012 )
// Library name: gsclib045
// Cell name: LSHLX1_TO
// View name: extracted

simulator lang=spectre

subckt LSHLX1_TO A VDD VSS Y
mp0 (\9\:n0 \4\:A \4\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=21.3061 \
        scb=0.0229136 scc=0.00064882 m=(1)
C1 (VDD VSS) capacitor c=5.9193e-17
C2 (A VSS) capacitor c=8.50588e-17
C3 (Y VSS) capacitor c=1.93597e-17
C4 (n0 VSS) capacitor c=6.10013e-17
C5 (\4\:A VSS) capacitor c=3.7711e-17
C6 (\4\:n0 VSS) capacitor c=3.54221e-17
C7 (\3\:A VSS) capacitor c=4.25535e-17
C8 (\3\:n0 VSS) capacitor c=2.25053e-17
C9 (\1\:A VSS) capacitor c=2.51166e-17
C10 (\4\:Y VSS) capacitor c=6.17067e-17
C11 (\4\:VDD VSS) capacitor c=7.79231e-17
C12 (\9\:n0 VSS) capacitor c=4.43079e-17
C13 (\1\:VDD VSS) capacitor c=2.70819e-17
C14 (\2\:Y VSS) capacitor c=3.32465e-17
C15 (\7\:n0 VSS) capacitor c=2.47205e-17
C16 (\2\:A VSS) capacitor c=3.76276e-17
C17 (\2\:n0 VSS) capacitor c=2.77111e-17
C18 (\5\:n0 VSS) capacitor c=4.97038e-17
C19 (\6\:n0 VSS) capacitor c=6.52399e-17
C20 (\1\:Y VSS) capacitor c=4.75567e-17
Rk9 (VDD VDD) resistor r=0.0153 c=0
Rk8 (\2\:VDD VDD) resistor r=0.1004 c=0
Rk10 (VDD \3\:VDD) resistor r=0.08549 c=0
Rk11 (VDD \5\:VDD) resistor r=0.3691 c=0
Rk13 (VSS VSS) resistor r=0.02533 c=0
Rk12 (\2\:VSS VSS) resistor r=0.1004 c=0
Rk14 (VSS \3\:VSS) resistor r=0.07546 c=0
Rk15 (VSS \5\:VSS) resistor r=0.3057 c=0
Rk5 (Y \1\:Y) resistor r=0.0271 c=0
Rk6 (\1\:Y \3\:Y) resistor r=0.1987 c=0
Rk7 (\1\:Y \5\:Y) resistor r=0.3953 c=0
Rk2 (\5\:n0 \6\:n0) resistor r=0.1999 c=0
Rk3 (\6\:n0 \8\:n0) resistor r=0.171 c=0
Rk4 (\6\:n0 \10\:n0) resistor r=0.4249 c=0
Rl3 (\2\:A \4\:A) resistor r=92.4917 c=0
Rl2 (\2\:A \3\:A) resistor r=126.583 c=0
Rl1 (\1\:A \2\:A) resistor r=2.4834 c=0
Rl4 (n0 \2\:n0) resistor r=132.374 c=0
Rl6 (\2\:n0 \4\:n0) resistor r=38.1316 c=0
Rl5 (\2\:n0 \3\:n0) resistor r=2.4801 c=0
Rz3 (\1\:VDD \2\:VDD) resistor r=37.5 c=0
Rz4 (\1\:VDD \3\:VDD) resistor r=37.5 c=0
Rz5 (\4\:VSS \5\:VSS) resistor r=37.5 c=0
Rz2 (\2\:Y \3\:Y) resistor r=37.5 c=0
Rz1 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry3 (\4\:VDD \5\:VDD) resistor r=20.6667 c=0
Ry4 (\1\:VSS \2\:VSS) resistor r=31 c=0
Ry5 (\1\:VSS \3\:VSS) resistor r=31 c=0
Ry2 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry1 (\9\:n0 \10\:n0) resistor r=62 c=0
Rx1 (\1\:A A) resistor r=45 c=0
Rx2 (\3\:n0 \5\:n0) resistor r=45 c=0
mn0 (\4\:VSS \3\:A \7\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=8.85152 \
        scb=0.00706865 scc=0.000138481 m=(1)
NM0 (\2\:Y \4\:n0 \4\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.365e-14 ps=8e-07 pd=9e-07 nrd=1.16667 nrs=1.16667 \
        sa=2.71058e-07 sb=1.4e-07 sd=160n sca=8.97712 scb=0.00732387 \
        scc=0.000196032 m=(1)
PM0 (\4\:Y n0 \4\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.4e-07 sd=160n sca=22.176 \
        scb=0.0237558 scc=0.000835591 m=(1)
ends LSHLX1_TO
// End of subcircuit definition.

// Generated for: spectre (May  3 15:29:59 2012 )
// Library name: gsclib045
// Cell name: LSHL_ISOH_X1_FROM_OFF
// View name: extracted

simulator lang=spectre

subckt LSHL_ISOH_X1_FROM_OFF A ExtVDD ISO VDD VSS Y
PM1 (\9\:ison \1\:ISO \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=84.9167 \
        scb=0.0555848 scc=0.0100504 m=(1)
C1 (VDD VSS) capacitor c=9.57045e-17
C2 (ExtVDD VSS) capacitor c=8.66072e-17
C3 (ISO VSS) capacitor c=3.82301e-17
C4 (Y VSS) capacitor c=2.3794e-17
C5 (A VSS) capacitor c=4.79012e-17
C6 (ison VSS) capacitor c=7.82698e-17
C7 (gatedVSS VSS) capacitor c=2.26976e-16
C8 (n0 VSS) capacitor c=3.16407e-17
C9 (\4\:n0 VSS) capacitor c=4.74742e-17
C10 (\1\:A VSS) capacitor c=6.13299e-17
C11 (\1\:ISO VSS) capacitor c=8.60095e-17
C12 (\4\:A VSS) capacitor c=3.39208e-17
C13 (\3\:ISO VSS) capacitor c=3.54098e-17
C14 (\3\:n0 VSS) capacitor c=2.53368e-17
C15 (\4\:ison VSS) capacitor c=1.71249e-17
C16 (\3\:A VSS) capacitor c=1.77976e-17
C17 (\2\:ISO VSS) capacitor c=6.8303e-17
C18 (\1\:Y VSS) capacitor c=4.77994e-17
C19 (\1\:ExtVDD VSS) capacitor c=1.66392e-16
C20 (\6\:Y VSS) capacitor c=1.3898e-16
C21 (\9\:n0 VSS) capacitor c=9.90951e-17
C22 (\3\:ExtVDD VSS) capacitor c=1.30141e-16
C23 (\9\:ison VSS) capacitor c=1.13018e-16
C24 (\4\:Y VSS) capacitor c=2.82834e-17
C25 (\7\:gatedVSS VSS) capacitor c=5.54084e-17
C26 (\7\:n0 VSS) capacitor c=1.39016e-16
C27 (\7\:ison VSS) capacitor c=1.53671e-16
C28 (\2\:A VSS) capacitor c=6.58204e-17
C29 (VDD VSS) capacitor c=2.23491e-16
C30 (\2\:ison VSS) capacitor c=1.14989e-16
C31 (\2\:n0 VSS) capacitor c=2.90081e-17
C32 (\5\:ISO VSS) capacitor c=1.64861e-17
C33 (\6\:A VSS) capacitor c=3.39674e-17
C34 (\6\:ison VSS) capacitor c=1.20796e-16
C35 (\6\:ExtVDD VSS) capacitor c=1.28335e-16
C36 (\5\:n0 VSS) capacitor c=5.89621e-17
C37 (\6\:n0 VSS) capacitor c=1.76395e-16
C38 (\3\:Y VSS) capacitor c=6.77032e-17
Rk33 (VDD VDD) resistor r=0.4002 c=0
Rk12 (\4\:ExtVDD ExtVDD) resistor r=0.2723 c=0
Rk11 (\2\:ExtVDD \4\:ExtVDD) resistor r=0.8374 c=0
Rk13 (ExtVDD \6\:ExtVDD) resistor r=0.001554 c=0
Rk14 (\6\:ExtVDD ExtVDD) resistor r=0.001554 c=0
Rk2 (\5\:ISO ISO) resistor r=0.007161 c=0
Rk1 (\4\:ISO \5\:ISO) resistor r=0.00331 c=0
Rk22 (\3\:Y Y) resistor r=0.3129 c=0
Rk21 (\2\:Y \3\:Y) resistor r=0.2076 c=0
Rk23 (Y \5\:Y) resistor r=0.0308 c=0
Rk24 (\3\:Y \7\:Y) resistor r=0.4964 c=0
Rk25 (\2\:VSS VSS) resistor r=0.6351 c=0
Rk28 (\4\:VSS VSS) resistor r=0.4003 c=0
Rk27 (VSS \4\:VSS) resistor r=0.06335 c=0
Rk29 (VSS \5\:VSS) resistor r=0.1345 c=0
Rk30 (\5\:VSS \6\:VSS) resistor r=0.03647 c=0
Rk31 (\4\:VSS \8\:VSS) resistor r=0.2096 c=0
Rk32 (\5\:VSS \10\:VSS) resistor r=0.2969 c=0
Rk34 (\12\:VSS VSS) resistor r=0.5863 c=0
Rk36 (\13\:VSS VSS) resistor r=0.3663 c=0
Rk35 (VSS \13\:VSS) resistor r=0.09799 c=0
Rk6 (\6\:A A) resistor r=0.008156 c=0
Rk5 (\5\:A \6\:A) resistor r=0.004287 c=0
Rk9 (\6\:ison \8\:ison) resistor r=0.6373 c=0
Rk10 (\8\:ison \10\:ison) resistor r=0.9102 c=0
Rk17 (gatedVSS \8\:gatedVSS) resistor r=0.08699 c=0
Rk18 (\5\:n0 \6\:n0) resistor r=0.2548 c=0
Rk19 (\6\:n0 \8\:n0) resistor r=0.7794 c=0
Rk20 (\6\:n0 \10\:n0) resistor r=0.4514 c=0
Rl1 (\1\:ISO \2\:ISO) resistor r=264.957 c=0
Rl2 (\2\:ISO \3\:ISO) resistor r=171.342 c=0
Rl3 (\1\:A \2\:A) resistor r=248.037 c=0
Rl5 (\2\:A \4\:A) resistor r=117.068 c=0
Rl4 (\2\:A \3\:A) resistor r=1.2666 c=0
Rl6 (\2\:ison ison) resistor r=208.445 c=0
Rl8 (\4\:ison \2\:ison) resistor r=77.0076 c=0
Rl10 (n0 \2\:n0) resistor r=78.8553 c=0
Rl12 (\2\:n0 \4\:n0) resistor r=89.0826 c=0
Rl11 (\2\:n0 \3\:n0) resistor r=1.2301 c=0
Rz8 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz9 (\8\:VSS \7\:VSS) resistor r=75 c=0
Rz10 (\10\:VSS \9\:VSS) resistor r=75 c=0
Rz1 (\8\:ison \7\:ison) resistor r=75 c=0
Rz4 (gatedVSS \3\:gatedVSS) resistor r=37.5 c=0
Rz6 (\8\:gatedVSS \7\:gatedVSS) resistor r=75 c=0
Rz7 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry2 (\1\:ExtVDD \2\:ExtVDD) resistor r=20.6667 c=0
Ry3 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry5 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry6 (\6\:Y \7\:Y) resistor r=20.6667 c=0
Ry8 (VSS \1\:VSS) resistor r=5.1667 c=0
Ry7 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry9 (\6\:VSS \1\:VSS) resistor r=62 c=0
Ry10 (\12\:VSS \11\:VSS) resistor r=31 c=0
Ry11 (\13\:VSS \11\:VSS) resistor r=5.1667 c=0
Ry1 (\10\:ison \9\:ison) resistor r=62 c=0
Ry4 (\9\:n0 \10\:n0) resistor r=62 c=0
Rx1 (\2\:ISO \4\:ISO) resistor r=45 c=0
Rx2 (\3\:A \5\:A) resistor r=45 c=0
Rx3 (\6\:ison \4\:ison) resistor r=45 c=0
Rx4 (\3\:n0 \5\:n0) resistor r=45 c=0
NM1 (\7\:ison \3\:ISO \9\:VSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=3.6606 \
        scb=0.000125236 scc=4.16931e-09 m=(1)
mn0 (\7\:n0 \4\:A \7\:gatedVSS VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=5.4629 \
        scb=0.00240631 scc=0.000219187 m=(1)
NM3 (\7\:VSS \2\:ison gatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.64e-14 ps=8.4e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(2)
NM0 (\4\:Y n0 \3\:gatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mp0 (\9\:n0 \1\:A \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=70.353 \
        scb=0.0375991 scc=0.00748848 m=(1)
PM4 (\6\:Y ison \1\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=48.4468 \
        scb=0.0316144 scc=0.0044182 m=(1)
PM0 (\1\:Y \4\:n0 \1\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=63.0104 scb=0.0496 \
        scc=0.00698014 m=(1)
ends LSHL_ISOH_X1_FROM_OFF
// End of subcircuit definition.

// Generated for: spectre (May  3 15:31:01 2012 )
// Library name: gsclib045
// Cell name: LSHL_ISOH_X1_TO_ON
// View name: extracted

simulator lang=spectre

subckt LSHL_ISOH_X1_TO_ON A ISO VDD VSS Y
PM1 (\9\:ison \1\:ISO \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
C1 (VDD VSS) capacitor c=1.72914e-16
C2 (ISO VSS) capacitor c=5.18186e-17
C3 (A VSS) capacitor c=2.97217e-17
C4 (ison VSS) capacitor c=6.73914e-17
C5 (gatedVSS VSS) capacitor c=2.39759e-16
C6 (n0 VSS) capacitor c=5.32411e-17
C7 (\1\:A VSS) capacitor c=5.54774e-17
C8 (\1\:ISO VSS) capacitor c=8.47789e-17
C9 (\4\:n0 VSS) capacitor c=2.68128e-17
C10 (\4\:A VSS) capacitor c=3.41508e-17
C11 (\3\:ISO VSS) capacitor c=3.44895e-17
C12 (\3\:n0 VSS) capacitor c=4.53739e-17
C13 (\4\:ison VSS) capacitor c=1.74764e-17
C14 (\3\:A VSS) capacitor c=1.77336e-17
C15 (\2\:ISO VSS) capacitor c=6.03888e-17
C16 (\6\:Y VSS) capacitor c=5.88867e-17
C17 (\1\:VDD VSS) capacitor c=1.12455e-16
C18 (\4\:Y VSS) capacitor c=1.34245e-16
C19 (\9\:n0 VSS) capacitor c=1.02293e-16
C20 (\5\:VDD VSS) capacitor c=5.57611e-17
C21 (\9\:ison VSS) capacitor c=1.04345e-16
C22 (\1\:Y VSS) capacitor c=4.89906e-17
C23 (\7\:gatedVSS VSS) capacitor c=5.62487e-17
C24 (\7\:n0 VSS) capacitor c=1.30505e-16
C25 (\7\:ison VSS) capacitor c=1.51514e-16
C26 (VDD VSS) capacitor c=3.53193e-17
C27 (\2\:A VSS) capacitor c=6.3675e-17
C28 (\2\:ison VSS) capacitor c=1.13079e-16
C29 (\5\:A VSS) capacitor c=3.65733e-17
C30 (\6\:ison VSS) capacitor c=1.1813e-16
C31 (\5\:n0 VSS) capacitor c=6.28135e-17
C32 (\6\:n0 VSS) capacitor c=1.49366e-16
C33 (\3\:Y VSS) capacitor c=6.72831e-17
Rk23 (VDD VDD) resistor r=0.2687 c=0
Rk20 (\2\:VDD VDD) resistor r=0.6479 c=0
Rk22 (VDD \6\:VDD) resistor r=0.3124 c=0
Rk1 (ISO \4\:ISO) resistor r=0.003448 c=0
Rk16 (\2\:Y \3\:Y) resistor r=0.3039 c=0
Rk17 (\3\:Y \5\:Y) resistor r=0.5546 c=0
Rk19 (\7\:Y Y) resistor r=0.004839 c=0
Rk18 (\3\:Y \7\:Y) resistor r=0.1783 c=0
Rk26 (VSS VSS) resistor r=0.326 c=0
Rk25 (\4\:VSS VSS) resistor r=0.04991 c=0
Rk24 (\2\:VSS \4\:VSS) resistor r=0.2569 c=0
Rk27 (VSS \5\:VSS) resistor r=0.138 c=0
Rk28 (\5\:VSS \6\:VSS) resistor r=0.03742 c=0
Rk29 (\5\:VSS \8\:VSS) resistor r=0.3089 c=0
Rk5 (\5\:A A) resistor r=0.008783 c=0
Rk4 (\5\:A \6\:A) resistor r=0.005175 c=0
Rk8 (\6\:ison \8\:ison) resistor r=0.6624 c=0
Rk9 (\8\:ison \10\:ison) resistor r=0.9061 c=0
Rk12 (gatedVSS \8\:gatedVSS) resistor r=0.09023 c=0
Rk13 (\5\:n0 \6\:n0) resistor r=0.3375 c=0
Rk14 (\6\:n0 \8\:n0) resistor r=0.6842 c=0
Rk15 (\6\:n0 \10\:n0) resistor r=0.531 c=0
Rl1 (\1\:ISO \2\:ISO) resistor r=264.957 c=0
Rl2 (\2\:ISO \3\:ISO) resistor r=171.342 c=0
Rl3 (\1\:A \2\:A) resistor r=248.037 c=0
Rl5 (\2\:A \4\:A) resistor r=117.068 c=0
Rl4 (\2\:A \3\:A) resistor r=1.2666 c=0
Rl6 (\2\:ison ison) resistor r=208.445 c=0
Rl8 (\4\:ison \2\:ison) resistor r=77.0076 c=0
Rl10 (n0 \2\:n0) resistor r=125.556 c=0
Rl12 (\2\:n0 \4\:n0) resistor r=41.9777 c=0
Rl11 (\2\:n0 \3\:n0) resistor r=0.6051 c=0
Rz7 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz9 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz10 (\8\:VSS \7\:VSS) resistor r=75 c=0
Rz1 (\8\:ison \7\:ison) resistor r=75 c=0
Rz3 (gatedVSS \3\:gatedVSS) resistor r=37.5 c=0
Rz5 (\8\:gatedVSS \7\:gatedVSS) resistor r=75 c=0
Rz6 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry6 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry3 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry4 (\6\:Y \7\:Y) resistor r=20.6667 c=0
Ry7 (\4\:VSS \3\:VSS) resistor r=6.2 c=0
Ry8 (\6\:VSS \3\:VSS) resistor r=62 c=0
Ry1 (\10\:ison \9\:ison) resistor r=62 c=0
Ry2 (\9\:n0 \10\:n0) resistor r=62 c=0
Rx1 (\2\:ISO \4\:ISO) resistor r=45 c=0
Rx2 (\3\:A \6\:A) resistor r=45 c=0
Rx3 (\6\:ison \4\:ison) resistor r=45 c=0
Rx4 (\3\:n0 \5\:n0) resistor r=45 c=0
NM1 (\7\:VSS \3\:ISO \7\:ison VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn0 (\7\:gatedVSS \4\:A \7\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
NM3 (gatedVSS \2\:ison \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(2)
NM0 (\1\:Y \4\:n0 \3\:gatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.32128 scb=0.00786794 \
        scc=0.000232361 m=(1)
mp0 (\9\:n0 \1\:A \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
PM4 (\4\:Y ison \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=14.3303 \
        scb=0.0124199 scc=0.00051711 m=(1)
PM0 (\6\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=17.0626 \
        scb=0.016739 scc=0.000580643 m=(1)
ends LSHL_ISOH_X1_TO_ON
// End of subcircuit definition.

// Generated for: spectre (May  3 15:31:49 2012 )
// Library name: gsclib045
// Cell name: LSHL_ISOL_X1_FROM_OFF
// View name: extracted

simulator lang=spectre

subckt LSHL_ISOL_X1_FROM_OFF A ExtVDD ISO VDD VSS Y
PM1 (\9\:ison \1\:ISO \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=84.7214 \
        scb=0.0553128 scc=0.0100481 m=(1)
C1 (Y VSS) capacitor c=4.5268e-17
C2 (VDD VSS) capacitor c=1.02668e-16
C3 (ExtVDD VSS) capacitor c=8.18042e-17
C4 (ISO VSS) capacitor c=5.57712e-17
C5 (A VSS) capacitor c=4.45175e-17
C6 (n0 VSS) capacitor c=3.94972e-17
C7 (ison VSS) capacitor c=6.58594e-17
C8 (GatedVSS VSS) capacitor c=1.7713e-16
C9 (\4\:n0 VSS) capacitor c=4.58089e-17
C10 (\1\:A VSS) capacitor c=6.16855e-17
C11 (\1\:ISO VSS) capacitor c=8.84385e-17
C12 (\4\:A VSS) capacitor c=3.54709e-17
C13 (\4\:ISO VSS) capacitor c=3.96772e-17
C14 (\3\:n0 VSS) capacitor c=4.00355e-17
C15 (\4\:ison VSS) capacitor c=1.73926e-17
C16 (\3\:A VSS) capacitor c=8.39335e-17
C17 (\3\:ISO VSS) capacitor c=1.57201e-17
C18 (\3\:Y VSS) capacitor c=6.32063e-17
C19 (\1\:ExtVDD VSS) capacitor c=1.59951e-16
C20 (\12\:n0 VSS) capacitor c=3.34896e-17
C21 (\10\:n0 VSS) capacitor c=3.62127e-17
C22 (\3\:ExtVDD VSS) capacitor c=1.2867e-16
C23 (\9\:ison VSS) capacitor c=1.43283e-16
C24 (\1\:Y VSS) capacitor c=3.7335e-17
C25 (\5\:GatedVSS VSS) capacitor c=5.43649e-17
C26 (\7\:n0 VSS) capacitor c=1.39343e-16
C27 (\7\:ison VSS) capacitor c=1.38013e-16
C28 (ExtVDD VSS) capacitor c=1.19199e-16
C29 (\2\:ISO VSS) capacitor c=6.02772e-17
C30 (VDD VSS) capacitor c=2.23837e-16
C31 (\2\:ison VSS) capacitor c=1.12646e-16
C32 (\7\:A VSS) capacitor c=2.97603e-17
C33 (\6\:ison VSS) capacitor c=1.19187e-16
C34 (\5\:n0 VSS) capacitor c=4.64728e-17
C35 (\6\:n0 VSS) capacitor c=1.43461e-16
C36 (\9\:n0 VSS) capacitor c=3.11981e-17
Rk22 (\3\:VSS VSS) resistor r=0.1531 c=0
Rk21 (\2\:VSS \3\:VSS) resistor r=0.48 c=0
Rk25 (\5\:VSS VSS) resistor r=0.3993 c=0
Rk24 (VSS \5\:VSS) resistor r=0.06318 c=0
Rk26 (VSS \6\:VSS) resistor r=0.1341 c=0
Rk27 (\6\:VSS \7\:VSS) resistor r=0.03637 c=0
Rk28 (\3\:VSS \9\:VSS) resistor r=0.2567 c=0
Rk29 (\5\:VSS \11\:VSS) resistor r=0.209 c=0
Rk30 (\6\:VSS \13\:VSS) resistor r=0.2961 c=0
Rk32 (\15\:VSS VSS) resistor r=0.5847 c=0
Rk34 (\16\:VSS VSS) resistor r=0.3654 c=0
Rk33 (VSS \16\:VSS) resistor r=0.09774 c=0
Rk19 (\2\:Y Y) resistor r=0.1618 c=0
Rk20 (Y \4\:Y) resistor r=0.3688 c=0
Rk31 (VDD VDD) resistor r=0.3992 c=0
Rk12 (ExtVDD ExtVDD) resistor r=0.00388 c=0
Rk11 (\4\:ExtVDD ExtVDD) resistor r=0.2736 c=0
Rk10 (\2\:ExtVDD \4\:ExtVDD) resistor r=0.8519 c=0
Rk1 (\5\:ISO ISO) resistor r=0.01211 c=0
Rk5 (A \7\:A) resistor r=0.01179 c=0
Rk4 (\6\:A \7\:A) resistor r=0.006737 c=0
Rk14 (\5\:n0 \6\:n0) resistor r=0.242 c=0
Rk15 (\6\:n0 \8\:n0) resistor r=0.8405 c=0
Rk16 (\6\:n0 \9\:n0) resistor r=0.2588 c=0
Rk17 (\9\:n0 \11\:n0) resistor r=0.02663 c=0
Rk18 (\9\:n0 \13\:n0) resistor r=0.03226 c=0
Rk6 (\6\:ison \8\:ison) resistor r=0.6356 c=0
Rk7 (\8\:ison \10\:ison) resistor r=0.8662 c=0
Rk9 (GatedVSS \6\:GatedVSS) resistor r=0.08685 c=0
Rl1 (\1\:ISO \2\:ISO) resistor r=245.671 c=0
Rl3 (\2\:ISO \4\:ISO) resistor r=203.048 c=0
Rl2 (\2\:ISO \3\:ISO) resistor r=21.3506 c=0
Rl4 (\1\:A \2\:A) resistor r=213.712 c=0
Rl6 (\2\:A \4\:A) resistor r=145.474 c=0
Rl5 (\2\:A \3\:A) resistor r=5.8309 c=0
Rl11 (n0 \2\:n0) resistor r=113.624 c=0
Rl13 (\2\:n0 \4\:n0) resistor r=55.4393 c=0
Rl12 (\2\:n0 \3\:n0) resistor r=0.6051 c=0
Rl7 (\2\:ison ison) resistor r=257.877 c=0
Rl9 (\4\:ison \2\:ison) resistor r=77.0076 c=0
Rz8 (\9\:VSS \8\:VSS) resistor r=37.5 c=0
Rz9 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz10 (\13\:VSS \12\:VSS) resistor r=75 c=0
Rz7 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz6 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz1 (\8\:ison \7\:ison) resistor r=75 c=0
Rz4 (\6\:GatedVSS \5\:GatedVSS) resistor r=75 c=0
Ry8 (VSS \1\:VSS) resistor r=5.1667 c=0
Ry7 (\2\:VSS \1\:VSS) resistor r=62 c=0
Ry9 (\7\:VSS \1\:VSS) resistor r=62 c=0
Ry10 (\15\:VSS \14\:VSS) resistor r=31 c=0
Ry11 (\16\:VSS \14\:VSS) resistor r=5.1667 c=0
Ry6 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry2 (\1\:ExtVDD \2\:ExtVDD) resistor r=20.6667 c=0
Ry3 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry4 (\10\:n0 \11\:n0) resistor r=62 c=0
Ry5 (\12\:n0 \13\:n0) resistor r=62 c=0
Ry1 (\10\:ison \9\:ison) resistor r=62 c=0
Rx1 (\3\:ISO \5\:ISO) resistor r=45 c=0
Rx2 (\3\:A \6\:A) resistor r=45 c=0
Rx4 (\3\:n0 \5\:n0) resistor r=45 c=0
Rx3 (\6\:ison \4\:ison) resistor r=45 c=0
NM1 (\12\:VSS \4\:ISO \7\:ison VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=3.6606 \
        scb=0.000125236 scc=4.16931e-09 m=(1)
mn0 (\5\:GatedVSS \4\:A \7\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=5.4629 \
        scb=0.00240631 scc=0.000219187 m=(1)
NM3 (GatedVSS \2\:ison \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(2)
NM0 (\1\:Y n0 \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
mp0 (\10\:n0 \1\:A \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=70.1578 \
        scb=0.0373272 scc=0.00748621 m=(1)
PM2 (\12\:n0 ison \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=69.7507 \
        scb=0.0364058 scc=0.00745349 m=(1)
PM0 (\3\:Y \4\:n0 \1\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.4e-07 sd=160n sca=63.0104 \
        scb=0.0496 scc=0.00698014 m=(1)
ends LSHL_ISOL_X1_FROM_OFF
// End of subcircuit definition.

// Generated for: spectre (May  3 15:32:34 2012 )
// Library name: gsclib045
// Cell name: LSHL_ISOL_X1_TO_ON
// View name: extracted

simulator lang=spectre

subckt LSHL_ISOL_X1_TO_ON A ISO VDD VSS Y
PM2 (\9\:ison \1\:ISO \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
C1 (VDD VSS) capacitor c=1.53776e-16
C2 (ISO VSS) capacitor c=4.87202e-17
C3 (Y VSS) capacitor c=7.14055e-17
C4 (ison VSS) capacitor c=6.08964e-17
C5 (GatedVSS VSS) capacitor c=1.72185e-16
C6 (n0 VSS) capacitor c=5.47254e-17
C7 (\1\:A VSS) capacitor c=5.43107e-17
C8 (\1\:ISO VSS) capacitor c=1.01161e-16
C9 (\4\:n0 VSS) capacitor c=2.88079e-17
C10 (\4\:A VSS) capacitor c=3.23319e-17
C11 (\3\:ISO VSS) capacitor c=1.85264e-17
C12 (\3\:n0 VSS) capacitor c=4.06897e-17
C13 (\4\:ison VSS) capacitor c=1.76505e-17
C14 (\3\:A VSS) capacitor c=1.78489e-17
C15 (\2\:ISO VSS) capacitor c=6.16594e-17
C16 (\1\:Y VSS) capacitor c=3.26923e-17
C17 (\1\:VDD VSS) capacitor c=1.01143e-16
C18 (\12\:n0 VSS) capacitor c=2.97773e-17
C19 (\10\:n0 VSS) capacitor c=3.05082e-17
C20 (\5\:VDD VSS) capacitor c=5.34486e-17
C21 (\9\:ison VSS) capacitor c=9.3037e-17
C22 (\3\:Y VSS) capacitor c=4.19267e-17
C23 (\5\:GatedVSS VSS) capacitor c=5.01309e-17
C24 (\7\:n0 VSS) capacitor c=1.26768e-16
C25 (\7\:ison VSS) capacitor c=1.69077e-16
C26 (VDD VSS) capacitor c=3.8461e-17
C27 (\2\:A VSS) capacitor c=6.54861e-17
C28 (\2\:ison VSS) capacitor c=1.08081e-16
C29 (\4\:ISO VSS) capacitor c=1.06919e-17
C30 (\6\:A VSS) capacitor c=3.40825e-17
C31 (\7\:A VSS) capacitor c=4.17168e-18
C32 (\8\:A VSS) capacitor c=3.18532e-17
C33 (\6\:ison VSS) capacitor c=1.17866e-16
C34 (\5\:n0 VSS) capacitor c=4.29988e-17
C35 (\6\:n0 VSS) capacitor c=1.06556e-16
C36 (\9\:n0 VSS) capacitor c=2.81146e-17
Rk25 (VDD VDD) resistor r=0.2685 c=0
Rk22 (\2\:VDD VDD) resistor r=0.6358 c=0
Rk24 (VDD \6\:VDD) resistor r=0.3106 c=0
Rk2 (\4\:ISO ISO) resistor r=0.01055 c=0
Rk1 (\4\:ISO \5\:ISO) resistor r=0.007408 c=0
Rk20 (\2\:Y Y) resistor r=0.1256 c=0
Rk21 (Y \4\:Y) resistor r=0.4017 c=0
Rk29 (VSS VSS) resistor r=0.3258 c=0
Rk26 (\2\:VSS \3\:VSS) resistor r=0.4913 c=0
Rk28 (\5\:VSS VSS) resistor r=0.04987 c=0
Rk27 (\3\:VSS \5\:VSS) resistor r=0.03489 c=0
Rk30 (VSS \6\:VSS) resistor r=0.1379 c=0
Rk31 (\6\:VSS \7\:VSS) resistor r=0.0374 c=0
Rk32 (\3\:VSS \9\:VSS) resistor r=0.2169 c=0
Rk33 (\6\:VSS \11\:VSS) resistor r=0.3071 c=0
Rk5 (A \5\:A) resistor r=0.008776 c=0
Rk6 (\6\:A \5\:A) resistor r=0.004301 c=0
Rk7 (A \7\:A) resistor r=0.002581 c=0
Rk8 (\6\:A \7\:A) resistor r=0.008776 c=0
Rk9 (A \8\:A) resistor r=0.004301 c=0
Rk10 (\7\:A \8\:A) resistor r=0.008562 c=0
Rk11 (\6\:ison \8\:ison) resistor r=0.6586 c=0
Rk12 (\8\:ison \10\:ison) resistor r=0.8928 c=0
Rk14 (GatedVSS \6\:GatedVSS) resistor r=0.08877 c=0
Rk15 (\5\:n0 \6\:n0) resistor r=0.2858 c=0
Rk16 (\6\:n0 \8\:n0) resistor r=0.7154 c=0
Rk17 (\6\:n0 \9\:n0) resistor r=0.3668 c=0
Rk18 (\9\:n0 \11\:n0) resistor r=0.0272 c=0
Rk19 (\9\:n0 \13\:n0) resistor r=0.03295 c=0
Rl1 (\1\:ISO \2\:ISO) resistor r=377.693 c=0
Rl2 (\2\:ISO \3\:ISO) resistor r=48.5227 c=0
Rl3 (\1\:A \2\:A) resistor r=248.037 c=0
Rl5 (\2\:A \4\:A) resistor r=117.068 c=0
Rl4 (\2\:A \3\:A) resistor r=1.2666 c=0
Rl6 (\2\:ison ison) resistor r=257.877 c=0
Rl8 (\4\:ison \2\:ison) resistor r=77.0076 c=0
Rl10 (n0 \2\:n0) resistor r=120.442 c=0
Rl12 (\2\:n0 \4\:n0) resistor r=47.7469 c=0
Rl11 (\2\:n0 \3\:n0) resistor r=0.6051 c=0
Rz6 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz8 (\2\:VSS \1\:VSS) resistor r=37.5 c=0
Rz9 (\9\:VSS \8\:VSS) resistor r=75 c=0
Rz10 (\11\:VSS \10\:VSS) resistor r=75 c=0
Rz1 (\8\:ison \7\:ison) resistor r=75 c=0
Rz4 (\6\:GatedVSS \5\:GatedVSS) resistor r=75 c=0
Rz5 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry5 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry6 (\5\:VDD \6\:VDD) resistor r=62 c=0
Ry4 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry7 (\5\:VSS \4\:VSS) resistor r=6.2 c=0
Ry8 (\7\:VSS \4\:VSS) resistor r=62 c=0
Ry1 (\10\:ison \9\:ison) resistor r=62 c=0
Ry2 (\10\:n0 \11\:n0) resistor r=62 c=0
Ry3 (\12\:n0 \13\:n0) resistor r=62 c=0
Rx1 (\2\:ISO \5\:ISO) resistor r=45 c=0
Rx2 (\3\:A \5\:A) resistor r=45 c=0
Rx3 (\6\:ison \4\:ison) resistor r=45 c=0
Rx4 (\3\:n0 \5\:n0) resistor r=45 c=0
NM1 (\10\:VSS \3\:ISO \7\:ison VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
mn0 (\5\:GatedVSS \4\:A \7\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
NM3 (GatedVSS \2\:ison \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(2)
NM0 (\3\:Y \4\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.32128 scb=0.00786794 \
        scc=0.000232361 m=(1)
mp0 (\10\:n0 \1\:A \5\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.44e-14 ps=7.1e-07 pd=7.5e-07 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=10.1453 \
        scb=0.00734814 scc=7.36798e-05 m=(1)
PM1 (\12\:n0 ison \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=11.3694 \
        scb=0.00808912 scc=7.45876e-05 m=(1)
PM0 (\1\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.4e-07 sd=160n sca=17.0626 \
        scb=0.016739 scc=0.000580643 m=(1)
ends LSHL_ISOL_X1_TO_ON
// End of subcircuit definition.

// Generated for: spectre (Mar 22 13:06:05 2012 )
// Library name: gsclib045
// Cell name: LSHL_ISONH_X1_FROM_OFF
// View name: extracted

simulator lang=spectre

subckt LSHL_ISONH_X1_FROM_OFF A ExtVDD ISOn VDD VSS Y
mp0 (\9\:n0 \1\:A \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=70.353 scb=0.0375991 \
        scc=0.00748848 m=(1)
C1 (Y VSS) capacitor c=2.37448e-17
C2 (ExtVDD VSS) capacitor c=7.85451e-17
C3 (A VSS) capacitor c=4.25173e-17
C4 (ISOn VSS) capacitor c=9.20809e-17
C5 (VDD VSS) capacitor c=8.12678e-17
C6 (gatedVSS VSS) capacitor c=2.41625e-16
C7 (n0 VSS) capacitor c=2.70969e-17
C8 (\4\:n0 VSS) capacitor c=5.82264e-17
C9 (\1\:ISOn VSS) capacitor c=4.93513e-17
C10 (\1\:A VSS) capacitor c=5.13483e-17
C11 (\4\:A VSS) capacitor c=3.21812e-17
C12 (\3\:n0 VSS) capacitor c=4.6516e-17
C13 (\2\:ISOn VSS) capacitor c=6.17023e-17
C14 (\3\:A VSS) capacitor c=1.29944e-17
C15 (\6\:Y VSS) capacitor c=4.86617e-17
C16 (\1\:ExtVDD VSS) capacitor c=1.65343e-16
C17 (\2\:Y VSS) capacitor c=1.49886e-16
C18 (\9\:n0 VSS) capacitor c=1.16186e-16
C19 (\3\:ExtVDD VSS) capacitor c=9.98846e-17
C20 (\4\:Y VSS) capacitor c=5.96094e-17
C21 (\7\:gatedVSS VSS) capacitor c=4.54351e-17
C22 (\7\:n0 VSS) capacitor c=8.46615e-17
C23 (ExtVDD VSS) capacitor c=8.61074e-17
C24 (\2\:A VSS) capacitor c=4.09949e-17
C25 (VDD VSS) capacitor c=2.23493e-16
C26 (\3\:ISOn VSS) capacitor c=8.64432e-17
C27 (\5\:n0 VSS) capacitor c=7.23896e-17
C28 (\6\:n0 VSS) capacitor c=1.88257e-16
C29 (\1\:Y VSS) capacitor c=4.33755e-17
Rk14 (Y \1\:Y) resistor r=0.04858 c=0
Rk15 (\1\:Y \3\:Y) resistor r=0.5102 c=0
Rk16 (Y \5\:Y) resistor r=0.3376 c=0
Rk17 (\1\:Y \7\:Y) resistor r=0.2186 c=0
Rk6 (ExtVDD ExtVDD) resistor r=0.001734 c=0
Rk5 (\4\:ExtVDD ExtVDD) resistor r=0.2699 c=0
Rk4 (\2\:ExtVDD \4\:ExtVDD) resistor r=0.8305 c=0
Rk18 (\2\:VSS VSS) resistor r=0.5817 c=0
Rk19 (VSS \3\:VSS) resistor r=0.0631 c=0
Rk21 (\4\:VSS VSS) resistor r=0.3635 c=0
Rk20 (\3\:VSS \4\:VSS) resistor r=0.03376 c=0
Rk22 (\3\:VSS \6\:VSS) resistor r=0.1786 c=0
Rk24 (\8\:VSS VSS) resistor r=0.5817 c=0
Rk26 (\9\:VSS VSS) resistor r=0.3635 c=0
Rk25 (VSS \9\:VSS) resistor r=0.09723 c=0
Rk3 (\6\:ISOn ISOn) resistor r=0.008599 c=0
Rk23 (VDD VDD) resistor r=0.3971 c=0
Rk10 (gatedVSS \8\:gatedVSS) resistor r=0.08655 c=0
Rk11 (\5\:n0 \6\:n0) resistor r=0.3065 c=0
Rk12 (\6\:n0 \8\:n0) resistor r=0.6671 c=0
Rk13 (\6\:n0 \10\:n0) resistor r=0.5355 c=0
Rl1 (\1\:A \2\:A) resistor r=248.037 c=0
Rl3 (\2\:A \4\:A) resistor r=132.409 c=0
Rl2 (\2\:A \3\:A) resistor r=1.2666 c=0
Rl4 (\2\:ISOn \1\:ISOn) resistor r=77.4365 c=0
Rl5 (\3\:ISOn \2\:ISOn) resistor r=130.132 c=0
Rl8 (n0 \2\:n0) resistor r=37.3411 c=0
Rl10 (\2\:n0 \4\:n0) resistor r=147.373 c=0
Rl9 (\2\:n0 \3\:n0) resistor r=1.263 c=0
Rz7 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz8 (\6\:VSS \5\:VSS) resistor r=75 c=0
Rz3 (gatedVSS \3\:gatedVSS) resistor r=37.5 c=0
Rz5 (\8\:gatedVSS \7\:gatedVSS) resistor r=75 c=0
Rz6 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry4 (\2\:Y \3\:Y) resistor r=20.6667 c=0
Ry5 (\6\:Y \7\:Y) resistor r=20.6667 c=0
Ry1 (\1\:ExtVDD \2\:ExtVDD) resistor r=20.6667 c=0
Ry2 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry6 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry7 (\4\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry8 (\8\:VSS \7\:VSS) resistor r=31 c=0
Ry9 (\9\:VSS \7\:VSS) resistor r=5.1667 c=0
Ry3 (\9\:n0 \10\:n0) resistor r=62 c=0
Rx1 (\3\:A A) resistor r=45 c=0
Rx2 (\6\:ISOn \2\:ISOn) resistor r=45 c=0
Rx3 (\3\:n0 \5\:n0) resistor r=45 c=0
mn0 (\7\:gatedVSS \4\:A \7\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=4.89823 \
        scb=0.00185688 scc=0.000107217 m=(1)
NM3 (gatedVSS \3\:ISOn \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(2)
NM0 (\4\:Y n0 \3\:gatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
PM4 (\2\:Y \1\:ISOn \1\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=48.4468 \
        scb=0.0316144 scc=0.0044182 m=(1)
PM0 (\6\:Y \4\:n0 \1\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=63.0104 scb=0.0496 \
        scc=0.00698014 m=(1)
ends LSHL_ISONH_X1_FROM_OFF
// End of subcircuit definition.

// Generated for: spectre (Mar 22 13:06:57 2012 )
// Library name: gsclib045
// Cell name: LSHL_ISONH_X1_TO_ON
// View name: extracted

simulator lang=spectre

subckt LSHL_ISONH_X1_TO_ON A ISOn VDD VSS Y
mp0 (\9\:n0 \1\:A \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.5181 \
        scb=0.00745996 scc=7.37045e-05 m=(1)
C1 (Y VSS) capacitor c=1.90321e-17
C2 (A VSS) capacitor c=1.57671e-17
C3 (VDD VSS) capacitor c=1.27769e-16
C4 (ISOn VSS) capacitor c=2.87133e-17
C5 (gatedVSS VSS) capacitor c=2.0419e-16
C6 (n0 VSS) capacitor c=5.15294e-17
C7 (\1\:ISOn VSS) capacitor c=6.08015e-17
C8 (\1\:A VSS) capacitor c=5.32788e-17
C9 (\4\:n0 VSS) capacitor c=2.80393e-17
C10 (\4\:A VSS) capacitor c=3.90298e-17
C11 (\3\:n0 VSS) capacitor c=3.2402e-17
C12 (\3\:A VSS) capacitor c=4.64144e-17
C13 (\6\:Y VSS) capacitor c=4.68822e-17
C14 (\1\:VDD VSS) capacitor c=1.01937e-16
C15 (\2\:Y VSS) capacitor c=1.25769e-16
C16 (\9\:n0 VSS) capacitor c=9.89208e-17
C17 (\6\:VDD VSS) capacitor c=3.50393e-17
C18 (\4\:Y VSS) capacitor c=5.17808e-17
C19 (\7\:gatedVSS VSS) capacitor c=3.81036e-17
C20 (\7\:n0 VSS) capacitor c=6.66908e-17
C21 (VDD VSS) capacitor c=2.72315e-17
C22 (\2\:ISOn VSS) capacitor c=1.28714e-16
C23 (\6\:A VSS) capacitor c=5.76994e-18
C24 (\8\:A VSS) capacitor c=9.40856e-18
C25 (\6\:ISOn VSS) capacitor c=2.68329e-17
C26 (\5\:n0 VSS) capacitor c=5.70172e-17
C27 (\6\:n0 VSS) capacitor c=1.4735e-16
C28 (\1\:Y VSS) capacitor c=3.65283e-17
C29 (\5\:VDD VSS) capacitor c=3.02533e-18
Rk13 (Y \1\:Y) resistor r=0.05047 c=0
Rk14 (\1\:Y \3\:Y) resistor r=0.5068 c=0
Rk15 (Y \5\:Y) resistor r=0.3148 c=0
Rk16 (\1\:Y \7\:Y) resistor r=0.2272 c=0
Rk24 (VSS VSS) resistor r=0.1751 c=0
Rk22 (\2\:VSS VSS) resistor r=0.2983 c=0
Rk1 (\5\:A A) resistor r=0.0022 c=0
Rk2 (A \6\:A) resistor r=0.0022 c=0
Rk3 (\5\:A \6\:A) resistor r=0.03643 c=0
Rk5 (\6\:A \8\:A) resistor r=0.02537 c=0
Rk4 (\7\:A \8\:A) resistor r=0.0022 c=0
Rk17 (\2\:VDD VDD) resistor r=0.5644 c=0
Rk20 (\5\:VDD VDD) resistor r=0.01959 c=0
Rk19 (VDD \5\:VDD) resistor r=0.09748 c=0
Rk21 (\5\:VDD \7\:VDD) resistor r=0.2536 c=0
Rk6 (\6\:ISOn ISOn) resistor r=0.02942 c=0
Rk9 (gatedVSS \8\:gatedVSS) resistor r=0.08868 c=0
Rk10 (\5\:n0 \6\:n0) resistor r=0.3065 c=0
Rk11 (\6\:n0 \8\:n0) resistor r=0.7115 c=0
Rk12 (\6\:n0 \10\:n0) resistor r=0.4982 c=0
Rl1 (\1\:A \2\:A) resistor r=191.323 c=0
Rl3 (\2\:A \4\:A) resistor r=167.633 c=0
Rl2 (\2\:A \3\:A) resistor r=5.8309 c=0
Rl4 (\2\:ISOn \1\:ISOn) resistor r=119.395 c=0
Rl8 (n0 \2\:n0) resistor r=120.442 c=0
Rl10 (\2\:n0 \4\:n0) resistor r=47.7469 c=0
Rl9 (\2\:n0 \3\:n0) resistor r=0.6051 c=0
Rz6 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz8 (\2\:VSS \1\:VSS) resistor r=75 c=0
Rz2 (gatedVSS \3\:gatedVSS) resistor r=37.5 c=0
Rz4 (\8\:gatedVSS \7\:gatedVSS) resistor r=75 c=0
Rz5 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry2 (\2\:Y \3\:Y) resistor r=20.6667 c=0
Ry3 (\6\:Y \7\:Y) resistor r=20.6667 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry1 (\9\:n0 \10\:n0) resistor r=62 c=0
Rx1 (\3\:A \7\:A) resistor r=45 c=0
Rx2 (\6\:ISOn \2\:ISOn) resistor r=45 c=0
Rx3 (\3\:n0 \5\:n0) resistor r=45 c=0
mn0 (\7\:gatedVSS \4\:A \7\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
NM3 (gatedVSS \2\:ISOn \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(2)
NM0 (\4\:Y \4\:n0 \3\:gatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.32128 scb=0.00786794 \
        scc=0.000232361 m=(1)
PM4 (\2\:Y \1\:ISOn \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=6.24e-14 ad=5.46e-14 ps=1.1e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=14.6556 \
        scb=0.0128209 scc=0.000518831 m=(1)
PM0 (\6\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.24e-14 ps=1.06e-06 pd=1.1e-06 nrd=1.16667 \
        nrs=1.16667 sa=3.45e-07 sb=1.4e-07 sd=160n sca=18.1342 \
        scb=0.0186365 scc=0.000647246 m=(1)
ends LSHL_ISONH_X1_TO_ON
// End of subcircuit definition.

// Generated for: spectre (Mar 22 13:07:51 2012 )
// Library name: gsclib045
// Cell name: LSHL_ISONL_X1_FROM_OFF
// View name: extracted

simulator lang=spectre

subckt LSHL_ISONL_X1_FROM_OFF A ExtVDD ISOn VDD VSS Y
mp0 (\10\:n0 \1\:A \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=70.353 scb=0.0375991 \
        scc=0.00748848 m=(1)
C1 (Y VSS) capacitor c=3.58416e-17
C2 (ExtVDD VSS) capacitor c=7.36133e-17
C3 (A VSS) capacitor c=5.25088e-17
C4 (ISOn VSS) capacitor c=4.41741e-17
C5 (VDD VSS) capacitor c=8.20895e-17
C6 (n0 VSS) capacitor c=2.9188e-17
C7 (GatedVSS VSS) capacitor c=1.64382e-16
C8 (\4\:n0 VSS) capacitor c=5.51758e-17
C9 (\1\:ISOn VSS) capacitor c=4.33431e-17
C10 (\1\:A VSS) capacitor c=5.27918e-17
C11 (\4\:A VSS) capacitor c=3.06291e-17
C12 (\3\:n0 VSS) capacitor c=4.44192e-17
C13 (\2\:ISOn VSS) capacitor c=5.7524e-17
C14 (\3\:A VSS) capacitor c=1.31305e-17
C15 (\1\:Y VSS) capacitor c=5.50717e-17
C16 (\1\:ExtVDD VSS) capacitor c=1.58063e-16
C17 (\12\:n0 VSS) capacitor c=3.80457e-17
C18 (\10\:n0 VSS) capacitor c=3.60557e-17
C19 (\3\:ExtVDD VSS) capacitor c=9.98599e-17
C20 (\3\:Y VSS) capacitor c=5.5243e-17
C21 (\5\:GatedVSS VSS) capacitor c=3.88542e-17
C22 (\7\:n0 VSS) capacitor c=8.90561e-17
C23 (ExtVDD VSS) capacitor c=1.0238e-16
C24 (\2\:A VSS) capacitor c=4.04993e-17
C25 (VDD VSS) capacitor c=2.23543e-16
C26 (\3\:ISOn VSS) capacitor c=8.82105e-17
C27 (\7\:ISOn VSS) capacitor c=2.06639e-17
C28 (\5\:n0 VSS) capacitor c=5.68939e-17
C29 (\6\:n0 VSS) capacitor c=1.77273e-16
C30 (\9\:n0 VSS) capacitor c=4.23117e-17
Rk21 (\3\:VSS VSS) resistor r=0.1521 c=0
Rk20 (\2\:VSS \3\:VSS) resistor r=0.4284 c=0
Rk22 (VSS \4\:VSS) resistor r=0.06302 c=0
Rk24 (\5\:VSS VSS) resistor r=0.363 c=0
Rk23 (\4\:VSS \5\:VSS) resistor r=0.03371 c=0
Rk25 (\3\:VSS \7\:VSS) resistor r=0.2549 c=0
Rk26 (\4\:VSS \9\:VSS) resistor r=0.207 c=0
Rk28 (\11\:VSS VSS) resistor r=0.581 c=0
Rk30 (\12\:VSS VSS) resistor r=0.363 c=0
Rk29 (VSS \12\:VSS) resistor r=0.09711 c=0
Rk18 (Y \2\:Y) resistor r=0.2462 c=0
Rk19 (Y \4\:Y) resistor r=0.3025 c=0
Rk11 (ExtVDD ExtVDD) resistor r=0.001733 c=0
Rk10 (\4\:ExtVDD ExtVDD) resistor r=0.2675 c=0
Rk9 (\2\:ExtVDD \4\:ExtVDD) resistor r=0.8462 c=0
Rk6 (\6\:ISOn ISOn) resistor r=0.002491 c=0
Rk8 (\6\:ISOn \7\:ISOn) resistor r=0.01792 c=0
Rk7 (\7\:ISOn \8\:ISOn) resistor r=0.004982 c=0
Rk27 (VDD VDD) resistor r=0.3966 c=0
Rk13 (\5\:n0 \6\:n0) resistor r=0.2867 c=0
Rk14 (\6\:n0 \8\:n0) resistor r=0.7017 c=0
Rk15 (\6\:n0 \9\:n0) resistor r=0.3698 c=0
Rk16 (\9\:n0 \11\:n0) resistor r=0.02654 c=0
Rk17 (\9\:n0 \13\:n0) resistor r=0.03215 c=0
Rk4 (GatedVSS \6\:GatedVSS) resistor r=0.08648 c=0
Rl1 (\1\:A \2\:A) resistor r=248.037 c=0
Rl3 (\2\:A \4\:A) resistor r=117.068 c=0
Rl2 (\2\:A \3\:A) resistor r=1.2666 c=0
Rl4 (\2\:ISOn \1\:ISOn) resistor r=104.766 c=0
Rl5 (\3\:ISOn \2\:ISOn) resistor r=135.302 c=0
Rl8 (n0 \2\:n0) resistor r=47.9771 c=0
Rl10 (\2\:n0 \4\:n0) resistor r=120.442 c=0
Rl9 (\2\:n0 \3\:n0) resistor r=0.6051 c=0
Rz7 (\7\:VSS \6\:VSS) resistor r=37.5 c=0
Rz8 (\9\:VSS \8\:VSS) resistor r=75 c=0
Rz6 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz5 (\7\:n0 \8\:n0) resistor r=75 c=0
Rz3 (\6\:GatedVSS \5\:GatedVSS) resistor r=75 c=0
Ry6 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry7 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry8 (\11\:VSS \10\:VSS) resistor r=31 c=0
Ry9 (\12\:VSS \10\:VSS) resistor r=5.1667 c=0
Ry5 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry1 (\1\:ExtVDD \2\:ExtVDD) resistor r=20.6667 c=0
Ry2 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry3 (\10\:n0 \11\:n0) resistor r=62 c=0
Ry4 (\12\:n0 \13\:n0) resistor r=62 c=0
Rx1 (\3\:A A) resistor r=45 c=0
Rx2 (\8\:ISOn \2\:ISOn) resistor r=45 c=0
Rx3 (\3\:n0 \5\:n0) resistor r=45 c=0
mn0 (\5\:GatedVSS \4\:A \7\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=5.4629 \
        scb=0.00240631 scc=0.000219187 m=(1)
NM3 (GatedVSS \3\:ISOn \8\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=15.3338 \
        scb=0.0153436 scc=0.00119435 m=(2)
NM0 (\3\:Y n0 \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.3338 scb=0.0153436 \
        scc=0.00119435 m=(1)
PM2 (\12\:n0 \1\:ISOn \1\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=69.7507 \
        scb=0.0364058 scc=0.00745349 m=(1)
PM0 (\1\:Y \4\:n0 \1\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.4e-07 sd=160n sca=63.0104 \
        scb=0.0496 scc=0.00698014 m=(1)
ends LSHL_ISONL_X1_FROM_OFF
// End of subcircuit definition.

// Generated for: spectre (Mar 22 13:08:45 2012 )
// Library name: gsclib045
// Cell name: LSHL_ISONL_X1_TO_ON
// View name: extracted

simulator lang=spectre

subckt LSHL_ISONL_X1_TO_ON A ISOn VDD VSS Y
mp0 (\11\:n0 \1\:A \6\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.7232 \
        scb=0.00756373 scc=7.3759e-05 m=(1)
C1 (VDD VSS) capacitor c=1.25087e-16
C2 (Y VSS) capacitor c=3.12011e-17
C3 (A VSS) capacitor c=4.65213e-17
C4 (ISOn VSS) capacitor c=2.81423e-17
C5 (GatedVSS VSS) capacitor c=1.60213e-16
C6 (n0 VSS) capacitor c=4.88561e-17
C7 (\1\:ISOn VSS) capacitor c=4.952e-17
C8 (\1\:A VSS) capacitor c=5.18537e-17
C9 (\4\:n0 VSS) capacitor c=2.93421e-17
C10 (\4\:A VSS) capacitor c=3.09982e-17
C11 (\3\:n0 VSS) capacitor c=2.81809e-17
C12 (\3\:A VSS) capacitor c=1.3128e-17
C13 (\3\:Y VSS) capacitor c=5.36282e-17
C14 (\1\:VDD VSS) capacitor c=9.38474e-17
C15 (\9\:n0 VSS) capacitor c=6.04221e-17
C16 (\11\:n0 VSS) capacitor c=4.48402e-17
C17 (\6\:VDD VSS) capacitor c=3.34395e-17
C18 (\1\:Y VSS) capacitor c=5.43057e-17
C19 (\5\:GatedVSS VSS) capacitor c=3.82226e-17
C20 (\7\:n0 VSS) capacitor c=9.15416e-17
C21 (\2\:A VSS) capacitor c=4.22897e-17
C22 (VDD VSS) capacitor c=2.88055e-17
C23 (\2\:ISOn VSS) capacitor c=1.31501e-16
C24 (\7\:ISOn VSS) capacitor c=9.49739e-18
C25 (\9\:ISOn VSS) capacitor c=2.66927e-17
C26 (\5\:n0 VSS) capacitor c=4.21912e-17
C27 (\6\:n0 VSS) capacitor c=1.27769e-16
C28 (\5\:VDD VSS) capacitor c=4.56304e-18
Rk16 (\2\:VDD VDD) resistor r=0.5221 c=0
Rk19 (\5\:VDD VDD) resistor r=0.01952 c=0
Rk18 (VDD \5\:VDD) resistor r=0.1271 c=0
Rk20 (\5\:VDD \7\:VDD) resistor r=0.2521 c=0
Rk14 (Y \2\:Y) resistor r=0.313 c=0
Rk15 (Y \4\:Y) resistor r=0.2548 c=0
Rk23 (VSS VSS) resistor r=0.205 c=0
Rk21 (\2\:VSS VSS) resistor r=0.4632 c=0
Rk24 (VSS \6\:VSS) resistor r=0.2603 c=0
Rk3 (\6\:ISOn ISOn) resistor r=0.002186 c=0
Rk4 (ISOn \7\:ISOn) resistor r=0.002186 c=0
Rk5 (\6\:ISOn \7\:ISOn) resistor r=0.03492 c=0
Rk7 (\7\:ISOn \9\:ISOn) resistor r=0.0454 c=0
Rk6 (\8\:ISOn \9\:ISOn) resistor r=0.002186 c=0
Rk9 (GatedVSS \6\:GatedVSS) resistor r=0.08844 c=0
Rk10 (\5\:n0 \6\:n0) resistor r=0.1995 c=0
Rk11 (\6\:n0 \8\:n0) resistor r=0.8038 c=0
Rk12 (\6\:n0 \10\:n0) resistor r=0.436 c=0
Rk13 (\10\:n0 \12\:n0) resistor r=0.06056 c=0
Rl1 (\1\:A \2\:A) resistor r=245.621 c=0
Rl3 (\2\:A \4\:A) resistor r=117.068 c=0
Rl2 (\2\:A \3\:A) resistor r=1.2666 c=0
Rl4 (\2\:ISOn \1\:ISOn) resistor r=151.871 c=0
Rl8 (n0 \2\:n0) resistor r=120.442 c=0
Rl10 (\2\:n0 \4\:n0) resistor r=47.7469 c=0
Rl9 (\2\:n0 \3\:n0) resistor r=0.6051 c=0
Rz5 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz7 (\2\:VSS \1\:VSS) resistor r=37.5 c=0
Rz8 (\6\:VSS \5\:VSS) resistor r=75 c=0
Rz3 (\6\:GatedVSS \5\:GatedVSS) resistor r=75 c=0
Rz4 (\7\:n0 \8\:n0) resistor r=75 c=0
Ry4 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry5 (\6\:VDD \7\:VDD) resistor r=62 c=0
Ry3 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry1 (\9\:n0 \10\:n0) resistor r=62 c=0
Ry2 (\11\:n0 \12\:n0) resistor r=62 c=0
Rx1 (\3\:A A) resistor r=45 c=0
Rx2 (\8\:ISOn \2\:ISOn) resistor r=45 c=0
Rx3 (\3\:n0 \5\:n0) resistor r=45 c=0
mn0 (\5\:GatedVSS \4\:A \7\:n0 VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.1906 \
        scb=0.0108717 scc=0.000387468 m=(1)
NM3 (GatedVSS \2\:ISOn \5\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=4.16e-14 ps=8e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.45e-07 sd=160n sca=9.32128 \
        scb=0.00786794 scc=0.000232361 m=(2)
NM0 (\1\:Y \4\:n0 \1\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.32128 scb=0.00786794 \
        scc=0.000232361 m=(1)
PM1 (\9\:n0 \1\:ISOn \1\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=6.535e-14 ad=3.01e-14 ps=1.16e-06 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=3.75e-07 sd=160n sca=11.246 \
        scb=0.00796689 scc=7.43059e-05 m=(1)
PM0 (\3\:Y n0 \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=6.535e-14 ps=1.06e-06 pd=1.16e-06 nrd=1.16667 \
        nrs=1.16667 sa=2.69551e-07 sb=1.4e-07 sd=160n sca=16.6283 \
        scb=0.0159718 scc=0.000561163 m=(1)
ends LSHL_ISONL_X1_TO_ON
// End of subcircuit definition.

// Generated for: spectre (May  3 15:33:23 2012 )
// Library name: gsclib045
// Cell name: LSLHX1_FROM
// View name: extracted

simulator lang=spectre

subckt LSLHX1_FROM A ExtVDD VDD VSS Y
PM2 (\9\:Ab \8\:A \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.3577 \
        scb=0.0261982 scc=0.000929898 m=(1)
C1 (ExtVDD VSS) capacitor c=2.56905e-16
C2 (A VSS) capacitor c=4.11587e-17
C3 (Y VSS) capacitor c=7.2355e-17
C4 (VDD VSS) capacitor c=8.19008e-17
C5 (Yint VSS) capacitor c=3.22672e-17
C6 (Ab VSS) capacitor c=1.70767e-16
C7 (Ybint VSS) capacitor c=2.64223e-17
C8 (\6\:Ybint VSS) capacitor c=5.11536e-17
C9 (\4\:Yint VSS) capacitor c=2.54578e-17
C10 (\8\:A VSS) capacitor c=3.98623e-17
C11 (\3\:Ybint VSS) capacitor c=2.61807e-17
C12 (\1\:A VSS) capacitor c=2.28031e-16
C13 (\9\:A VSS) capacitor c=2.96624e-17
C14 (\5\:Ybint VSS) capacitor c=7.15196e-18
C15 (\2\:Ybint VSS) capacitor c=2.41466e-17
C16 (\3\:Yint VSS) capacitor c=2.01013e-17
C17 (\4\:Ab VSS) capacitor c=7.92137e-17
C18 (\5\:A VSS) capacitor c=1.68514e-17
C19 (\3\:Y VSS) capacitor c=3.55117e-17
C20 (\1\:ExtVDD VSS) capacitor c=6.17168e-17
C21 (\4\:ExtVDD VSS) capacitor c=1.17725e-16
C22 (\11\:Yint VSS) capacitor c=6.38643e-17
C23 (\15\:Ybint VSS) capacitor c=8.76534e-17
C24 (\6\:ExtVDD VSS) capacitor c=1.22389e-16
C25 (\9\:Ab VSS) capacitor c=5.3694e-17
C26 (\3\:VDD VSS) capacitor c=3.67148e-17
C27 (\1\:Y VSS) capacitor c=6.28567e-17
C28 (\5\:Yint VSS) capacitor c=1.65008e-16
C29 (\11\:Ab VSS) capacitor c=2.73533e-17
C30 (VDD VSS) capacitor c=2.86772e-16
C31 (\2\:Yint VSS) capacitor c=1.64661e-17
C32 (\4\:A VSS) capacitor c=1.52189e-16
C33 (\4\:Ybint VSS) capacitor c=1.92796e-17
C34 (\11\:A VSS) capacitor c=1.78551e-17
C35 (\7\:Ab VSS) capacitor c=6.6245e-18
C36 (\8\:Ab VSS) capacitor c=5.97011e-17
C37 (\8\:Yint VSS) capacitor c=4.05965e-17
C38 (\13\:Yint VSS) capacitor c=5.47695e-17
C39 (\3\:ExtVDD VSS) capacitor c=1.5466e-17
C40 (\9\:ExtVDD VSS) capacitor c=6.81915e-17
C41 (\7\:Ybint VSS) capacitor c=4.54417e-17
C42 (\8\:Ybint VSS) capacitor c=1.96517e-16
C43 (\10\:Ybint VSS) capacitor c=9.36469e-17
C44 (\2\:VDD VSS) capacitor c=1.29731e-17
Rk18 (ExtVDD ExtVDD) resistor r=0.003781 c=0
Rk13 (\2\:ExtVDD \3\:ExtVDD) resistor r=0.2441 c=0
Rk14 (\3\:ExtVDD \5\:ExtVDD) resistor r=0.2633 c=0
Rk15 (\5\:ExtVDD \7\:ExtVDD) resistor r=0.9774 c=0
Rk17 (\9\:ExtVDD ExtVDD) resistor r=0.001891 c=0
Rk16 (\3\:ExtVDD \9\:ExtVDD) resistor r=0.17 c=0
Rk35 (VSS VSS) resistor r=0.3618 c=0
Rk27 (\2\:VSS \3\:VSS) resistor r=0.09705 c=0
Rk29 (\4\:VSS VSS) resistor r=0.1457 c=0
Rk28 (\3\:VSS \4\:VSS) resistor r=0.1457 c=0
Rk36 (VSS \10\:VSS) resistor r=0.01726 c=0
Rk37 (\10\:VSS \12\:VSS) resistor r=0.4873 c=0
Rk38 (\3\:VSS \14\:VSS) resistor r=0.2239 c=0
Rk45 (\22\:VSS VSS) resistor r=0.5832 c=0
Rk47 (\23\:VSS VSS) resistor r=0.2161 c=0
Rk46 (VSS \23\:VSS) resistor r=0.2434 c=0
Rk1 (A \10\:A) resistor r=0.008124 c=0
Rk3 (\11\:A A) resistor r=0.005152 c=0
Rk2 (\10\:A \11\:A) resistor r=0.004002 c=0
Rk25 (\2\:Y Y) resistor r=0.4142 c=0
Rk26 (Y \4\:Y) resistor r=0.1588 c=0
Rk42 (VDD VDD) resistor r=0.4473 c=0
Rk43 (VDD \2\:VDD) resistor r=0.202 c=0
Rk44 (\2\:VDD \4\:VDD) resistor r=0.3266 c=0
Rk10 (\5\:Yint \8\:Yint) resistor r=0.2597 c=0
Rk12 (\12\:Yint \13\:Yint) resistor r=0.2923 c=0
Rk6 (\7\:Ab \8\:Ab) resistor r=0.04195 c=0
Rk7 (\8\:Ab \10\:Ab) resistor r=0.4612 c=0
Rk8 (\8\:Ab \12\:Ab) resistor r=0.1382 c=0
Rk19 (\7\:Ybint \8\:Ybint) resistor r=0.2668 c=0
Rk21 (\8\:Ybint \10\:Ybint) resistor r=0.1974 c=0
Rk24 (\10\:Ybint \16\:Ybint) resistor r=0.5886 c=0
Rl16 (\4\:A \8\:A) resistor r=163.948 c=0
Rl12 (\4\:A \1\:A) resistor r=621.773 c=0
Rl17 (\4\:A \9\:A) resistor r=83.8346 c=0
Rl13 (\4\:A \5\:A) resistor r=9.0434 c=0
Rl6 (\2\:Yint Yint) resistor r=105.33 c=0
Rl8 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl7 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl3 (Ab \4\:Ab) resistor r=297.331 c=0
Rl9 (\2\:Ybint Ybint) resistor r=72.3229 c=0
Rl20 (\4\:Ybint \6\:Ybint) resistor r=154.48 c=0
Rl18 (\4\:Ybint \3\:Ybint) resistor r=49.0088 c=0
Rl19 (\4\:Ybint \5\:Ybint) resistor r=3.5166 c=0
Rz8 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz9 (\14\:VSS \13\:VSS) resistor r=37.5 c=0
Rz7 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz1 (\12\:Ab \11\:Ab) resistor r=75 c=0
Ry3 (\1\:ExtVDD \2\:ExtVDD) resistor r=20.6667 c=0
Ry4 (\4\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry5 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry11 (VSS \1\:VSS) resistor r=15.5 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry9 (\4\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry12 (\10\:VSS \1\:VSS) resistor r=7.75 c=0
Ry14 (\22\:VSS \21\:VSS) resistor r=12.4 c=0
Ry15 (\23\:VSS \21\:VSS) resistor r=5.1667 c=0
Ry7 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry13 (\3\:VDD \4\:VDD) resistor r=62 c=0
Ry2 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry1 (\10\:Ab \9\:Ab) resistor r=62 c=0
Ry6 (\16\:Ybint \15\:Ybint) resistor r=62 c=0
Rx1 (\10\:A \5\:A) resistor r=45 c=0
Rx3 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx4 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\7\:Ab \4\:Ab) resistor r=45 c=0
Rx5 (\7\:Ybint \5\:Ybint) resistor r=45 c=0
Rx6 (\10\:Ybint \2\:Ybint) resistor r=45 c=0
NM2 (\11\:VSS \9\:A \11\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
NM1 (\5\:Yint Ab VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(3)
NM0 (\8\:Ybint \1\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(3)
mn0 (\1\:Y \3\:Ybint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
PM0 (\15\:Ybint \4\:Yint \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.4693 \
        scb=0.0242319 scc=0.00195457 m=(1)
PM1 (\11\:Yint Ybint \4\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.50531 \
        scb=0.00284023 scc=1.84334e-05 m=(1)
mp0 (\3\:Y \6\:Ybint \1\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.4979 \
        scb=0.0102291 scc=0.000163486 m=(1)
ends LSLHX1_FROM
// End of subcircuit definition.

// Generated for: spectre (May  8 15:10:13 2012 )
// Library name: gsclib045
// Cell name: LSLHX1_TO
// View name: extracted

simulator lang=spectre

subckt LSLHX1_TO A ExtVDD VDD VSS Y
PM2 (\7\:Ab \9\:A \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=21.5924 \
        scb=0.0250741 scc=0.000917806 m=(1)
C1 (VDD VSS) capacitor c=2.75077e-16
C2 (A VSS) capacitor c=2.33738e-17
C3 (ExtVDD VSS) capacitor c=1.3359e-16
C4 (Y VSS) capacitor c=1.73213e-17
C5 (Yint VSS) capacitor c=3.4504e-17
C6 (Ab VSS) capacitor c=1.20532e-16
C7 (Ybint VSS) capacitor c=2.66646e-17
C8 (\6\:Ybint VSS) capacitor c=4.47167e-17
C9 (\4\:Yint VSS) capacitor c=2.69826e-17
C10 (\9\:A VSS) capacitor c=5.76563e-17
C11 (\3\:Ybint VSS) capacitor c=2.72431e-17
C12 (\1\:A VSS) capacitor c=1.75066e-16
C13 (\10\:A VSS) capacitor c=2.5225e-17
C14 (\5\:Ybint VSS) capacitor c=6.04079e-18
C15 (\2\:Ybint VSS) capacitor c=2.84409e-17
C16 (\3\:Yint VSS) capacitor c=2.35231e-17
C17 (\4\:Ab VSS) capacitor c=3.71322e-17
C18 (\6\:A VSS) capacitor c=2.16626e-17
C19 (\2\:Y VSS) capacitor c=5.27718e-17
C20 (\1\:VDD VSS) capacitor c=6.57215e-17
C21 (\7\:VDD VSS) capacitor c=3.45683e-17
C22 (\11\:Yint VSS) capacitor c=6.48165e-17
C23 (\15\:Ybint VSS) capacitor c=8.70394e-17
C24 (\9\:VDD VSS) capacitor c=4.96336e-17
C25 (\7\:Ab VSS) capacitor c=9.92812e-17
C26 (\3\:ExtVDD VSS) capacitor c=3.57642e-17
C27 (\4\:Y VSS) capacitor c=4.34756e-17
C28 (\5\:Yint VSS) capacitor c=1.85011e-16
C29 (\10\:Ab VSS) capacitor c=5.8041e-17
C30 (VDD VSS) capacitor c=1.82136e-17
C31 (\2\:Yint VSS) capacitor c=1.86945e-17
C32 (\4\:A VSS) capacitor c=1.56928e-16
C33 (\5\:A VSS) capacitor c=2.60346e-17
C34 (\4\:Ybint VSS) capacitor c=2.17322e-17
C35 (\11\:A VSS) capacitor c=2.28497e-17
C36 (\9\:Ab VSS) capacitor c=1.18464e-16
C37 (\8\:Yint VSS) capacitor c=4.55377e-17
C38 (\13\:Yint VSS) capacitor c=5.34851e-17
C39 (\7\:Ybint VSS) capacitor c=4.41956e-17
C40 (\8\:Ybint VSS) capacitor c=1.73489e-16
C41 (\10\:Ybint VSS) capacitor c=8.54832e-17
C42 (\1\:Y VSS) capacitor c=4.07916e-17
C43 (\4\:VDD VSS) capacitor c=2.1595e-18
C44 (\5\:VDD VSS) capacitor c=1.41911e-17
C45 (\6\:VDD VSS) capacitor c=2.26207e-17
Rk35 (\2\:VDD \4\:VDD) resistor r=0.4954 c=0
Rk37 (\5\:VDD VDD) resistor r=0.2917 c=0
Rk36 (\4\:VDD \5\:VDD) resistor r=0.124 c=0
Rk39 (\6\:VDD VDD) resistor r=0.3111 c=0
Rk38 (VDD \6\:VDD) resistor r=0.1364 c=0
Rk40 (\5\:VDD \8\:VDD) resistor r=0.2768 c=0
Rk41 (\6\:VDD \10\:VDD) resistor r=0.2768 c=0
Rk28 (VSS VSS) resistor r=0.3623 c=0
Rk20 (\2\:VSS \3\:VSS) resistor r=0.09718 c=0
Rk22 (\4\:VSS VSS) resistor r=0.1459 c=0
Rk21 (\3\:VSS \4\:VSS) resistor r=0.1459 c=0
Rk29 (VSS \10\:VSS) resistor r=0.01728 c=0
Rk30 (\10\:VSS \12\:VSS) resistor r=0.4559 c=0
Rk31 (\3\:VSS \14\:VSS) resistor r=0.2238 c=0
Rk42 (\22\:VSS VSS) resistor r=0.584 c=0
Rk44 (\23\:VSS VSS) resistor r=0.2164 c=0
Rk43 (VSS \23\:VSS) resistor r=0.2437 c=0
Rk1 (A \11\:A) resistor r=0.01817 c=0
Rk3 (\2\:ExtVDD ExtVDD) resistor r=0.02507 c=0
Rk2 (ExtVDD \2\:ExtVDD) resistor r=0.01693 c=0
Rk4 (ExtVDD \4\:ExtVDD) resistor r=0.3343 c=0
Rk17 (Y \1\:Y) resistor r=0.02619 c=0
Rk18 (\1\:Y \3\:Y) resistor r=0.2878 c=0
Rk19 (\1\:Y \5\:Y) resistor r=0.339 c=0
Rk8 (\5\:Yint \8\:Yint) resistor r=0.2601 c=0
Rk10 (\12\:Yint \13\:Yint) resistor r=0.2927 c=0
Rk5 (\8\:Ab \9\:Ab) resistor r=0.8843 c=0
Rk6 (\9\:Ab \11\:Ab) resistor r=0.5142 c=0
Rk11 (\7\:Ybint \8\:Ybint) resistor r=0.2868 c=0
Rk13 (\8\:Ybint \10\:Ybint) resistor r=0.1784 c=0
Rk16 (\10\:Ybint \16\:Ybint) resistor r=0.5894 c=0
Rl17 (\4\:A \9\:A) resistor r=336.831 c=0
Rl12 (\4\:A \1\:A) resistor r=446.755 c=0
Rl18 (\5\:A \10\:A) resistor r=62.4311 c=0
Rl14 (\5\:A \6\:A) resistor r=44.7819 c=0
Rl13 (\5\:A \4\:A) resistor r=240.459 c=0
Rl6 (\2\:Yint Yint) resistor r=105.33 c=0
Rl8 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl7 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl3 (Ab \4\:Ab) resistor r=108.126 c=0
Rl9 (\2\:Ybint Ybint) resistor r=72.3229 c=0
Rl21 (\4\:Ybint \6\:Ybint) resistor r=140.931 c=0
Rl19 (\4\:Ybint \3\:Ybint) resistor r=58.975 c=0
Rl20 (\4\:Ybint \5\:Ybint) resistor r=3.5166 c=0
Rz8 (\12\:VSS \11\:VSS) resistor r=75 c=0
Rz9 (\14\:VSS \13\:VSS) resistor r=37.5 c=0
Rz7 (\4\:Y \5\:Y) resistor r=37.5 c=0
Rz2 (\11\:Ab \10\:Ab) resistor r=75 c=0
Ry11 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry12 (\7\:VDD \8\:VDD) resistor r=62 c=0
Ry13 (\9\:VDD \10\:VDD) resistor r=62 c=0
Ry9 (VSS \1\:VSS) resistor r=15.5 c=0
Ry6 (\2\:VSS \1\:VSS) resistor r=31 c=0
Ry7 (\4\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry10 (\10\:VSS \1\:VSS) resistor r=7.75 c=0
Ry14 (\22\:VSS \21\:VSS) resistor r=12.4 c=0
Ry15 (\23\:VSS \21\:VSS) resistor r=5.1667 c=0
Ry1 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry5 (\2\:Y \3\:Y) resistor r=20.6667 c=0
Ry3 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry2 (\8\:Ab \7\:Ab) resistor r=62 c=0
Ry4 (\16\:Ybint \15\:Ybint) resistor r=62 c=0
Rx1 (\11\:A \6\:A) resistor r=45 c=0
Rx3 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx4 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\9\:Ab \4\:Ab) resistor r=45 c=0
Rx5 (\7\:Ybint \5\:Ybint) resistor r=45 c=0
Rx6 (\10\:Ybint \2\:Ybint) resistor r=45 c=0
NM2 (\11\:VSS \10\:A \10\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=9.16682 \
        scb=0.00760686 scc=0.000164708 m=(1)
NM1 (\5\:Yint Ab VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(3)
NM0 (\8\:Ybint \1\:A VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(3)
mn0 (\4\:Y \3\:Ybint \13\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
PM0 (\15\:Ybint \4\:Yint \9\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.4693 \
        scb=0.0242319 scc=0.00195457 m=(1)
PM1 (\11\:Yint Ybint \7\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.50531 \
        scb=0.00284023 scc=1.84334e-05 m=(1)
mp0 (\2\:Y \6\:Ybint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.8211 \
        scb=0.0185035 scc=0.000835503 m=(1)
ends LSLHX1_TO
// End of subcircuit definition.

// Generated for: spectre (May  3 21:50:58 2012 )
// Library name: gsclib045
// Cell name: LSLH_ISOH_X1_FROM_OFF
// View name: extracted

simulator lang=spectre

subckt LSLH_ISOH_X1_FROM_OFF A ExtVDD ISO VDD VSS Y
PM2 (\9\:Ab \9\:A \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.3577 \
        scb=0.0261982 scc=0.000929898 m=(1)
C1 (Y VSS) capacitor c=3.57445e-17
C2 (ISO VSS) capacitor c=3.84367e-17
C3 (ExtVDD VSS) capacitor c=2.92877e-16
C4 (A VSS) capacitor c=4.11134e-17
C5 (VDD VSS) capacitor c=1.20565e-16
C6 (Yint VSS) capacitor c=3.45698e-17
C7 (Ab VSS) capacitor c=1.65388e-16
C8 (Ybint VSS) capacitor c=3.11581e-17
C9 (GatedVSS VSS) capacitor c=3.45138e-17
C10 (ison VSS) capacitor c=1.21436e-16
C11 (\6\:Ybint VSS) capacitor c=3.67116e-17
C12 (\8\:ison VSS) capacitor c=3.86426e-17
C13 (\1\:ISO VSS) capacitor c=4.19925e-17
C14 (\4\:Yint VSS) capacitor c=2.39409e-17
C15 (\9\:A VSS) capacitor c=3.93413e-17
C16 (\3\:Ybint VSS) capacitor c=2.95989e-17
C17 (\1\:A VSS) capacitor c=2.30376e-16
C18 (\4\:ISO VSS) capacitor c=2.63156e-17
C19 (\10\:A VSS) capacitor c=2.86142e-17
C20 (\5\:Ybint VSS) capacitor c=1.13303e-17
C21 (\1\:Y VSS) capacitor c=3.52058e-17
C22 (\2\:Y VSS) capacitor c=3.56976e-17
C23 (\2\:ExtVDD VSS) capacitor c=1.85472e-17
C24 (\1\:ExtVDD VSS) capacitor c=2.00619e-17
C25 (\2\:Ybint VSS) capacitor c=2.18635e-17
C26 (\12\:ison VSS) capacitor c=3.01791e-17
C27 (\7\:ison VSS) capacitor c=1.99454e-17
C28 (\3\:ISO VSS) capacitor c=1.56073e-17
C29 (\3\:Yint VSS) capacitor c=2.30664e-17
C30 (\2\:GatedVSS VSS) capacitor c=3.12543e-17
C31 (\4\:Ab VSS) capacitor c=7.73733e-17
C32 (\6\:A VSS) capacitor c=1.71946e-17
C33 (\8\:Y VSS) capacitor c=8.75896e-17
C34 (\10\:ExtVDD VSS) capacitor c=7.14611e-17
C35 (\4\:Y VSS) capacitor c=5.81649e-17
C36 (\3\:ExtVDD VSS) capacitor c=6.58076e-17
C37 (\12\:ExtVDD VSS) capacitor c=1.19045e-16
C38 (\11\:Yint VSS) capacitor c=6.32786e-17
C39 (\17\:ison VSS) capacitor c=7.04874e-17
C40 (\12\:Ybint VSS) capacitor c=9.04615e-17
C41 (\6\:ExtVDD VSS) capacitor c=1.18101e-16
C42 (\14\:ExtVDD VSS) capacitor c=1.32146e-16
C43 (\9\:Ab VSS) capacitor c=6.07014e-17
C44 (\3\:VDD VSS) capacitor c=3.74334e-17
C45 (\6\:Y VSS) capacitor c=7.44877e-17
C46 (\9\:GatedVSS VSS) capacitor c=9.93139e-17
C47 (\3\:GatedVSS VSS) capacitor c=3.65991e-16
C48 (\7\:Ybint VSS) capacitor c=2.16924e-16
C49 (\5\:Yint VSS) capacitor c=1.97823e-16
C50 (\14\:ison VSS) capacitor c=3.52448e-17
C51 (\11\:Ab VSS) capacitor c=3.98008e-17
C52 (\15\:GatedVSS VSS) capacitor c=9.94709e-17
C53 (\2\:ISO VSS) capacitor c=3.79544e-17
C54 (\2\:Yint VSS) capacitor c=1.89474e-17
C55 (VDD VSS) capacitor c=4.52391e-16
C56 (\4\:A VSS) capacitor c=1.29536e-16
C57 (\5\:A VSS) capacitor c=2.03136e-17
C58 (\6\:ison VSS) capacitor c=1.72068e-17
C59 (\4\:Ybint VSS) capacitor c=1.55291e-17
C60 (\12\:A VSS) capacitor c=1.99809e-17
C61 (\7\:Ab VSS) capacitor c=1.00133e-17
C62 (\8\:Ab VSS) capacitor c=6.19998e-17
C63 (\5\:ISO VSS) capacitor c=3.76723e-17
C64 (\8\:Yint VSS) capacitor c=3.96066e-17
C65 (\13\:ison VSS) capacitor c=4.30409e-17
C66 (\16\:ison VSS) capacitor c=7.06954e-17
C67 (\13\:Yint VSS) capacitor c=5.46163e-17
C68 (\5\:ExtVDD VSS) capacitor c=1.04763e-16
C69 (\6\:GatedVSS VSS) capacitor c=1.11973e-16
C70 (\3\:Y VSS) capacitor c=5.35243e-17
C71 (\11\:GatedVSS VSS) capacitor c=4.32902e-16
C72 (\14\:GatedVSS VSS) capacitor c=1.65193e-16
C73 (\23\:GatedVSS VSS) capacitor c=7.7721e-17
C74 (\8\:ExtVDD VSS) capacitor c=8.8348e-18
C75 (\9\:ExtVDD VSS) capacitor c=1.44395e-17
C76 (\17\:ExtVDD VSS) capacitor c=7.13957e-17
C77 (\11\:Ybint VSS) capacitor c=9.76604e-17
C78 (\14\:Ybint VSS) capacitor c=5.50099e-17
C79 (\10\:Y VSS) capacitor c=4.61279e-17
C80 (\2\:VDD VSS) capacitor c=1.53298e-17
Rk21 (\3\:Y \5\:Y) resistor r=0.3227 c=0
Rk46 (\9\:Y Y) resistor r=0.01673 c=0
Rk44 (\7\:Y \9\:Y) resistor r=0.5262 c=0
Rk45 (\9\:Y \10\:Y) resistor r=0.2619 c=0
Rk9 (\5\:ISO ISO) resistor r=0.04036 c=0
Rk37 (ExtVDD ExtVDD) resistor r=0.002861 c=0
Rk16 (\4\:ExtVDD \5\:ExtVDD) resistor r=0.3119 c=0
Rk17 (\5\:ExtVDD \7\:ExtVDD) resistor r=0.9376 c=0
Rk31 (\8\:ExtVDD \9\:ExtVDD) resistor r=0.1174 c=0
Rk32 (\9\:ExtVDD \11\:ExtVDD) resistor r=0.3119 c=0
Rk33 (\9\:ExtVDD \13\:ExtVDD) resistor r=0.2247 c=0
Rk34 (\13\:ExtVDD \15\:ExtVDD) resistor r=0.9909 c=0
Rk36 (\17\:ExtVDD ExtVDD) resistor r=0.002861 c=0
Rk35 (\9\:ExtVDD \17\:ExtVDD) resistor r=0.1819 c=0
Rk1 (A \11\:A) resistor r=0.008212 c=0
Rk3 (\12\:A A) resistor r=0.005208 c=0
Rk2 (\11\:A \12\:A) resistor r=0.004045 c=0
Rk62 (VDD VDD) resistor r=0.6016 c=0
Rk63 (VDD \2\:VDD) resistor r=0.2049 c=0
Rk64 (\2\:VDD \4\:VDD) resistor r=0.3311 c=0
Rk54 (VSS VSS) resistor r=0.1479 c=0
Rk53 (VSS VSS) resistor r=0.001 c=0
Rk52 (\3\:VSS VSS) resistor r=0.08092 c=0
Rk47 (\2\:VSS \3\:VSS) resistor r=0.2537 c=0
Rk55 (VSS \8\:VSS) resistor r=0.1135 c=0
Rk57 (\9\:VSS VSS) resistor r=0.1699 c=0
Rk56 (\8\:VSS \9\:VSS) resistor r=0.1822 c=0
Rk61 (\8\:VSS \17\:VSS) resistor r=0.2098 c=0
Rk65 (\19\:VSS VSS) resistor r=0.5915 c=0
Rk67 (\20\:VSS VSS) resistor r=0.1797 c=0
Rk66 (VSS \20\:VSS) resistor r=0.3947 c=0
Rk11 (\5\:Yint \8\:Yint) resistor r=0.2147 c=0
Rk15 (\12\:Yint \13\:Yint) resistor r=0.2964 c=0
Rk6 (\7\:Ab \8\:Ab) resistor r=0.04277 c=0
Rk7 (\8\:Ab \10\:Ab) resistor r=0.4592 c=0
Rk8 (\8\:Ab \12\:Ab) resistor r=0.1596 c=0
Rk40 (\7\:Ybint \11\:Ybint) resistor r=0.1765 c=0
Rk41 (\11\:Ybint \13\:Ybint) resistor r=0.6333 c=0
Rk42 (\7\:Ybint \14\:Ybint) resistor r=0.2894 c=0
Rk19 (\3\:GatedVSS \6\:GatedVSS) resistor r=1.4219 c=0
Rk22 (\10\:GatedVSS \11\:GatedVSS) resistor r=0.5676 c=0
Rk25 (\11\:GatedVSS \14\:GatedVSS) resistor r=0.4737 c=0
Rk26 (\14\:GatedVSS \16\:GatedVSS) resistor r=0.6286 c=0
Rk30 (\14\:GatedVSS \23\:GatedVSS) resistor r=0.7591 c=0
Rk13 (\13\:ison \15\:ison) resistor r=0.2856 c=0
Rk14 (\16\:ison \18\:ison) resistor r=0.4254 c=0
Rl35 (\1\:Y \2\:Y) resistor r=107.339 c=0
Rl2 (\1\:ISO \2\:ISO) resistor r=159.681 c=0
Rl4 (\2\:ISO \4\:ISO) resistor r=86.3858 c=0
Rl3 (\2\:ISO \3\:ISO) resistor r=5.1123 c=0
Rl23 (\1\:ExtVDD \2\:ExtVDD) resistor r=166.126 c=0
Rl21 (\4\:A \9\:A) resistor r=132.549 c=0
Rl16 (\4\:A \1\:A) resistor r=624.028 c=0
Rl22 (\5\:A \10\:A) resistor r=84.6812 c=0
Rl18 (\5\:A \6\:A) resistor r=5.1123 c=0
Rl17 (\5\:A \4\:A) resistor r=29.0517 c=0
Rl10 (\2\:Yint Yint) resistor r=105.33 c=0
Rl12 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl11 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl7 (Ab \4\:Ab) resistor r=297.11 c=0
Rl13 (\2\:Ybint Ybint) resistor r=72.3229 c=0
Rl38 (\4\:Ybint \6\:Ybint) resistor r=93.2039 c=0
Rl36 (\4\:Ybint \3\:Ybint) resistor r=67.6128 c=0
Rl37 (\4\:Ybint \5\:Ybint) resistor r=3.5166 c=0
Rl1 (\2\:GatedVSS GatedVSS) resistor r=169.462 c=0
Rl30 (ison \8\:ison) resistor r=115.053 c=0
Rl28 (\6\:ison ison) resistor r=72.842 c=0
Rl34 (\6\:ison \12\:ison) resistor r=116.573 c=0
Rl29 (\6\:ison \7\:ison) resistor r=51.6001 c=0
Rz15 (\6\:Y \7\:Y) resistor r=37.5 c=0
Rz19 (\17\:VSS \16\:VSS) resistor r=75 c=0
Rz1 (\12\:Ab \11\:Ab) resistor r=75 c=0
Rz7 (\10\:GatedVSS \9\:GatedVSS) resistor r=37.5 c=0
Rz8 (\16\:GatedVSS \15\:GatedVSS) resistor r=75 c=0
Rz4 (\15\:ison \14\:ison) resistor r=75 c=0
Ry6 (\4\:Y \5\:Y) resistor r=20.6667 c=0
Ry11 (\8\:Y \9\:Y) resistor r=20.6667 c=0
Ry4 (\3\:ExtVDD \4\:ExtVDD) resistor r=20.6667 c=0
Ry5 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry7 (\10\:ExtVDD \11\:ExtVDD) resistor r=20.6667 c=0
Ry8 (\12\:ExtVDD \13\:ExtVDD) resistor r=62 c=0
Ry9 (\14\:ExtVDD \15\:ExtVDD) resistor r=62 c=0
Ry16 (\3\:VDD \4\:VDD) resistor r=62 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=12.4 c=0
Ry14 (\3\:VSS \1\:VSS) resistor r=15.5 c=0
Ry15 (\9\:VSS \1\:VSS) resistor r=5.6364 c=0
Ry17 (\19\:VSS \18\:VSS) resistor r=7.75 c=0
Ry18 (\20\:VSS \18\:VSS) resistor r=5.1667 c=0
Ry3 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry1 (\10\:Ab \9\:Ab) resistor r=62 c=0
Ry10 (\13\:Ybint \12\:Ybint) resistor r=62 c=0
Ry2 (\18\:ison \17\:ison) resistor r=62 c=0
Rx10 (\2\:Y \3\:Y) resistor r=45 c=0
Rx15 (\1\:Y \10\:Y) resistor r=45 c=0
Rx3 (\3\:ISO \5\:ISO) resistor r=45 c=0
Rx8 (\1\:ExtVDD \5\:ExtVDD) resistor r=45 c=0
Rx12 (\2\:ExtVDD \8\:ExtVDD) resistor r=45 c=0
Rx1 (\11\:A \6\:A) resistor r=45 c=0
Rx4 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx7 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\7\:Ab \4\:Ab) resistor r=45 c=0
Rx13 (\11\:Ybint \2\:Ybint) resistor r=45 c=0
Rx14 (\14\:Ybint \5\:Ybint) resistor r=45 c=0
Rx9 (\6\:GatedVSS \2\:GatedVSS) resistor r=45 c=0
Rx11 (\23\:GatedVSS GatedVSS) resistor r=45 c=0
Rx5 (\13\:ison \7\:ison) resistor r=45 c=0
Rx6 (\16\:ison \12\:ison) resistor r=45 c=0
NM2 (\15\:GatedVSS \10\:A \11\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
NM4 (\16\:VSS \4\:ISO \14\:ison VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
NM1 (\5\:Yint Ab \11\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(3)
NM0 (\7\:Ybint \1\:A \11\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(3)
NM3 (\3\:GatedVSS ison \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(4)
mn0 (\6\:Y \3\:Ybint \9\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 \
        scb=0.0115056 scc=0.000581193 m=(1)
PM0 (\12\:Ybint \4\:Yint \14\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=25.7248 \
        scb=0.0268097 scc=0.00266528 m=(1)
PM5 (\17\:ison \1\:ISO \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=20.8995 \
        scb=0.0240463 scc=0.00131353 m=(1)
PM1 (\11\:Yint Ybint \12\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.55891 \
        scb=0.00285886 scc=1.84381e-05 m=(1)
PM4 (\4\:Y \8\:ison \3\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=16.2275 \
        scb=0.0146219 scc=0.00118588 m=(1)
mp0 (\8\:Y \6\:Ybint \10\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=28.6983 \
        scb=0.0316799 scc=0.00295254 m=(1)
ends LSLH_ISOH_X1_FROM_OFF
// End of subcircuit definition.

// Generated for: spectre (Mar 22 13:12:25 2012 )
// Library name: gsclib045
// Cell name: LSLH_ISOH_X1_TO_ON
// View name: extracted

simulator lang=spectre

subckt LSLH_ISOH_X1_TO_ON A ExtVDD ISO VDD VSS Y
PM2 (\7\:Ab \9\:A \4\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.5188 \
        scb=0.0293267 scc=0.00134465 m=(1)
C1 (ExtVDD VSS) capacitor c=7.29961e-17
C2 (A VSS) capacitor c=1.99572e-17
C3 (VDD VSS) capacitor c=4.31842e-16
C4 (ISO VSS) capacitor c=3.21905e-17
C5 (Y VSS) capacitor c=2.95348e-17
C6 (Yint VSS) capacitor c=3.70706e-17
C7 (Ab VSS) capacitor c=1.51785e-16
C8 (ison VSS) capacitor c=3.65414e-17
C9 (Ybint VSS) capacitor c=3.01294e-17
C10 (GatedVSS VSS) capacitor c=3.33903e-17
C11 (\6\:Ybint VSS) capacitor c=2.83141e-17
C12 (\1\:ISO VSS) capacitor c=2.51396e-17
C13 (\4\:Yint VSS) capacitor c=2.71694e-17
C14 (\9\:A VSS) capacitor c=4.8361e-17
C15 (\3\:Ybint VSS) capacitor c=2.54544e-17
C16 (\1\:A VSS) capacitor c=2.06608e-16
C17 (\4\:ISO VSS) capacitor c=5.60413e-17
C18 (\10\:A VSS) capacitor c=2.43985e-17
C19 (\5\:Ybint VSS) capacitor c=7.50637e-18
C20 (\2\:Y VSS) capacitor c=3.31945e-17
C21 (\1\:Y VSS) capacitor c=3.15728e-17
C22 (\2\:Ybint VSS) capacitor c=2.3087e-17
C23 (\11\:ison VSS) capacitor c=3.16958e-17
C24 (\6\:ison VSS) capacitor c=1.87229e-17
C25 (\3\:ISO VSS) capacitor c=5.38132e-17
C26 (\3\:Yint VSS) capacitor c=2.38248e-17
C27 (\2\:GatedVSS VSS) capacitor c=2.78849e-17
C28 (\4\:Ab VSS) capacitor c=6.12182e-17
C29 (\6\:A VSS) capacitor c=2.15167e-17
C30 (\6\:Y VSS) capacitor c=7.52282e-17
C31 (\1\:VDD VSS) capacitor c=9.07492e-17
C32 (\3\:Y VSS) capacitor c=4.54625e-17
C33 (\9\:VDD VSS) capacitor c=8.48827e-17
C34 (\3\:VDD VSS) capacitor c=5.16424e-17
C35 (\11\:Yint VSS) capacitor c=5.05695e-17
C36 (\16\:ison VSS) capacitor c=3.87391e-17
C37 (\11\:VDD VSS) capacitor c=4.73879e-17
C38 (\11\:Ybint VSS) capacitor c=8.50936e-17
C39 (\13\:VDD VSS) capacitor c=5.23297e-17
C40 (\7\:Ab VSS) capacitor c=8.57483e-17
C41 (\4\:ExtVDD VSS) capacitor c=3.51603e-17
C42 (\9\:Y VSS) capacitor c=3.8892e-17
C43 (\9\:GatedVSS VSS) capacitor c=9.87313e-17
C44 (\3\:GatedVSS VSS) capacitor c=3.3296e-16
C45 (\5\:Yint VSS) capacitor c=1.88049e-16
C46 (\13\:ison VSS) capacitor c=5.13771e-17
C47 (\10\:Ab VSS) capacitor c=6.32406e-17
C48 (\15\:GatedVSS VSS) capacitor c=1.08963e-16
C49 (ExtVDD VSS) capacitor c=3.05604e-17
C50 (VDD VSS) capacitor c=4.60997e-17
C51 (\2\:Yint VSS) capacitor c=2.44813e-17
C52 (\4\:A VSS) capacitor c=1.63454e-16
C53 (\5\:A VSS) capacitor c=2.18669e-17
C54 (\2\:ison VSS) capacitor c=1.47068e-16
C55 (\4\:Ybint VSS) capacitor c=8.78967e-18
C56 (\11\:A VSS) capacitor c=3.51059e-17
C57 (\3\:ExtVDD VSS) capacitor c=1.93201e-17
C58 (\9\:Ab VSS) capacitor c=1.05196e-16
C59 (\8\:Yint VSS) capacitor c=3.85689e-17
C60 (\6\:ISO VSS) capacitor c=8.20041e-18
C61 (\8\:ISO VSS) capacitor c=2.55656e-17
C62 (\12\:ison VSS) capacitor c=5.89189e-17
C63 (\13\:Yint VSS) capacitor c=3.31167e-17
C64 (\15\:ison VSS) capacitor c=4.82261e-17
C65 (\6\:GatedVSS VSS) capacitor c=8.06675e-17
C66 (\5\:Y VSS) capacitor c=4.68364e-17
C67 (\11\:GatedVSS VSS) capacitor c=4.05809e-16
C68 (\14\:GatedVSS VSS) capacitor c=1.86961e-16
C69 (\23\:GatedVSS VSS) capacitor c=1.03766e-16
C70 (\7\:Ybint VSS) capacitor c=5.50844e-17
C71 (\8\:Ybint VSS) capacitor c=1.7983e-16
C72 (\10\:Ybint VSS) capacitor c=6.22475e-17
C73 (\8\:Y VSS) capacitor c=6.63373e-17
C74 (\5\:VDD VSS) capacitor c=1.16935e-16
C75 (\7\:VDD VSS) capacitor c=2.84313e-17
C76 (\8\:VDD VSS) capacitor c=1.74788e-17
Rk4 (\3\:ExtVDD ExtVDD) resistor r=0.02416 c=0
Rk3 (ExtVDD \3\:ExtVDD) resistor r=0.03424 c=0
Rk5 (\3\:ExtVDD \5\:ExtVDD) resistor r=0.2891 c=0
Rk1 (\11\:A A) resistor r=0.02681 c=0
Rk58 (VDD VDD) resistor r=0.3051 c=0
Rk53 (\2\:VDD \4\:VDD) resistor r=0.5807 c=0
Rk54 (\4\:VDD \5\:VDD) resistor r=0.2409 c=0
Rk55 (\5\:VDD \7\:VDD) resistor r=0.2187 c=0
Rk57 (\8\:VDD VDD) resistor r=0.1845 c=0
Rk56 (\7\:VDD \8\:VDD) resistor r=0.03916 c=0
Rk59 (\5\:VDD \10\:VDD) resistor r=0.562 c=0
Rk60 (\8\:VDD \12\:VDD) resistor r=0.2568 c=0
Rk61 (VDD \14\:VDD) resistor r=0.2861 c=0
Rk11 (\5\:ISO ISO) resistor r=0.004142 c=0
Rk12 (ISO \6\:ISO) resistor r=0.004142 c=0
Rk13 (\5\:ISO \6\:ISO) resistor r=0.007378 c=0
Rk15 (\6\:ISO \8\:ISO) resistor r=0.02927 c=0
Rk14 (\7\:ISO \8\:ISO) resistor r=0.004142 c=0
Rk48 (VSS VSS) resistor r=0.3173 c=0
Rk63 (VSS VSS) resistor r=0.2779 c=0
Rk41 (\2\:VSS \3\:VSS) resistor r=0.1326 c=0
Rk47 (\8\:VSS VSS) resistor r=0.2457 c=0
Rk46 (\3\:VSS \8\:VSS) resistor r=0.05391 c=0
Rk49 (VSS \9\:VSS) resistor r=0.07649 c=0
Rk62 (\17\:VSS VSS) resistor r=0.59 c=0
Rk64 (VSS \18\:VSS) resistor r=0.1158 c=0
Rk22 (\4\:Y \5\:Y) resistor r=0.2698 c=0
Rk38 (Y \7\:Y) resistor r=0.2113 c=0
Rk39 (\7\:Y \8\:Y) resistor r=0.519 c=0
Rk40 (Y \10\:Y) resistor r=0.2219 c=0
Rk9 (\5\:Yint \8\:Yint) resistor r=0.2013 c=0
Rk17 (\12\:Yint \13\:Yint) resistor r=0.2047 c=0
Rk6 (\8\:Ab \9\:Ab) resistor r=0.6836 c=0
Rk7 (\9\:Ab \11\:Ab) resistor r=0.4474 c=0
Rk16 (\12\:ison \14\:ison) resistor r=0.3822 c=0
Rk18 (\15\:ison \17\:ison) resistor r=0.2458 c=0
Rk32 (\7\:Ybint \8\:Ybint) resistor r=0.3016 c=0
Rk34 (\8\:Ybint \10\:Ybint) resistor r=0.152 c=0
Rk35 (\10\:Ybint \12\:Ybint) resistor r=0.5783 c=0
Rk20 (\3\:GatedVSS \6\:GatedVSS) resistor r=1.1462 c=0
Rk23 (\10\:GatedVSS \11\:GatedVSS) resistor r=0.6487 c=0
Rk26 (\11\:GatedVSS \14\:GatedVSS) resistor r=0.3563 c=0
Rk27 (\14\:GatedVSS \16\:GatedVSS) resistor r=0.7661 c=0
Rk31 (\14\:GatedVSS \23\:GatedVSS) resistor r=0.8124 c=0
Rl21 (\4\:A \9\:A) resistor r=239.672 c=0
Rl16 (\4\:A \1\:A) resistor r=494.483 c=0
Rl22 (\5\:A \10\:A) resistor r=59.022 c=0
Rl18 (\5\:A \6\:A) resistor r=46.4864 c=0
Rl17 (\5\:A \4\:A) resistor r=192.732 c=0
Rl2 (\1\:ISO \2\:ISO) resistor r=56.5719 c=0
Rl4 (\2\:ISO \4\:ISO) resistor r=193.396 c=0
Rl3 (\2\:ISO \3\:ISO) resistor r=0.6051 c=0
Rl33 (\1\:Y \2\:Y) resistor r=105.578 c=0
Rl10 (\2\:Yint Yint) resistor r=148.662 c=0
Rl12 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl11 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl7 (Ab \4\:Ab) resistor r=178.013 c=0
Rl23 (\2\:ison ison) resistor r=105.555 c=0
Rl32 (\2\:ison \11\:ison) resistor r=115.398 c=0
Rl27 (\2\:ison \6\:ison) resistor r=4.4574 c=0
Rl13 (\2\:Ybint Ybint) resistor r=58.6635 c=0
Rl36 (\4\:Ybint \6\:Ybint) resistor r=53.5603 c=0
Rl34 (\4\:Ybint \3\:Ybint) resistor r=53.5603 c=0
Rl35 (\4\:Ybint \5\:Ybint) resistor r=2.0166 c=0
Rl1 (\2\:GatedVSS GatedVSS) resistor r=171.167 c=0
Rz15 (\9\:Y \10\:Y) resistor r=37.5 c=0
Rz2 (\11\:Ab \10\:Ab) resistor r=75 c=0
Rz5 (\14\:ison \13\:ison) resistor r=75 c=0
Rz8 (\10\:GatedVSS \9\:GatedVSS) resistor r=37.5 c=0
Rz9 (\16\:GatedVSS \15\:GatedVSS) resistor r=75 c=0
Ry1 (\4\:ExtVDD \5\:ExtVDD) resistor r=62 c=0
Ry13 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry14 (\3\:VDD \4\:VDD) resistor r=62 c=0
Ry15 (\9\:VDD \10\:VDD) resistor r=20.6667 c=0
Ry16 (\11\:VDD \12\:VDD) resistor r=62 c=0
Ry17 (\13\:VDD \14\:VDD) resistor r=62 c=0
Ry8 (\2\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry9 (\3\:VSS \1\:VSS) resistor r=15.5 c=0
Ry11 (\8\:VSS \1\:VSS) resistor r=62 c=0
Ry12 (\9\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry18 (\17\:VSS \16\:VSS) resistor r=7.75 c=0
Ry19 (\18\:VSS \16\:VSS) resistor r=5.1667 c=0
Ry5 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry7 (\6\:Y \7\:Y) resistor r=20.6667 c=0
Ry3 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry2 (\8\:Ab \7\:Ab) resistor r=62 c=0
Ry4 (\17\:ison \16\:ison) resistor r=62 c=0
Ry6 (\12\:Ybint \11\:Ybint) resistor r=62 c=0
Rx1 (\11\:A \6\:A) resistor r=45 c=0
Rx4 (\3\:ISO \7\:ISO) resistor r=45 c=0
Rx9 (\2\:Y \5\:Y) resistor r=45 c=0
Rx13 (\1\:Y \8\:Y) resistor r=45 c=0
Rx3 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx6 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\9\:Ab \4\:Ab) resistor r=45 c=0
Rx5 (\12\:ison \6\:ison) resistor r=45 c=0
Rx7 (\15\:ison \11\:ison) resistor r=45 c=0
Rx11 (\7\:Ybint \5\:Ybint) resistor r=45 c=0
Rx12 (\10\:Ybint \2\:Ybint) resistor r=45 c=0
Rx8 (\6\:GatedVSS \2\:GatedVSS) resistor r=45 c=0
Rx10 (\23\:GatedVSS GatedVSS) resistor r=45 c=0
NM2 (\15\:GatedVSS \10\:A \10\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM4 (\3\:VSS \4\:ISO \13\:ison VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.9e-07 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
NM1 (\5\:Yint Ab \11\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
NM0 (\8\:Ybint \1\:A \11\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(3)
NM3 (\3\:GatedVSS \2\:ison \3\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=4.081e-14 ps=8.4e-07 pd=8.45e-07 nrd=1.16667 \
        nrs=1.16667 sa=2.71058e-07 sb=7.55e-07 sd=160n sca=9.89531 \
        scb=0.00874901 scc=0.000299334 m=(4)
mn0 (\9\:Y \3\:Ybint \9\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=17.5885 \
        scb=0.0172826 scc=0.00162584 m=(1)
PM0 (\11\:Ybint \4\:Yint \13\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.7575 \
        scb=0.0246973 scc=0.00196249 m=(1)
PM5 (\16\:ison \1\:ISO \11\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=8.91404 \
        scb=0.00557767 scc=4.88511e-05 m=(1)
PM1 (\11\:Yint Ybint \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.79344 \
        scb=0.00330563 scc=2.63533e-05 m=(1)
PM4 (\3\:Y ison \9\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=15.2536 \
        scb=0.0136406 scc=0.00109716 m=(1)
mp0 (\6\:Y \6\:Ybint \1\:VDD VDD) g45p1svt w=(3.9e-07) l=4.5e-08 nf=1 \
        as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=26.5171 \
        scb=0.0296471 scc=0.00227211 m=(1)
ends LSLH_ISOH_X1_TO_ON
// End of subcircuit definition.

// Generated for: spectre (May  3 15:34:56 2012 )
// Library name: gsclib045
// Cell name: LSLH_ISOL_X1_FROM_OFF
// View name: extracted

simulator lang=spectre

subckt LSLH_ISOL_X1_FROM_OFF A ExtVDD ISO VDD VSS Y
PM2 (\9\:Ab \9\:A \3\:VDD VDD) g45p1svt w=(2.15e-07) l=4.5e-08 nf=1 \
        as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.3577 \
        scb=0.0261982 scc=0.000929898 m=(1)
C1 (VDD VSS) capacitor c=1.19985e-16
C2 (ISO VSS) capacitor c=5.02994e-17
C3 (ExtVDD VSS) capacitor c=3.21139e-16
C4 (A VSS) capacitor c=3.56374e-17
C5 (Y VSS) capacitor c=2.82711e-17
C6 (Yint VSS) capacitor c=3.30193e-17
C7 (Ab VSS) capacitor c=1.80498e-16
C8 (Ybint VSS) capacitor c=2.96519e-17
C9 (GatedVSS VSS) capacitor c=3.415e-17
C10 (ison VSS) capacitor c=1.25689e-16
C11 (\6\:Ybint VSS) capacitor c=4.35956e-17
C12 (\8\:ison VSS) capacitor c=3.59119e-17
C13 (\1\:ISO VSS) capacitor c=4.7206e-17
C14 (\4\:Yint VSS) capacitor c=2.39721e-17
C15 (\9\:A VSS) capacitor c=4.07131e-17
C16 (\3\:Ybint VSS) capacitor c=2.89525e-17
C17 (\1\:A VSS) capacitor c=2.31435e-16
C18 (\4\:ISO VSS) capacitor c=2.32851e-17
C19 (\10\:A VSS) capacitor c=2.86029e-17
C20 (\7\:Ybint VSS) capacitor c=3.51273e-17
C21 (\5\:Ybint VSS) capacitor c=1.08786e-17
C22 (\1\:ExtVDD VSS) capacitor c=1.31781e-17
C23 (\2\:ExtVDD VSS) capacitor c=1.62965e-17
C24 (\2\:Ybint VSS) capacitor c=2.20258e-17
C25 (\12\:ison VSS) capacitor c=3.07911e-17
C26 (\7\:ison VSS) capacitor c=2.04814e-17
C27 (\3\:ISO VSS) capacitor c=1.57032e-17
C28 (\3\:Yint VSS) capacitor c=2.18969e-17
C29 (\2\:GatedVSS VSS) capacitor c=3.13977e-17
C30 (\4\:Ab VSS) capacitor c=8.793e-17
C31 (\6\:A VSS) capacitor c=1.71941e-17
C32 (\1\:Y VSS) capacitor c=7.6615e-17
C33 (\8\:ExtVDD VSS) capacitor c=5.84354e-17
C34 (\19\:Ybint VSS) capacitor c=5.2531e-17
C35 (\3\:ExtVDD VSS) capacitor c=3.9269e-17
C36 (\11\:ExtVDD VSS) capacitor c=1.16167e-16
C37 (\11\:Yint VSS) capacitor c=6.28448e-17
C38 (\17\:ison VSS) capacitor c=7.14438e-17
C39 (\13\:Ybint VSS) capacitor c=8.94932e-17
C40 (\6\:ExtVDD VSS) capacitor c=1.23141e-16
C41 (\13\:ExtVDD VSS) capacitor c=1.31953e-16
C42 (\9\:Ab VSS) capacitor c=6.05239e-17
C43 (\3\:VDD VSS) capacitor c=3.74334e-17
C44 (\3\:Y VSS) capacitor c=6.84677e-17
C45 (\15\:GatedVSS VSS) capacitor c=3.53273e-16
C46 (\8\:Ybint VSS) capacitor c=2.0644e-16
C47 (\3\:GatedVSS VSS) capacitor c=3.889e-16
C48 (\5\:Yint VSS) capacitor c=1.94884e-16
C49 (\14\:ison VSS) capacitor c=4.3387e-17
C50 (\11\:Ab VSS) capacitor c=3.993e-17
C51 (\8\:GatedVSS VSS) capacitor c=9.94193e-17
C52 (\2\:ISO VSS) capacitor c=3.41477e-17
C53 (\2\:Yint VSS) capacitor c=1.77081e-17
C54 (VDD VSS) capacitor c=4.49321e-16
C55 (\4\:A VSS) capacitor c=1.63953e-16
C56 (\6\:ison VSS) capacitor c=1.744e-17
C57 (\4\:Ybint VSS) capacitor c=1.88877e-17
C58 (\12\:A VSS) capacitor c=1.99809e-17
C59 (\7\:Ab VSS) capacitor c=1.00778e-17
C60 (\8\:Ab VSS) capacitor c=5.62182e-17
C61 (\7\:ISO VSS) capacitor c=4.21617e-17
C62 (\8\:Yint VSS) capacitor c=3.95666e-17
C63 (\13\:ison VSS) capacitor c=3.52373e-17
C64 (\16\:ison VSS) capacitor c=6.77462e-17
C65 (\13\:Yint VSS) capacitor c=5.45128e-17
C66 (\7\:GatedVSS VSS) capacitor c=1.65735e-16
C67 (\14\:GatedVSS VSS) capacitor c=7.69898e-17
C68 (\5\:ExtVDD VSS) capacitor c=1.17314e-16
C69 (\18\:GatedVSS VSS) capacitor c=1.1666e-16
C70 (\10\:ExtVDD VSS) capacitor c=1.63485e-17
C71 (\15\:ExtVDD VSS) capacitor c=7.97873e-18
C72 (\17\:ExtVDD VSS) capacitor c=7.35163e-17
C73 (\12\:Ybint VSS) capacitor c=9.66361e-17
C74 (\15\:Ybint VSS) capacitor c=5.25426e-17
C75 (\18\:Ybint VSS) capacitor c=7.30783e-17
C76 (\2\:VDD VSS) capacitor c=1.54487e-17
Rk68 (VDD VDD) resistor r=0.6016 c=0
Rk69 (VDD \2\:VDD) resistor r=0.2049 c=0
Rk70 (\2\:VDD \4\:VDD) resistor r=0.3311 c=0
Rk12 (ISO \7\:ISO) resistor r=0.03636 c=0
Rk11 (\6\:ISO \7\:ISO) resistor r=0.004571 c=0
Rk37 (ExtVDD ExtVDD) resistor r=0.003814 c=0
Rk26 (\4\:ExtVDD \5\:ExtVDD) resistor r=0.2489 c=0
Rk27 (\5\:ExtVDD \7\:ExtVDD) resistor r=0.9975 c=0
Rk31 (\9\:ExtVDD \10\:ExtVDD) resistor r=0.3122 c=0
Rk32 (\10\:ExtVDD \12\:ExtVDD) resistor r=0.2603 c=0
Rk33 (\12\:ExtVDD \14\:ExtVDD) resistor r=0.9909 c=0
Rk34 (\10\:ExtVDD \15\:ExtVDD) resistor r=0.1174 c=0
Rk36 (\17\:ExtVDD ExtVDD) resistor r=0.001907 c=0
Rk35 (\10\:ExtVDD \17\:ExtVDD) resistor r=0.192 c=0
Rk60 (VSS VSS) resistor r=0.1479 c=0
Rk59 (VSS VSS) resistor r=0.001 c=0
Rk47 (\2\:VSS \3\:VSS) resistor r=0.2463 c=0
Rk49 (\4\:VSS VSS) resistor r=0.3449 c=0
Rk48 (\3\:VSS \4\:VSS) resistor r=0.1477 c=0
Rk51 (\5\:VSS VSS) resistor r=0.1797 c=0
Rk50 (VSS \5\:VSS) resistor r=0.3947 c=0
Rk52 (\3\:VSS \7\:VSS) resistor r=0.2267 c=0
Rk58 (\10\:VSS VSS) resistor r=0.08092 c=0
Rk53 (\9\:VSS \10\:VSS) resistor r=0.2537 c=0
Rk61 (VSS \15\:VSS) resistor r=0.1135 c=0
Rk63 (\16\:VSS VSS) resistor r=0.1699 c=0
Rk62 (\15\:VSS \16\:VSS) resistor r=0.1822 c=0
Rk67 (\15\:VSS \24\:VSS) resistor r=0.2098 c=0
Rk1 (A \11\:A) resistor r=0.008212 c=0
Rk3 (\12\:A A) resistor r=0.005208 c=0
Rk2 (\11\:A \12\:A) resistor r=0.004045 c=0
Rk45 (Y \2\:Y) resistor r=0.02239 c=0
Rk46 (\2\:Y \4\:Y) resistor r=0.6563 c=0
Rk14 (\5\:Yint \8\:Yint) resistor r=0.2147 c=0
Rk18 (\12\:Yint \13\:Yint) resistor r=0.2964 c=0
Rk6 (\7\:Ab \8\:Ab) resistor r=0.04277 c=0
Rk7 (\8\:Ab \10\:Ab) resistor r=0.4555 c=0
Rk8 (\8\:Ab \12\:Ab) resistor r=0.1628 c=0
Rk40 (\8\:Ybint \12\:Ybint) resistor r=0.1765 c=0
Rk41 (\12\:Ybint \14\:Ybint) resistor r=0.6333 c=0
Rk42 (\8\:Ybint \15\:Ybint) resistor r=0.2894 c=0
Rk44 (\18\:Ybint \20\:Ybint) resistor r=0.4523 c=0
Rk21 (\3\:GatedVSS \7\:GatedVSS) resistor r=0.4737 c=0
Rk22 (\7\:GatedVSS \9\:GatedVSS) resistor r=0.6286 c=0
Rk25 (\7\:GatedVSS \14\:GatedVSS) resistor r=0.7591 c=0
Rk29 (\15\:GatedVSS \18\:GatedVSS) resistor r=1.4392 c=0
Rk16 (\13\:ison \15\:ison) resistor r=0.254 c=0
Rk17 (\16\:ison \18\:ison) resistor r=0.4254 c=0
Rl2 (\1\:ISO \2\:ISO) resistor r=178.431 c=0
Rl4 (\2\:ISO \4\:ISO) resistor r=67.6128 c=0
Rl3 (\2\:ISO \3\:ISO) resistor r=5.1123 c=0
Rl23 (\1\:ExtVDD \2\:ExtVDD) resistor r=160.124 c=0
Rl21 (\4\:A \9\:A) resistor r=144.481 c=0
Rl16 (\4\:A \1\:A) resistor r=617.212 c=0
Rl22 (\5\:A \10\:A) resistor r=84.6812 c=0
Rl18 (\5\:A \6\:A) resistor r=5.1123 c=0
Rl17 (\5\:A \4\:A) resistor r=20.529 c=0
Rl10 (\2\:Yint Yint) resistor r=105.33 c=0
Rl12 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl11 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl7 (Ab \4\:Ab) resistor r=300.227 c=0
Rl38 (\7\:Ybint \6\:Ybint) resistor r=141.321 c=0
Rl13 (\2\:Ybint Ybint) resistor r=72.3229 c=0
Rl37 (\4\:Ybint \6\:Ybint) resistor r=132.409 c=0
Rl35 (\4\:Ybint \3\:Ybint) resistor r=67.6128 c=0
Rl36 (\4\:Ybint \5\:Ybint) resistor r=3.5166 c=0
Rl1 (\2\:GatedVSS GatedVSS) resistor r=169.462 c=0
Rl30 (ison \8\:ison) resistor r=150.846 c=0
Rl28 (\6\:ison ison) resistor r=72.842 c=0
Rl34 (\6\:ison \12\:ison) resistor r=116.573 c=0
Rl29 (\6\:ison \7\:ison) resistor r=51.6001 c=0
Rz15 (\7\:VSS \6\:VSS) resistor r=37.5 c=0
Rz19 (\24\:VSS \23\:VSS) resistor r=75 c=0
Rz14 (\3\:Y \4\:Y) resistor r=37.5 c=0
Rz1 (\12\:Ab \11\:Ab) resistor r=75 c=0
Rz6 (\9\:GatedVSS \8\:GatedVSS) resistor r=75 c=0
Rz4 (\15\:ison \14\:ison) resistor r=75 c=0
Ry19 (\3\:VDD \4\:VDD) resistor r=62 c=0
Ry4 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry5 (\6\:ExtVDD \7\:ExtVDD) resistor r=62 c=0
Ry6 (\8\:ExtVDD \9\:ExtVDD) resistor r=20.6667 c=0
Ry7 (\11\:ExtVDD \12\:ExtVDD) resistor r=62 c=0
Ry8 (\13\:ExtVDD \14\:ExtVDD) resistor r=62 c=0
Ry12 (\2\:VSS \1\:VSS) resistor r=12.4 c=0
Ry13 (\4\:VSS \1\:VSS) resistor r=20.6667 c=0
Ry14 (\5\:VSS \1\:VSS) resistor r=5.1667 c=0
Ry15 (\9\:VSS \8\:VSS) resistor r=12.4 c=0
Ry16 (\10\:VSS \8\:VSS) resistor r=15.5 c=0
Ry18 (\16\:VSS \8\:VSS) resistor r=5.6364 c=0
Ry11 (\1\:Y \2\:Y) resistor r=20.6667 c=0
Ry3 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry1 (\10\:Ab \9\:Ab) resistor r=62 c=0
Ry9 (\14\:Ybint \13\:Ybint) resistor r=62 c=0
Ry10 (\20\:Ybint \19\:Ybint) resistor r=62 c=0
Ry2 (\18\:ison \17\:ison) resistor r=62 c=0
Rx3 (\3\:ISO \6\:ISO) resistor r=45 c=0
Rx9 (\2\:ExtVDD \5\:ExtVDD) resistor r=45 c=0
Rx11 (\1\:ExtVDD \15\:ExtVDD) resistor r=45 c=0
Rx1 (\11\:A \6\:A) resistor r=45 c=0
Rx4 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx7 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\7\:Ab \4\:Ab) resistor r=45 c=0
Rx12 (\12\:Ybint \2\:Ybint) resistor r=45 c=0
Rx13 (\15\:Ybint \5\:Ybint) resistor r=45 c=0
Rx14 (\18\:Ybint \7\:Ybint) resistor r=45 c=0
Rx8 (\14\:GatedVSS GatedVSS) resistor r=45 c=0
Rx10 (\18\:GatedVSS \2\:GatedVSS) resistor r=45 c=0
Rx5 (\13\:ison \7\:ison) resistor r=45 c=0
Rx6 (\16\:ison \12\:ison) resistor r=45 c=0
NM2 (\8\:GatedVSS \10\:A \11\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=10.9472 \
        scb=0.0104991 scc=0.000356047 m=(1)
NM4 (\23\:VSS \4\:ISO \14\:ison VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=7.688 scb=0.00504888 \
        scc=6.29443e-05 m=(1)
NM1 (\5\:Yint Ab \3\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=4.16e-14 ad=3.987e-14 ps=8.4e-07 pd=8.2667e-07 nrd=1.16667 \
        nrs=1.16667 sa=5.5e-07 sb=7.55e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(3)
NM0 (\8\:Ybint \1\:A \3\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=3.987e-14 ad=4.16e-14 ps=8.2667e-07 pd=8.4e-07 nrd=1.16667 \
        nrs=1.16667 sa=7.55e-07 sb=5.5e-07 sd=160n sca=16.3874 \
        scb=0.0162972 scc=0.00139495 m=(3)
NM3 (\15\:GatedVSS ison \10\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 \
        nf=1 as=4.16e-14 ad=3.9e-14 ps=8.4e-07 pd=8.2e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=7.55e-07 sd=160n sca=8.97712 \
        scb=0.00732387 scc=0.000196032 m=(4)
mn0 (\3\:Y \3\:Ybint \6\:VSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
        as=3.64e-14 ad=3.64e-14 ps=8e-07 pd=8e-07 nrd=1.16667 nrs=1.16667 \
        sa=1.4e-07 sb=1.4e-07 sd=160n sca=11.8713 scb=0.0115056 \
        scc=0.000581193 m=(1)
PM0 (\13\:Ybint \4\:Yint \13\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=22.4693 \
        scb=0.0242319 scc=0.00195457 m=(1)
PM5 (\17\:ison \1\:ISO \6\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=19.098 \
        scb=0.0218837 scc=0.000978838 m=(1)
PM1 (\11\:Yint Ybint \11\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=6.50531 \
        scb=0.00284023 scc=1.84334e-05 m=(1)
PM3 (\19\:Ybint \8\:ison \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) \
        l=4.5e-08 nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 \
        nrd=1.16667 nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.4753 \
        scb=0.0115009 scc=0.000423885 m=(1)
mp0 (\1\:Y \6\:Ybint \8\:ExtVDD ExtVDD) g45p1svt w=(3.9e-07) l=4.5e-08 \
        nf=1 as=5.46e-14 ad=5.46e-14 ps=1.06e-06 pd=1.06e-06 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=19.532 scb=0.0217466 \
        scc=0.00133989 m=(1)
ends LSLH_ISOL_X1_FROM_OFF
// End of subcircuit definition.

// Generated for: spectre (May  3 15:35:43 2012 )
// Library name: gsclib045
// Cell name: LSLH_ISOL_X1_TO_ON
// View name: extracted

simulator lang=spectre

subckt LSLH_ISOL_X1_TO_ON A ExtVDD ISO VDD VSS Y
PM2 (\7\:Ab \9\:A \3\:ExtVDD ExtVDD) g45p1svt w=(2.15e-07) l=4.5e-08 \
        nf=1 as=3.01e-14 ad=3.01e-14 ps=7.1e-07 pd=7.1e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=24.1303 \
        scb=0.0290334 scc=0.0012433 m=(1)
C1 (VDD VSS) capacitor c=4.46449e-16
C2 (A VSS) capacitor c=2.183e-17
C3 (ISO VSS) capacitor c=3.21905e-17
C4 (ExtVDD VSS) capacitor c=1.45443e-16
C5 (Yint VSS) capacitor c=3.76828e-17
C6 (Ab VSS) capacitor c=1.51784e-16
C7 (ison VSS) capacitor c=3.68731e-17
C8 (Ybint VSS) capacitor c=2.67741e-17
C9 (GatedVSS VSS) capacitor c=3.41015e-17
C10 (\6\:Ybint VSS) capacitor c=4.27577e-17
C11 (\1\:ISO VSS) capacitor c=2.47254e-17
C12 (\4\:Yint VSS) capacitor c=2.69811e-17
C13 (\9\:A VSS) capacitor c=4.84255e-17
C14 (\3\:Ybint VSS) capacitor c=2.60416e-17
C15 (\1\:A VSS) capacitor c=2.04761e-16
C16 (\4\:ISO VSS) capacitor c=5.60413e-17
C17 (\10\:A VSS) capacitor c=2.4381e-17
C18 (\7\:Ybint VSS) capacitor c=3.76917e-17
C19 (\5\:Ybint VSS) capacitor c=6.58921e-18
C20 (\2\:Ybint VSS) capacitor c=2.57056e-17
C21 (\11\:ison VSS) capacitor c=3.39387e-17
C22 (\6\:ison VSS) capacitor c=1.87229e-17
C23 (\3\:ISO VSS) capacitor c=5.34582e-17
C24 (\3\:Yint VSS) capacitor c=2.38248e-17
C25 (\2\:GatedVSS VSS) capacitor c=2.73843e-17
C26 (\4\:Ab VSS) capacitor c=6.13072e-17
C27 (\6\:A VSS) capacitor c=2.2138e-17
C28 (\3\:Y VSS) capacitor c=1.15551e-16
C29 (\1\:VDD VSS) capacitor c=7.24739e-17
C30 (\19\:Ybint VSS) capacitor c=4.07411e-17
C31 (\8\:VDD VSS) capacitor c=4.40829e-17
C32 (\10\:VDD VSS) capacitor c=3.37893e-17
C33 (\11\:Yint VSS) capacitor c=5.49889e-17
C34 (\16\:ison VSS) capacitor c=3.87391e-17
C35 (\12\:VDD VSS) capacitor c=4.73106e-17
C36 (\12\:Ybint VSS) capacitor c=8.48956e-17
C37 (\14\:VDD VSS) capacitor c=5.21309e-17
C38 (\7\:Ab VSS) capacitor c=8.86566e-17
C39 (\3\:ExtVDD VSS) capacitor c=3.52654e-17
C40 (\1\:Y VSS) capacitor c=5.31053e-17
C41 (\15\:GatedVSS VSS) capacitor c=3.25999e-16
C42 (\3\:GatedVSS VSS) capacitor c=3.63234e-16
C43 (\5\:Yint VSS) capacitor c=1.88031e-16
C44 (\13\:ison VSS) capacitor c=5.13771e-17
C45 (\10\:Ab VSS) capacitor c=6.62522e-17
C46 (\8\:GatedVSS VSS) capacitor c=1.1072e-16
C47 (VDD VSS) capacitor c=4.62579e-17
C48 (\2\:Yint VSS) capacitor c=2.4569e-17
C49 (\4\:A VSS) capacitor c=1.62446e-16
C50 (\5\:A VSS) capacitor c=2.30364e-17
C51 (\2\:ison VSS) capacitor c=1.55321e-16
C52 (\4\:Ybint VSS) capacitor c=1.41669e-17
C53 (\12\:A VSS) capacitor c=4.13711e-17
C54 (\9\:Ab VSS) capacitor c=1.05527e-16
C55 (\8\:Yint VSS) capacitor c=3.85438e-17
C56 (\6\:ISO VSS) capacitor c=8.20041e-18
C57 (\8\:ISO VSS) capacitor c=2.44957e-17
C58 (\12\:ison VSS) capacitor c=5.89189e-17
C59 (\13\:Yint VSS) capacitor c=3.31167e-17
C60 (\15\:ison VSS) capacitor c=4.54437e-17
C61 (\7\:GatedVSS VSS) capacitor c=1.86961e-16
C62 (\14\:GatedVSS VSS) capacitor c=1.03735e-16
C63 (\18\:GatedVSS VSS) capacitor c=8.06668e-17
C64 (\8\:Ybint VSS) capacitor c=4.50395e-17
C65 (\9\:Ybint VSS) capacitor c=1.73325e-16
C66 (\11\:Ybint VSS) capacitor c=6.3548e-17
C67 (\18\:Ybint VSS) capacitor c=3.06398e-17
C68 (\3\:VDD VSS) capacitor c=6.45309e-17
C69 (\4\:VDD VSS) capacitor c=2.48979e-17
C70 (\6\:VDD VSS) capacitor c=2.84313e-17
C71 (\7\:VDD VSS) capacitor c=1.69236e-17
Rk49 (VDD VDD) resistor r=0.3048 c=0
Rk44 (\2\:VDD \3\:VDD) resistor r=0.4462 c=0
Rk45 (\3\:VDD \4\:VDD) resistor r=0.1593 c=0
Rk46 (\4\:VDD \6\:VDD) resistor r=0.2185 c=0
Rk48 (\7\:VDD VDD) resistor r=0.1844 c=0
Rk47 (\6\:VDD \7\:VDD) resistor r=0.03913 c=0
Rk50 (\3\:VDD \9\:VDD) resistor r=0.2979 c=0
Rk51 (\4\:VDD \11\:VDD) resistor r=0.2408 c=0
Rk52 (\7\:VDD \13\:VDD) resistor r=0.2566 c=0
Rk53 (VDD \15\:VDD) resistor r=0.2859 c=0
Rk61 (VSS VSS) resistor r=0.317 c=0
Rk42 (VSS VSS) resistor r=0.2777 c=0
Rk41 (\4\:VSS VSS) resistor r=0.5895 c=0
Rk40 (\2\:VSS \4\:VSS) resistor r=0.4817 c=0
Rk43 (VSS \5\:VSS) resistor r=0.1157 c=0
Rk54 (\7\:VSS \8\:VSS) resistor r=0.1325 c=0
Rk60 (\13\:VSS VSS) resistor r=0.2455 c=0
Rk59 (\8\:VSS \13\:VSS) resistor r=0.05387 c=0
Rk62 (VSS \14\:VSS) resistor r=0.07642 c=0
Rk4 (A \12\:A) resistor r=0.01985 c=0
Rk3 (\12\:A \13\:A) resistor r=0.002167 c=0
Rk13 (\5\:ISO ISO) resistor r=0.00414 c=0
Rk14 (ISO \6\:ISO) resistor r=0.00414 c=0
Rk15 (\5\:ISO \6\:ISO) resistor r=0.007372 c=0
Rk17 (\6\:ISO \8\:ISO) resistor r=0.02924 c=0
Rk16 (\7\:ISO \8\:ISO) resistor r=0.00414 c=0
Rk5 (ExtVDD ExtVDD) resistor r=0.01053 c=0
Rk6 (ExtVDD \2\:ExtVDD) resistor r=0.00653 c=0
Rk7 (\2\:ExtVDD \4\:ExtVDD) resistor r=0.3218 c=0
Rk38 (\2\:Y Y) resistor r=0.3888 c=0
Rk39 (Y \4\:Y) resistor r=0.2155 c=0
Rk11 (\5\:Yint \8\:Yint) resistor r=0.2012 c=0
Rk19 (\12\:Yint \13\:Yint) resistor r=0.2046 c=0
Rk8 (\8\:Ab \9\:Ab) resistor r=0.6832 c=0
Rk9 (\9\:Ab \11\:Ab) resistor r=0.4471 c=0
Rk18 (\12\:ison \14\:ison) resistor r=0.382 c=0
Rk20 (\15\:ison \17\:ison) resistor r=0.2456 c=0
Rk31 (\8\:Ybint \9\:Ybint) resistor r=0.2475 c=0
Rk33 (\9\:Ybint \11\:Ybint) resistor r=0.1519 c=0
Rk34 (\11\:Ybint \13\:Ybint) resistor r=0.5779 c=0
Rk37 (\18\:Ybint \20\:Ybint) resistor r=0.2764 c=0
Rk23 (\3\:GatedVSS \7\:GatedVSS) resistor r=0.356 c=0
Rk24 (\7\:GatedVSS \9\:GatedVSS) resistor r=0.7656 c=0
Rk27 (\7\:GatedVSS \14\:GatedVSS) resistor r=0.8118 c=0
Rk29 (\15\:GatedVSS \18\:GatedVSS) resistor r=1.1454 c=0
Rl21 (\4\:A \9\:A) resistor r=239.672 c=0
Rl16 (\4\:A \1\:A) resistor r=494.483 c=0
Rl22 (\5\:A \10\:A) resistor r=59.022 c=0
Rl18 (\5\:A \6\:A) resistor r=46.4864 c=0
Rl17 (\5\:A \4\:A) resistor r=192.732 c=0
Rl2 (\1\:ISO \2\:ISO) resistor r=56.5719 c=0
Rl4 (\2\:ISO \4\:ISO) resistor r=193.396 c=0
Rl3 (\2\:ISO \3\:ISO) resistor r=0.6051 c=0
Rl10 (\2\:Yint Yint) resistor r=148.662 c=0
Rl12 (\2\:Yint \4\:Yint) resistor r=41.7694 c=0
Rl11 (\2\:Yint \3\:Yint) resistor r=34.5546 c=0
Rl7 (Ab \4\:Ab) resistor r=178.013 c=0
Rl23 (\2\:ison ison) resistor r=165.444 c=0
Rl32 (\2\:ison \11\:ison) resistor r=115.398 c=0
Rl27 (\2\:ison \6\:ison) resistor r=4.4574 c=0
Rl36 (\7\:Ybint \6\:Ybint) resistor r=173.707 c=0
Rl13 (\2\:Ybint Ybint) resistor r=58.6635 c=0
Rl35 (\4\:Ybint \6\:Ybint) resistor r=90.3549 c=0
Rl33 (\4\:Ybint \3\:Ybint) resistor r=52.8549 c=0
Rl34 (\4\:Ybint \5\:Ybint) resistor r=1.2666 c=0
Rl1 (\2\:GatedVSS GatedVSS) resistor r=171.167 c=0
Rz15 (\2\:VSS \1\:VSS) resistor r=37.5 c=0
Rz14 (\1\:Y \2\:Y) resistor r=37.5 c=0
Rz2 (\11\:Ab \10\:Ab) resistor r=75 c=0
Rz5 (\14\:ison \13\:ison) resistor r=75 c=0
Rz7 (\9\:GatedVSS \8\:GatedVSS) resistor r=75 c=0
Ry10 (\1\:VDD \2\:VDD) resistor r=20.6667 c=0
Ry11 (\8\:VDD \9\:VDD) resistor r=62 c=0
Ry12 (\10\:VDD \11\:VDD) resistor r=62 c=0
Ry13 (\12\:VDD \13\:VDD) resistor r=62 c=0
Ry14 (\14\:VDD \15\:VDD) resistor r=62 c=0
Ry8 (\4\:VSS \3\:VSS) resistor r=7.75 c=0
Ry9 (\5\:VSS \3\:VSS) resistor r=5.1667 c=0
Ry15 (\7\:VSS \6\:VSS) resistor r=20.6667 c=0
Ry17 (\8\:VSS \6\:VSS) resistor r=15.5 c=0
Ry18 (\13\:VSS \6\:VSS) resistor r=62 c=0
Ry19 (\14\:VSS \6\:VSS) resistor r=5.1667 c=0
Ry1 (\3\:ExtVDD \4\:ExtVDD) resistor r=62 c=0
Ry7 (\3\:Y \4\:Y) resistor r=20.6667 c=0
Ry3 (\12\:Yint \11\:Yint) resistor r=62 c=0
Ry2 (\8\:Ab \7\:Ab) resistor r=62 c=0
Ry4 (\17\:ison \16\:ison) resistor r=62 c=0
Ry5 (\13\:Ybint \12\:Ybint) resistor r=62 c=0
Ry6 (\20\:Ybint \19\:Ybint) resistor r=62 c=0
Rx1 (\13\:A \6\:A) resistor r=45 c=0
Rx4 (\3\:ISO \7\:ISO) resistor r=45 c=0
Rx3 (\8\:Yint \3\:Yint) resistor r=45 c=0
Rx6 (\13\:Yint Yint) resistor r=45 c=0
Rx2 (\9\:Ab \4\:Ab) resistor r=45 c=0
Rx5 (\12\:ison \6\:ison) resistor r=45 c=0
Rx7 (\15\:ison \11\:ison) resistor r=45 c=0
Rx10 (\8\:Ybint \5\:Ybint) resistor r=45 c=0
Rx11 (\11\:Ybint \2\:Ybint) resistor r=45 c=0
Rx12 (\18\:Ybint \7\:Ybint) resistor r=45 c=0
Rx8 (\14\:GatedVSS GatedVSS) resistor r=45 c=0
Rx9 (\18\:GatedVSS \2\:GatedVSS) resistor r=45 c=0
NM2 (\8\:GatedVSS \10\:A \10\:Ab VSS) g45n1svt w=(1.45e-07) l=4.5e-08 \
        nf=1 as=2.03e-14 ad=2.03e-14 ps=5.7e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=1.4e-07 sd=160n sca=12.9138 \
        scb=0.0133404 scc=0.000640143 m=(1)
NM4 (\8\:VSS \4\:ISO \13\:ison VSS) g45n1svt w=(1.45e-07) l=4.5e-08 nf=1 \
        as=4.365e-14 ad=2.03e-14 ps=9e-07 pd=5.7e-07 nrd=1.16667 \
        nrs=1.16667 sa=1.4e-07 sb=9.9e-07 sd=160n sca=9.00614 \
        scb=0.00733335 scc=0.00015104 m=(1)
NM1 (\5\:Yint Ab \3\:GatedVSS VSS) g45n1svt w=(2.6e-07) l=4.5e-08 nf=1 \
